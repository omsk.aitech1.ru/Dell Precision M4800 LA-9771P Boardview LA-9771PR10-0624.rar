# Allegro board LA-9771PR10-0624.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USBP2-: length 15.9
  TOP w0.102: UH1.A36 24.54,104.47 24.52,104.47 23.9,105.09 23.27,105.09 23.05,105.32 19.95,105.32 19.56,105.7 19.21,105.7 18.61,105.1 v3(18.06,104.54) 16.91,103.4 16.25,103.4 14.85,104.8 14.85,105.97 14.73,106.09 14.27,106.09 14.17,105.99 14.17,105.83 14.37,105.63 14.37,105.48 14.26,105.37 14.11,105.37 13.89,105.6 JIO1.20
USBP3+: length 104.6
  TOP w0.102: v1(21.19,104.66) 21.69,104.16 22.35,104.16 22.5,104.32 23.91,104.32 24.36,103.87 24.77,103.87 25.07,103.57 UH1.C34
  IN4 w0.117: v1(21.19,104.66) 21.09,104.66 21,104.75 21,105.05 21.19,105.24 21.52,105.24 21.62,105.14 22.02,105.14 22.12,105.24 22.47,105.24 22.58,105.14 22.98,105.14 23.08,105.24 23.51,105.24 23.92,105.65 23.92,108.45 27.57,112.1 36.39,112.1 37.38,113.1 37.38,113.98 36.47,114.89 36.47,115.51 39.18,118.23 39.18,118.9 38.62,119.46 38.62,121.24 38.47,121.39 38.47,126.91 38.79,127.23 38.79,128.25 40.77,130.23 43.13,130.23 44.24,131.34 47.14,131.34 47.61,130.87 56.36,130.87 58.26,132.77 61.36,132.77 63.49,130.64 89.6,130.64 91.09,129.14 91.7,129.14 91.8,129.05 v1(91.8,128.97)
  BOTTOM w0.102: v1(91.8,128.97) 91.8,129.09 91.86,129.14 92.13,129.14 92.25,129.03 92.25,128.34 91.98,128.08 91.98,127.37 91.91,127.29 91.78,127.29 91.7,127.21 JDOCK1.72
USBP3-: length 104.7
  TOP w0.102: UH1.A34 24.62,103.57 24.53,103.66 24.27,103.66 23.82,104.1 22.59,104.1 22.44,103.95 21.6,103.95 21.29,104.25 20.68,104.25 20.58,104.35 v1(20.58,104.66)
  IN4 w0.117: v1(91.8,129.55) 91.63,129.38 91.19,129.38 89.7,130.87 63.59,130.87 61.46,133.01 58.16,133.01 56.26,131.11 47.71,131.11 47.24,131.58 44.14,131.58 43.03,130.47 40.67,130.47 38.55,128.35 38.55,127.32 38.24,127.01 38.24,121.3 38.39,121.14 38.39,119.37 38.95,118.81 38.95,118.33 36.23,115.61 36.23,114.79 37.14,113.88 37.14,113.19 36.29,112.34 27.47,112.34 23.68,108.54 23.68,105.75 23.41,105.48 21.09,105.48 20.76,105.15 20.76,104.83 v1(20.58,104.66)
  BOTTOM w0.102: JDOCK1.74 92.2,127.99 92.46,128.26 92.46,129.12 92.22,129.36 91.99,129.36 v1(91.8,129.55)
USBP4+: length 188.6
  TOP w0.102: UH1.D33 25.51,103.16 25.22,102.87 24.95,102.87 24.76,103.06 24.27,103.06 23.69,103.63 23.14,103.63 22.73,103.22 20.97,103.22 20.64,102.9 v1(20.64,102.79)
  IN4 w0.117: v1(20.64,102.79) 20.46,102.98 20.46,103.32 20.05,103.73 20.05,106.03 20.23,106.22 20.23,107 20.48,107.25 20.48,109.41 20.1,109.79 20.1,113.88 20.68,114.46 20.68,114.89 21.32,115.53 21.32,116.42 25.13,120.23 25.13,121.75 26.55,123.18 26.55,126.64 29.08,129.17 29.08,132.18 31.2,134.3 31.2,136.1 38.26,143.17 39.61,143.17 42.07,145.63 42.86,145.63 44.94,147.71 44.94,151.01 47.74,153.81 49.36,153.81 50.18,154.62 50.18,154.96 51.19,155.97 55.48,155.97 56.93,157.41 61.78,157.41 64.7,160.34 69.58,160.34 73,163.76 77.57,163.76 78.06,164.25 94.76,164.25 98.81,168.3 105.49,168.3 106.85,169.66 116.29,169.66 116.79,169.16 121.23,169.16 122.37,170.3 133.07,170.3 137.85,165.51 137.85,162.94 140.06,160.73 140.06,156.92 142.51,154.47 143.3,154.47 143.73,154.9 143.73,155.86 143.33,156.26 142.77,156.26 v1(142.58,156.45)
  BOTTOM w0.102: v1(142.58,156.45) 142.78,156.25 143.02,156.25 143.3,156.54 JMINI4.38
USBP4-: length 188.5
  TOP w0.102: UH1.B33 24.94,103.18 24.86,103.26 24.37,103.26 23.78,103.85 23.05,103.85 22.64,103.44 20.88,103.44 20.65,103.21 20,103.21 19.9,103.11 19.9,102.88 v1(19.98,102.79)
  IN4 w0.117: v1(142.58,155.84) 142.58,155.97 142.64,156.03 143.23,156.03 143.49,155.76 143.49,155 143.2,154.71 142.6,154.71 141.77,155.54 141.77,155.7 141.5,155.97 141.34,155.97 141.1,156.22 141.1,156.37 140.82,156.64 140.67,156.64 140.3,157.01 140.3,160.83 138.09,163.04 138.09,165.61 133.17,170.53 122.27,170.53 121.13,169.4 116.88,169.4 116.39,169.89 106.76,169.89 105.4,168.53 98.72,168.53 94.67,164.48 77.96,164.48 77.47,163.99 72.9,163.99 69.48,160.57 64.6,160.57 61.68,157.65 56.83,157.65 55.38,156.2 51.09,156.2 49.95,155.06 49.95,154.72 49.27,154.04 47.64,154.04 44.71,151.11 44.71,147.81 42.76,145.87 41.97,145.87 39.51,143.4 38.16,143.4 30.96,136.2 30.96,134.4 28.85,132.28 28.85,129.27 26.32,126.74 26.32,123.27 24.89,121.85 24.89,120.33 21.08,116.52 21.08,115.63 20.45,114.99 20.45,114.56 19.86,113.98 19.86,109.69 20.24,109.31 20.24,107.35 20,107.1 20,106.31 19.81,106.13 19.81,103.63 20.22,103.22 20.22,102.88 20.14,102.79 v1(19.98,102.79)
  BOTTOM w0.102: v1(142.58,155.84) 142.77,156.04 143.01,156.04 143.3,155.74 JMINI4.36
USBP5+: length 270.9
  TOP w0.102: v1(27.48,102.9) 27.16,102.58 UH1.G31
  IN3 w0.127: v1(254.03,70.7) 254.2,70.86 254.64,70.86 255.02,71.24 255.02,76.52 250.65,80.89 250.01,80.89 v1(249.85,81.06)
  IN4 w0.089: 30.49,101.8 30.22,101.8 29.49,102.53 27.85,102.53 v1(27.48,102.9)
  IN4 w0.117: 30.49,101.8 36.59,101.8 37.26,102.47 41.42,102.47 41.68,102.2 43.16,102.2 43.24,102.13 47.54,102.13 50.4,104.99 50.4,105.42 52.36,107.38 53.32,107.38 54.92,105.78 64.26,105.78 66.49,108 79.53,108 80.38,108.86 81.72,108.86 83.25,107.33 115.28,107.33 116.92,105.68 163.28,105.68 165.13,103.83 176.91,103.83 181.38,99.36 181.95,99.36 187.42,93.89 193.15,93.89 205.52,81.52 205.52,77.81 209.49,73.85 210.76,73.85 211.44,73.17 211.44,72.65 212.55,71.54 216.3,71.54 218.74,73.98 220.89,73.98 222.16,75.25 222.89,75.25 225.31,77.66 225.31,80.88 227.14,82.72 232.94,82.72 236.67,78.99 239.87,78.99 240.24,79.36 242.58,79.36 242.95,78.99 246.38,78.99 248.27,80.88 249.67,80.88 v1(249.85,81.06)
  BOTTOM w0.102: v1(254.03,70.7) 253.84,70.89 253.61,70.89 253.33,70.6 JMINI2.38
USBP5-: length 270.8
  TOP w0.102: UH1.F31 26.56,102.64 v1(26.83,102.9)
  IN3 w0.127: v1(249.85,80.47) 250.01,80.64 250.55,80.64 254.78,76.41 254.78,71.35 254.54,71.11 254.2,71.11 v1(254.03,71.28)
  IN4 w0.089: v1(26.83,102.9) 27.2,102.53 27.58,102.53 27.77,102.33 29.41,102.33 30.16,101.58 30.44,101.58 30.47,101.56 30.49,101.56
  IN4 w0.117: 30.49,101.56 36.69,101.56 37.36,102.23 41.32,102.23 41.59,101.97 43.06,101.97 43.14,101.89 47.64,101.89 50.64,104.89 50.64,105.33 52.46,107.15 53.22,107.15 54.83,105.54 64.36,105.54 66.59,107.77 79.63,107.77 80.48,108.62 81.62,108.62 83.15,107.09 115.18,107.09 116.82,105.45 163.18,105.45 165.03,103.59 176.81,103.59 181.28,99.13 181.85,99.13 187.32,93.65 193.05,93.65 205.28,81.42 205.28,77.72 209.39,73.61 210.66,73.61 211.2,73.07 211.2,72.56 212.45,71.31 216.4,71.31 218.84,73.75 220.99,73.75 222.26,75.01 222.99,75.01 225.54,77.56 225.54,80.79 227.24,82.48 232.85,82.48 236.58,78.76 239.97,78.76 240.34,79.12 242.48,79.12 242.85,78.76 246.47,78.76 248.37,80.65 249.67,80.65 v1(249.85,80.47)
  BOTTOM w0.102: v1(254.03,71.28) 253.86,71.11 253.63,71.11 253.33,71.4 JMINI2.36
USBP6+: length 79.3
  TOP w0.102: v1(28.68,102.9) 28.95,102.62 UH1.L31
  IN4 w0.089: v1(28.68,102.9) 28.63,102.86 28.56,102.86 28.45,102.97 28.45,103.07 28.32,103.19 28.32,103.27 28.36,103.31 29.48,103.31 29.5,103.28 29.52,103.28
  IN4 w0.117: 29.52,103.28 29.9,103.28 30.24,103.62 30.24,104.04 30.34,104.14 30.34,104.54 30.24,104.63 30.24,104.98 30.34,105.08 30.34,105.48 30.24,105.57 30.24,105.83 31.99,107.58 40.47,107.58 42.96,110.07 45.21,110.07 46.05,110.91 46.47,110.91 47.99,112.42 49.75,112.42 51.34,114.01 52.39,114.01 58.44,120.05 58.44,121.16 66.8,129.53 87.79,129.53 88.89,128.43 90.23,128.43 90.41,128.25 90.41,128 90.28,127.87 v1(90.07,127.87)
  BOTTOM w0.102: v1(90.07,127.87) 90.33,127.61 90.33,127.34 90.2,127.21 JDOCK1.66
USBP6-: length 79.4
  TOP w0.102: UH1.K31 28.36,102.62 v1(28.08,102.9)
  IN4 w0.089: v1(28.08,102.9) 28.13,102.96 28.13,103.35 28.29,103.5 29.48,103.5 29.5,103.52 29.52,103.52
  IN4 w0.117: 29.52,103.52 29.81,103.52 30.01,103.72 30.01,105.93 31.9,107.82 40.37,107.82 42.86,110.31 45.11,110.31 45.95,111.15 46.38,111.15 47.89,112.66 49.65,112.66 51.24,114.25 52.29,114.25 58.2,120.15 58.2,121.26 66.7,129.77 87.88,129.77 88.99,128.66 90.33,128.66 90.64,128.35 90.64,128.03 v1(90.8,127.87)
  BOTTOM w0.102: JDOCK1.68 90.7,127.2 90.55,127.36 90.55,127.62 v1(90.8,127.87)
USBP7+: length 121.6
  TOP w0.102: JUSH1.3 50.05,7.49 49.91,7.64 49.91,12.89 48.73,14.08 48.73,16.98 v1(48.93,17.18) ; UH1.H29 27.76,101.49 v1(27.4,101.85)
  IN1 w0.089: v1(27.4,101.85) 27.17,101.62 27.17,101.44 26.97,101.24 26.17,101.24 26.15,101.22 26.12,101.22
  IN1 w0.117: v1(48.93,17.18) 48.73,17.38 48.73,21.08 45.71,24.1 45.71,25.99 45.09,26.61 45.09,28.26 46.07,29.23 46.07,32.69 39.16,39.6 39.16,47.74 41.93,50.51 41.93,54.57 39.61,56.89 39.61,66.22 37.55,68.27 37.55,76.87 38.14,77.46 38.14,80.58 38.32,80.76 38.32,82.51 37.46,83.37 37.46,83.78 37.01,84.22 36.1,84.22 35.31,85.01 26.5,85.01 25.74,85.76 23.07,85.76 22.02,86.82 22.02,87.83 22.36,88.17 22.61,88.17 23.43,88.99 23.43,90.13 24.39,91.1 24.39,98.21 25.47,99.29 25.47,100.94 25.75,101.22 26.12,101.22
USBP7-: length 121.7
  TOP w0.102: v1(48.29,17.18) 48.51,16.97 48.51,13.99 49.69,12.8 49.69,7.65 49.55,7.51 JUSH1.2 ; UH1.G29 27.16,101.44 v1(26.75,101.85)
  IN1 w0.089: v1(26.75,101.85) 26.98,101.62 26.98,101.52 26.89,101.43 26.17,101.43 26.15,101.45 26.09,101.45 26.08,101.46 26.07,101.46
  IN1 w0.117: v1(48.29,17.18) 48.5,17.38 48.5,20.98 45.47,24 45.47,25.89 44.86,26.51 44.86,28.35 45.84,29.33 45.84,32.59 38.92,39.5 38.92,47.84 41.69,50.61 41.69,54.47 39.37,56.79 39.37,66.12 37.32,68.17 37.32,76.97 37.91,77.56 37.91,80.68 38.08,80.86 38.08,82.41 37.22,83.27 37.22,83.68 36.91,83.98 36,83.98 35.21,84.77 26.4,84.77 25.64,85.52 22.97,85.52 21.78,86.72 21.78,87.93 22.26,88.41 22.52,88.41 23.19,89.08 23.19,90.23 24.16,91.19 24.16,98.31 25.24,99.38 25.24,101.04 25.66,101.46 26.07,101.46
USBP8+: length 101.2
  TOP w0.102: L51.1 29.65,164.73 29.42,164.96 29.42,165.06 29.31,165.17 29.08,165.17 28.79,164.88 28.79,164.45 28.86,164.37 v1(29.16,164.37) ; v1(23.08,102.79) 23.48,102.4 23.87,102.4 23.92,102.45 24.77,102.45 24.97,102.66 25.44,102.66 UH1.C32
  IN4 w0.117: v1(23.08,102.79) 23.11,102.79 23.3,102.61 23.3,102.45 23.11,102.26 22.76,102.26 22.65,102.37 22.25,102.37 22.13,102.26 21.78,102.26 21.67,102.37 21.27,102.37 21.15,102.26 19.71,102.26 18.96,103.01 18.96,105.98 19.5,106.52 19.5,107.31 19.69,107.5 19.69,109.15 19.36,109.48 19.36,114.18 19.95,114.77 19.95,115.2 20.56,115.82 20.56,116.71 24.39,120.53 24.39,122.11 25.69,123.4 25.69,126.82 28.35,129.48 28.35,132.49 28.78,132.92 28.78,133.84 29.73,134.78 29.73,136.29 30.4,136.96 30.98,136.96 37.92,143.9 39.25,143.9 43.82,148.47 43.82,151.01 45.2,152.39 45.2,154.73 44.16,155.76 44.16,157.57 44.89,158.3 44.89,161.23 41.41,164.7 34.68,164.7 33.38,163.41 29.12,163.41 28.74,163.79 28.74,164.45 28.81,164.53 29,164.53 v1(29.16,164.37)
USBP8-: length 101.1
  TOP w0.102: L51.4 29.56,165.58 29.37,165.39 28.99,165.39 28.57,164.97 28.57,164.64 v1(28.3,164.37) ; v1(23.67,102.79) 23.67,102.79 23.22,103.24 23.22,103.34 23.33,103.44 23.61,103.44 24.14,102.91 24.14,102.73 24.2,102.66 24.54,102.66 UH1.A32
  IN4 w0.117: v1(23.67,102.79) 23.53,102.66 23.53,102.35 23.2,102.02 19.61,102.02 18.72,102.91 18.72,106.08 19.26,106.62 19.26,107.41 19.46,107.6 19.46,109.06 19.13,109.39 19.13,114.28 19.71,114.87 19.71,115.3 20.33,115.91 20.33,116.8 24.16,120.63 24.16,122.21 25.45,123.5 25.45,126.92 28.11,129.57 28.11,132.58 28.54,133.02 28.54,133.93 29.49,134.88 29.49,136.39 30.3,137.2 30.88,137.2 37.82,144.14 39.15,144.14 43.59,148.57 43.59,151.11 44.96,152.48 44.96,154.63 43.93,155.66 43.93,157.67 44.65,158.4 44.65,161.13 41.32,164.47 34.78,164.47 33.48,163.17 29.02,163.17 28.5,163.69 28.5,164.18 v1(28.3,164.37)
USBP8_D+: length 17.7
  TOP w0.102: JESA1.3 42.27,170.52 42.37,170.62 42.37,170.99 42.07,171.29 38.07,171.29 37.54,170.76 37.54,168.17 34.39,165.03 33.77,165.03 33.66,164.93 D73.3 32.81,165.03 32.29,165.03 31.99,164.73 L51.2
USBP8_D-: length 17.7
  TOP w0.102: L51.3 31.95,165.58 32.29,165.24 32.81,165.24 D73.2 33.66,165.35 33.77,165.24 34.3,165.24 37.32,168.26 37.32,170.85 37.98,171.51 42.16,171.51 42.59,171.08 42.59,170.62 42.69,170.52 JESA1.2
USBP9+: length 14.8
  TOP w0.102: UH1.C30 25.43,102.04 24.97,102.04 24.77,102.25 24.46,102.25 24.39,102.17 22.51,102.17 v1(21.89,102.79) ; v1(14.56,103.81) 14.37,104 14.16,104 13.96,103.8 JIO1.26
  IN3 w0.127: v1(21.89,102.79) 21.73,102.64 21.73,102.31 21.4,101.97 18.83,101.97 18.53,102.27 16.14,102.27 15.03,103.39 15.03,103.84 14.89,103.98 14.73,103.98 v1(14.56,103.81)
USBP9-: length 14.7
  TOP w0.102: v1(21.23,102.79) 21.14,102.71 21.14,102.5 21.27,102.37 22,102.37 22.42,101.96 24.62,101.96 UH1.A30 ; v1(14.56,104.4) 14.37,104.21 14.17,104.21 13.98,104.4 JIO1.24
  IN3 w0.127: v1(14.56,104.4) 14.56,104.28 14.61,104.23 14.99,104.23 15.27,103.95 15.27,103.49 16.24,102.52 18.63,102.52 18.93,102.22 19.3,102.22 19.4,102.32 19.83,102.32 19.94,102.22 20.32,102.22 20.42,102.32 20.85,102.32 20.95,102.22 21.29,102.22 21.49,102.41 21.49,102.66 21.36,102.79 v1(21.23,102.79)
USBP10+: length 13.6
  TOP w0.102: UH1.D29 25.49,101.53 25.21,101.25 24.96,101.25 24.77,101.43 v3(21.46,101.43) 20.4,101.43 19.76,102.08 19.48,102.08 19.26,102.3 18.37,102.3 18.36,102.28 17.76,102.28 17.75,102.3 15.76,102.3 15.46,102 JIO1.32
USBP10-: length 13.5
  TOP w0.102: UH1.B29 25.08,101.66 25,101.74 24.88,101.74 24.77,101.64 24.4,101.64 24.39,101.65 24.07,101.65 23.98,101.74 23.63,101.74 23.54,101.65 23.23,101.65 23.15,101.74 22.79,101.74 22.7,101.65 21.74,101.65 21.72,101.66 21.19,101.66 21.18,101.65 20.49,101.65 19.85,102.3 19.57,102.3 19.35,102.51 v3(18.08,102.51) 15.67,102.51 15.37,102.22 14.36,102.22 14.28,102.3 14.28,102.75 14.19,102.85 14.03,102.85 13.95,102.78 13.95,102.7 13.85,102.6 JIO1.30
USBP12+: length 63.7
  TOP w0.102: v1(26.73,100.87) 26.56,100.7 UH1.F26 ; v1(58.91,131.61) 59.14,131.61 59.25,131.72 59.25,131.98 58.77,132.46 L10.4
  IN4 w0.089: 28.66,106.99 28.66,106.98 28.64,106.97 28.64,106.76 28.84,106.56 28.84,104.63 28.44,104.22 26.45,104.22 26.23,104.44 25.61,104.44 25.24,104.06 25.24,100.9 25.72,100.42 26.89,100.42 27.11,100.64 27.11,101.03 27.06,101.08 26.82,101.08 26.73,100.99 v1(26.73,100.87)
  IN4 w0.117: v1(58.91,131.61) 58.91,131.42 59.06,131.27 59.22,131.27 59.33,131.38 59.33,131.83 59.13,132.03 58.58,132.03 57.64,131.1 57.64,120.3 52.09,114.75 49.26,114.75 46.2,111.69 45.78,111.69 44.92,110.83 38.31,110.83 36.13,108.65 31.71,108.65 31.07,108.01 29.34,108.01 28.66,107.33 28.66,106.99
USBP12-: length 63.6
  TOP w0.102: L10.1 59.62,132.39 59.47,132.24 59.47,131.85 59.71,131.61 v1(59.77,131.61) ; UH1.G26 27.16,100.53 v1(27.5,100.87)
  IN4 w0.089: 28.42,106.99 28.42,106.97 28.43,106.97 28.43,106.68 28.63,106.47 28.63,104.71 28.35,104.43 26.54,104.43 26.32,104.65 25.52,104.65 25.03,104.15 25.03,100.81 25.63,100.21 26.98,100.21 27.32,100.55 27.32,100.79 27.4,100.87 v1(27.5,100.87)
  IN4 w0.117: v1(59.77,131.61) 59.7,131.61 59.57,131.74 59.57,131.93 59.23,132.27 58.48,132.27 57.41,131.19 57.41,120.4 51.99,114.98 49.16,114.98 46.1,111.92 45.68,111.92 44.82,111.07 38.21,111.07 36.03,108.88 31.61,108.88 30.97,108.25 29.25,108.25 28.42,107.42 28.42,106.99
USBP12_D+: length 25.9
  TOP w0.102: L10.3 58.77,134.89 59.11,135.23 59.11,136.97 60.8,138.67 60.8,145.91 60,146.71 58.86,146.71 58.55,147.01 56.88,147.01 56.14,147.75 56.14,149.16 55.71,149.59 55.69,149.59 55.29,149.99 55.29,150.01 55.23,150.07 v3(53.68,150.07) 53.21,150.07 52.23,149.09 51.1,149.09 50.95,148.95 JLVDS1.14
USBP12_D-: length 26.3
  TOP w0.102: JLVDS1.13 50.95,149.45 51.09,149.31 52.14,149.31 53.12,150.29 53.3,150.29 53.31,150.3 53.97,150.3 53.98,150.29 55.32,150.29 v3(55.66,149.95) 55.86,149.74 56.36,149.25 56.36,147.84 56.97,147.23 58.64,147.23 58.95,146.92 60.09,146.92 61.02,146 61.02,138.58 59.32,136.88 59.32,135.2 59.62,134.9 L10.2
USBP13+: length 1.1
  TOP w0.102: v1(27.47,99.81) 27.16,99.5 UH1.G24
  BOTTOM w0.089: T167.1 27.67,100.01 v1(27.47,99.81)
USBP13-: length 1.3
  TOP w0.102: v1(26.88,99.81) 26.56,99.49 UH1.F24
  BOTTOM w0.089: v1(26.88,99.81) 26.63,99.55 T166.1
USBRBIAS: length 2
  TOP w0.305: UH1.K24 28.7,99.75 28.7,99.77 v1(28.66,99.81) 28.7,99.85 28.7,100.02 28.36,100.37 UH1.K26
  BOTTOM w0.381: v1(28.66,99.81) 28.66,99.12 RH187.1
USH_DET#: length 144.1
  TOP w0.102: UH1.F13 26.56,94.55 26.78,94.34 v1(26.78,94.34) ; JUSH1.20 v1(58.55,5.67)
  IN1 w0.109: v1(58.55,5.67) 57.26,4.39 49.57,4.39 43.67,10.29 43.67,16.94 42.12,18.49 42.12,24.52 38.95,27.68 38.95,30.68 35.43,34.2 35.43,48.23 38.95,51.75 38.95,53.3 36.6,55.65 36.6,65 34.44,67.16 34.44,77.99 32.77,79.67 29.47,79.67 28.97,80.16 24.63,80.16 24.14,80.66 21.41,80.66 15.97,86.09 15.11,86.09 13.12,88.09 13.12,91.6 13.47,91.95 13.47,96.59 v1(14.28,97.41)
  BOTTOM w0.102: RPH9.8 14.21,97.33 v1(14.28,97.41) 14.68,97.41 15.88,96.2 16.87,96.2 17.86,95.21 v2(18.91,95.21) 19.38,95.21 20.37,94.22 24.7,94.22 25.08,94.6 26.42,94.6 26.68,94.34 v1(26.78,94.34)
USH_PWR_ON: length 346.5
  TOP w0.102: v1(52.93,17.27) 53.27,17.27 T140.1
  IN1 w0.109: v1(52.93,17.27) 55.24,17.27 60.45,12.06 72.84,12.06 75.61,14.83 75.61,18 84.35,26.74 89.21,26.74 89.55,26.4 104.78,26.4 107.85,23.32 132.25,23.32 132.85,22.73 194.71,22.73 196.13,24.14 200.92,24.14 201.53,23.53 221.84,23.53 236.67,38.36 250.38,38.36 254.01,42 264.67,42 269.9,47.23 269.9,69.37 260.6,78.67 255.19,78.67 251.23,74.72 245.67,74.72 244.74,73.79 234.02,73.79 233.37,73.14 231.57,73.14 230.92,73.79 227.75,73.79 226.9,72.94 226.62,72.94 225.63,71.94 222.91,71.94 221.4,73.44 216.49,73.44 215.92,74.01 210.26,74.01 209.66,73.42 v1(208.92,73.42)
  BOTTOM w0.102: U46.A18 212.08,78.02 211.91,77.86 208.77,77.86 207.86,78.78 206.36,78.78 205.65,78.06 205.65,75.45 206.64,74.46 206.64,73.75 206.97,73.42 v1(208.92,73.42)
USH_PWR_STATE#: length 337.3
  TOP w0.102: JUSH1.16 v1(56.55,7.71)
  IN1 w0.109: v1(56.55,7.71) 72.67,7.71 74.35,9.39 74.35,11.21 77.83,14.68 77.83,15.13 79.83,17.13 79.83,19.04 84.07,23.28 84.07,23.69 84.44,24.06 103.4,24.06 106.74,20.71 131.1,20.71 131.68,20.13 199.86,20.13 200.64,20.91 222.94,20.91 237.17,35.14 250.83,35.14 252.03,36.34 257.38,36.34 257.59,36.55 258.54,36.55 258.67,36.43 262.8,36.43 272.73,46.35 272.73,70.24 261.6,81.37 252.99,81.37 250.72,79.09 243.2,79.09 242.68,79.61 239.83,79.61 238.07,77.85 233.08,77.85 227.54,83.39 227.54,83.93 225.21,86.27 221.75,86.27 220.63,87.39 220.63,87.62 219.62,88.63 214.66,88.63 v1(214.13,88.1)
  BOTTOM w0.102: v1(214.13,88.1) 214.13,88.07 214.28,88.22 R102.2 214.59,88.56 214.59,87.18 214.67,87.1 U46.A34 ; v2(57.15,7.39) 56.83,7.71 v1(56.55,7.71)
USH_SMBCLK: length 278.4
  TOP w0.102: v1(51.01,5.62) 51.19,5.8 51.19,5.93 51.05,6.07 JUSH1.5
  IN1 w0.109: v1(51.01,5.62) 51.19,5.8 51.19,6.16 50.79,6.55 49.3,6.55 44.98,10.86 44.98,17.57 43.33,19.22 43.33,25.02 40.19,28.16 40.19,31.17 36.78,34.58 36.78,47.86 40.17,51.25 40.17,53.81 37.85,56.13 37.85,65.5 35.76,67.58 35.76,78.44 35.19,79.01 35.19,80.1 33.03,82.26 26.57,82.26 26.2,82.63 24.96,82.63 24.78,82.81 22.59,82.81 21.82,83.58 21.82,83.63 21.37,84.08 20.76,84.08 19.38,85.46 19.38,85.84 17.77,87.46 16.53,87.46 15.67,88.31 15.67,89.06 16.19,89.57 16.19,90.38 14.56,92.01 14.56,92.74 14.69,92.88 14.69,94.18 15.3,94.78 15.3,96.1 16.56,97.36 16.56,97.88 16.29,98.16 16.29,99.05 15.22,100.11 15.22,104.51 15.91,105.19 15.91,105.62 16.41,106.12 16.41,108.94 19.41,111.95 19.41,119.87 19.04,120.25 18.83,120.25 18.19,120.89 18.19,121.9 19.37,123.08 25.23,123.08 27.13,124.98 27.13,128.15 29.69,130.71 29.69,133.71 29.17,134.23 29.17,142.56 28.03,143.69 28.03,145.51 27.46,146.08 27.46,153.25 28.2,153.98 28.2,158.38 27.56,159.02 27.56,160.05 28.03,160.52 29.81,160.52 30.43,161.15 34.4,161.15 37.15,163.9 42.18,163.9 46.26,159.82 46.76,159.82 47.64,158.94 50.96,158.94 52.76,157.14 55.67,157.14 56.42,157.9 62.59,157.9 64.96,160.27 78.22,160.27 78.84,160.89 84.64,160.89 85.33,161.59 99.31,161.59 100.12,162.41 100.12,162.76 v1(100.66,163.29)
  BOTTOM w0.102: v1(100.66,163.29) 100.26,162.9 100.26,162.53 100.5,162.3 U51.A50 ; v1(51.01,5.62) 51.19,5.45 51.19,4.91 R589.2
USH_SMBDAT: length 276.1
  TOP w0.102: v1(51.6,5.62) 51.41,5.81 51.41,5.93 51.55,6.06 JUSH1.6
  IN1 w0.109: v1(99.81,160.46) 99.81,160.79 99.25,161.35 85.43,161.35 84.74,160.66 78.94,160.66 78.31,160.03 65.06,160.03 62.69,157.66 56.52,157.66 55.77,156.91 52.66,156.91 50.86,158.7 47.54,158.7 46.66,159.58 46.16,159.58 42.08,163.66 37.25,163.66 34.49,160.91 30.53,160.91 29.9,160.28 28.13,160.28 27.8,159.95 27.8,159.12 28.43,158.48 28.43,153.88 27.69,153.15 27.69,146.17 28.27,145.6 28.27,143.79 29.4,142.65 29.4,134.33 29.92,133.81 29.92,130.61 27.36,128.06 27.36,124.88 25.33,122.85 19.47,122.85 18.42,121.8 18.42,120.99 18.93,120.48 19.14,120.48 19.65,119.97 19.65,111.85 16.65,108.85 16.65,106.03 16.15,105.53 16.15,105.09 15.46,104.41 15.46,100.21 16.53,99.14 16.53,98.25 16.8,97.98 16.8,97.26 15.54,96 15.54,94.68 14.93,94.08 14.93,92.78 14.79,92.64 14.79,92.11 16.42,90.48 16.42,89.47 15.91,88.96 15.91,88.41 16.62,87.69 17.86,87.69 19.62,85.94 19.62,85.56 20.86,84.31 21.47,84.31 22.06,83.73 22.06,83.68 22.69,83.04 24.88,83.04 25.06,82.87 26.3,82.87 26.67,82.49 33.13,82.49 35.42,80.19 35.42,79.11 36,78.53 36,67.68 38.08,65.6 38.08,56.23 40.4,53.91 40.4,51.15 37.02,47.76 37.02,34.68 40.43,31.27 40.43,28.26 43.57,25.12 43.57,19.32 45.22,17.67 45.22,10.96 49.4,6.79 50.89,6.79 51.42,6.26 51.42,5.8 v1(51.6,5.62)
  BOTTOM w0.102: U51.B53 100.25,160.9 v1(99.81,160.46) ; v1(51.6,5.62) 51.42,5.45 51.42,4.99 R585.2
VCI_IN3#: length 3.4
  BOTTOM w0.102: R873.2 v2(109.05,163.03) 109.05,162.95 108.44,162.34 108.44,161.99 107.75,161.29 U51.B68
VCORE_VDDP: length 5.9
  TOP w0.203: PU500.23 51.93,28.66 v1(51.47,29.12)
  TOP w0.508: PR523.1 51.08,30.95 50.83,30.71 PR520.1 50.33,30.34 50.99,29.68 50.99,29.6 51.04,29.55 v2(51.04,29.55) v1(51.47,29.12)
  BOTTOM w0.508: v1(51.47,29.12) 51.6,28.99 51.6,28.2 51.18,27.79 PC508.2
VCP_4021: length 2.6
  TOP w0.254: U29.25 172.09,131.51 v2(172.8,130.8) R430.1
VCT_LAN_R1: length 4.9
  BOTTOM w0.102: R553.2 124.21,157.52 R558.1 123.35,156.72 v2(122.72,156.09) 122.14,155.5 U31.6
VGA_ID: length 9
  TOP w0.102: v1(221.83,81.77) 221.42,82.18 221.42,82.97 221.67,83.22 222.16,83.22 222.58,83.65 222.58,85.87 222.33,86.11 v1(222.33,87.47)
  BOTTOM w0.102: U46.B59 v1(221.83,81.77) ; R803.1 222.74,88.68 222.74,87.88 v1(222.33,87.47)
VIDALERT_N: length 113.2
  TOP w0.102: PR506.1 46.89,23.02 45.67,21.79 v2(45.67,19.89) 45.67,19.81 47.15,18.32 50.25,18.32 v1(50.81,18.88) ; RC61.2 RC60.2 83.65,80.81 83.65,78.9 81.11,76.36 v1(81.11,76.34)
  IN3 w0.127: v1(50.81,18.88) 51.42,18.27 55.14,18.27 55.75,18.88 61.35,18.88 62.7,20.23 67.47,20.23 67.85,20.61 72.12,20.61 73.36,21.85 74,21.85 80.15,28 80.15,33.48 82.3,35.63 82.57,35.63 86.6,39.66 86.6,45.81 87.66,46.87 87.66,67.63 84.67,70.62 84.67,71 84.33,71.35 77.87,71.35 77.63,71.58 77.63,72.91 78.95,74.23 80.4,74.23 80.63,74.46 80.63,75.86 v1(81.11,76.34)
VIDSCLK: length 99.7
  TOP w0.102: v1(49.92,18.88) v2(47.68,18.88) 47.38,18.88 46.22,20.04 46.22,21.56 46.8,22.13 PR508.1 ; v1(78.12,71.75) JCPU1.AM29
  IN3 w0.127: v1(49.92,18.88) 51.11,17.69 55.38,17.69 55.99,18.3 61.59,18.3 62.94,19.64 67.71,19.64 68.09,20.03 72.36,20.03 73.61,21.27 74.24,21.27 80.73,27.76 80.73,33.24 82.54,35.05 83.05,35.05 87.56,39.56 87.56,45.76 88.25,46.44 88.25,67.96 85.63,70.57 85.63,71.97 85.43,72.17 78.55,72.17 v1(78.12,71.75)
VIDSOUT: length 121.6
  TOP w0.102: PR505.1 46.99,23.91 v2(45.43,22.35) 45.07,21.99 45.07,19.61 46.92,17.77 50.56,17.77 v1(51.66,18.87) ; JCPU1.AL28 v1(79.12,70.75)
  IN3 w0.127: v1(51.66,18.87) 54.91,18.87 55.51,19.47 61.11,19.47 62.46,20.81 67.22,20.81 67.61,21.19 71.88,21.19 73.13,22.45 73.73,22.45 79.56,28.28 79.56,33.72 82.06,36.22 82.33,36.22 85.66,39.55 85.66,45.91 87.08,47.33 87.08,67.37 84.2,70.25 79.62,70.25 v1(79.12,70.75)
  BOTTOM w0.102: RC63.2 63.2,77.23 66.63,77.23 68.44,75.42 68.44,73.24 69.48,72.2 70.52,72.2 70.7,72.02 72.48,72.02 73.34,71.16 78.71,71.16 v1(79.12,70.75)
VLDOIN_1.35V: length 1.2
  BOTTOM w0.203: PU200.19 177.49,74.96 177.03,74.51
  vias: v2(176.72,72.07)
VOL_DOWN: length 173.2
  TOP w0.102: R887.2 102.27,162.01 R1197.2 101.25,161 101.25,158.73 101.28,158.7 101.28,154.98 100.59,154.29 100.49,154.29 100.26,154.06 100.26,153.68 98.48,151.9 98.48,150.33 95.72,147.56 v1(95.72,145.86) ; JIO1.79 v1(6.51,87.6)
  IN1 w0.109: v1(92.19,95.24) 94.06,97.11 94.06,107.12 95.28,108.34 95.28,117.97 95.01,118.25 95.01,123.62 94.22,124.42 94.22,125.13 95.4,126.31 95.4,128.33 95.85,128.79 95.85,137.54 96.42,138.11 96.42,145.15 v1(95.72,145.86)
  IN2 w0.127: v1(92.19,95.24) 89.85,95.24 87.82,93.2 86.31,93.2 85.14,92.03 85.14,89.66 80.07,84.59 69.32,84.59 67.4,82.67 54,82.67 51.41,80.09 46.89,80.09 46.67,79.87 35.77,79.87 35.42,79.51 34.59,79.51 34,80.1 29.17,80.1 28.94,79.87 25.44,79.87 24.81,79.23 17.19,79.23 16.56,78.6 13.53,78.6 7.58,84.55 7.58,86.53 v1(6.51,87.6)
VOL_DOWN_R: length 3.3
  TOP w0.102: R887.1 102.27,160.46 v1(102.25,160.44) 103.03,159.65 v2(103.03,158.8)
  BOTTOM w0.102: U51.B57 v1(102.25,160.44)
VOL_MUTE: length 207
  TOP w0.102: R884.2 R1986.2 113.19,162.52 113.19,161.12 112.35,160.28 v1(110.52,160.28) ; JIO1.81 v1(6.51,87)
  IN1 w0.109: v1(110.52,160.28) 111.19,160.28 112.35,159.13 112.35,156.13 113.45,155.03 113.45,154.44 113.79,154.1 113.79,152.91 113.39,152.52 113.39,151.03 112.54,150.18 112.54,148.34 110.38,146.18 110.38,146.03 109.89,145.54 109.89,142.96 107.72,140.79 107.72,140.33 109.53,138.52 109.53,135.28 119.32,125.49 119.32,114.37 116.01,111.06 116.01,104.16 117.26,102.91 117.26,96.01 v1(116.19,94.94)
  IN2 w0.127: v1(116.19,94.94) 115.64,94.94 115.21,94.51 113.78,94.51 113.74,94.55 92.5,94.55 91.59,93.64 89.34,93.64 87.88,92.17 87.88,91.28 80.63,84.03 69.48,84.03 67.22,81.77 57.22,81.77 57.03,81.58 55.71,81.58 55.48,81.35 55.48,80.99 55.13,80.63 52.31,80.63 51.52,79.83 47,79.83 46.78,79.61 37.74,79.61 37.13,79 34.74,79 33.9,79.84 29.28,79.84 29.05,79.61 25.55,79.61 24.91,78.98 17.3,78.98 16.66,78.34 13.43,78.34 7.32,84.45 7.32,86.19 6.52,87 v1(6.51,87)
  BOTTOM w0.102: v1(116.19,94.94) v2(116.19,95.68)
VOL_UP: length 188.1
  TOP w0.102: v1(5.93,87.62) 6.51,88.2 JIO1.77 ; v1(107.63,146.62) 107.63,146.7 107.96,147.03 107.96,147.69 R1118.2 R1984.2
  IN1 w0.109: v1(107.63,146.62) 107.63,144.77 107.32,144.46 107.32,143.35 105.78,141.81 105.78,138.37 106.47,137.68 106.47,135.53 109.18,132.83 109.18,126.57 105.91,123.31 105.91,121.3 106.67,120.54 106.67,119.15 107.9,117.92 107.9,112.99 110.63,110.27 110.63,107.56 112.28,105.9 112.28,97.97 113.98,96.28 114.36,96.28 114.77,95.87 v1(114.77,95.74)
  IN2 w0.127: v1(5.93,87.62) 6.33,88.02 6.69,88.02 7.96,86.75 7.96,84.53 13.64,78.85 16.45,78.85 17.09,79.49 24.7,79.49 25.33,80.12 28.84,80.12 29.24,80.53 29.24,81.57 29.75,82.08 34.01,82.08 35.45,80.63 46.3,80.63 47.5,81.82 52.07,81.82 53.68,83.44 66.86,83.44 68.82,85.39 79.4,85.39 83.14,89.14 83.14,91.4 85.8,94.05 87.59,94.05 89.7,96.16 113.64,96.16 114.05,95.74 v1(114.77,95.74)
  BOTTOM w0.102: v1(114.77,95.74) v2(114.08,95.74)
VR_HOT#: length 4.5
  TOP w0.102: PU500.5 53.13,22.54 53.12,22.53 PR524.2 53.64,21.56 53.64,20.88 53.84,20.67 54,20.67 54.29,20.38 v2(54.29,20.24)
VR_ON: length 6.1
  TOP w0.203: PR517.2 PR513.2 48.5,21.5 49.21,21.5 v2(50.83,23.13) 51.11,23.4 51.72,23.4 51.93,23.61 PU500.2
VSB_N_001: length 5.4
  BOTTOM w0.102: PR15.2 25.29,147.67 v2(24.9,148.07)
  BOTTOM w0.508: PR17.2 PR15.2 25.69,147.43 PC7.2 25.42,146.26 PQ4.2
VSB_N_002: length 5.4
  BOTTOM w0.102: PR21.2 PR23.2 31.29,142.06 PC16.1 31.29,142.98 PQ7.2 31.29,145 32.05,145.76 v2(32.55,145.76)
VSB_N_003: length 4.9
  BOTTOM w0.508: PQ7.1 29.13,146.27 v2(28.79,146.62) 27.54,147.86 27.54,148.09 27.01,148.63 PR17.1
VSET_4021: length 3.6
  TOP w0.254: R424.1 C319.1 v2(172.91,133.56) 172.68,133.56 172.12,133.01 U29.28
VSET_5075: length 4.1
  BOTTOM w0.102: C1347.1 R1983.1 ; R1983.1 107.67,150.01 107.5,150.18 U51.A17 ; R1983.1 v2(108.62,148.89)
VSYNC: length 9.8
  TOP w0.076: UH1.N44 29.9,108.14 29.78,108.27 29.78,108.55 29.85,108.62 29.85,108.71 v1(29.72,108.84)
  BOTTOM w0.102: v1(29.72,108.84) 29.12,108.24 27.39,108.24 26.81,108.82 25.43,108.82 24.47,109.78 24.47,110.12 v2(23.79,110.79) 23.4,111.19 RH95.2
VSYNC_BUF: length 5.6
  TOP w0.102: L5.1 87.12,163.3 v2(86.42,162.6) 85.3,161.48 v1(83.8,161.48)
  BOTTOM w0.102: U19.36 v1(83.8,161.48)
VSYNC_DOCK: length 57
  TOP w0.102: v1(80.22,158.96) 80.55,158.63 83.8,158.63 85.05,157.39 88.45,157.39 89.09,156.75 89.09,154.39 89.75,153.73 89.75,144.91 91.36,143.3 91.36,139.04 95.31,135.09 v2(95.31,133.22) 95.31,126.79 96.17,125.93 96.17,122.92 94.23,120.97 92.51,120.97 91.76,120.23 v1(90.1,120.23)
  BOTTOM w0.102: U19.27 80.46,158.75 80.22,158.99 v1(80.22,158.96) ; JDOCK1.67 90.7,119.81 90.28,120.23 v1(90.1,120.23)
VSYNC_L: length 15.4
  TOP w0.102: v2(86.64,167.41) 86.42,167.19 v1(86.04,167.19) 86.04,166.99 86.06,166.96 86.06,165.26 86.27,165.06 L5.2
  IN3 w0.127: JCRT1.14 78.12,172.02 79.21,170.93 82.05,170.93 85.78,167.19 v1(86.04,167.19)
WAKE#: length 9.1
  TOP w0.102: JMXM1.40 123.5,99.43 v1(123.42,99.35)
  BOTTOM w0.102: v2(125.69,103.49) R36.2 125.28,102.12 125.28,100.65 R1972.1 124.95,99.35 v1(123.42,99.35)
WIGIG60GHZ_DIS#: length 145.3
  IN1 w0.109: v1(150.28,152.99) 150.61,152.99 151.34,152.26 151.34,150.86 151.42,150.79 152.1,150.79 153.2,149.69 153.2,143.67 153.86,143.01 154.75,143.01 157.21,140.55 157.21,138.95 160.14,136.02 160.14,135.3 160.8,134.63 165.55,134.63 166.77,135.85 173.45,135.85 174.42,134.88 174.42,127.19 172.11,124.88 172.11,123.82 173.82,122.11 173.82,113.43 174.76,112.5 175.76,112.5 187.77,100.49 194.32,100.49 201.81,93 201.81,89.56 v1(202.61,88.76)
  BOTTOM w0.102: U46.A1 221.67,75.47 221.95,75.19 221.95,71.99 v2(221.5,71.54) 220.64,71.54 219.4,70.29 215.26,70.29 213.97,69 207.15,69 202.46,73.69 202.46,88.61 v1(202.61,88.76) ; D29.1 149.71,152.94 150.22,152.94 v1(150.28,152.99)
WIGIG60GHZ_DIS#_R: length 7.3
  BOTTOM w0.102: JMINI4.32 v2(146.36,154.14) 149.27,154.14 D29.2 149.39,153.4 148.8,152.82 R692.1
WIGIG_LED#: length 21.5
  IN2 w0.127: v1(148.73,155.84) 148.6,155.84 147.74,154.98 147.74,150.53 147.99,150.28 147.99,147.74 149.92,145.81 149.92,143.77 v1(149.31,143.17)
  BOTTOM w0.102: v1(148.73,155.84) 148.35,156.22 Q124.4 147.24,156.22 v2(146.4,157.06) 145.31,158.14 JMINI4.42 ; R706.1 R705.1 148.93,142.78 v1(149.31,143.17)
WIRELESS_LED#: length 354
  TOP w0.102: Q78.3 15.78,146.42 14.35,144.98 v2(13.31,144.98) 13.08,144.98 R937.2 11.57,144.05 v1(11.54,144.08)
  IN1 w0.109: v1(150.17,156.37) 150.15,156.35 150.15,155.2 150.83,154.52 151.57,154.52 153.76,152.32 153.76,148.77 154.19,148.35 154.19,145.91 153.45,145.17 153.45,143.75 153.96,143.24 154.85,143.24 157.44,140.65 157.44,139.05 160.37,136.12 160.7,136.12 161.94,134.87 165.46,134.87 166.68,136.09 173.55,136.09 174.66,134.98 174.66,113.3 174.99,112.97 176.09,112.97 187.4,101.66 196.15,101.66 208.57,89.24 219.36,89.24 221.13,87.47 v1(221.26,87.47)
  IN2 w0.127: v1(246.01,82.36) 245.83,82.18 229.8,82.18 224.98,87.01 221.73,87.01 v1(221.26,87.47)
  IN3 w0.127: v1(150.17,156.37) 150.15,156.37 150.81,157.03 150.81,159.17 139.68,170.29 123.83,170.29 122.82,171.31 108.31,171.31 105.77,168.77 96.52,168.77 92.71,164.96 89.26,164.96 88.79,164.49 78.33,164.49 77.51,165.31 72.96,165.31 69.67,162.02 61.49,162.02 57.18,157.72 56.47,157.72 55.35,156.6 51.03,156.6 50.42,155.99 47.91,155.99 47.27,155.36 43.01,155.36 42.38,155.99 42.38,163.79 38.52,167.65 25.22,167.65 24.39,166.81 21.59,166.81 20.73,165.95 17.99,165.95 13.98,161.94 13.98,156.43 9.66,152.11 9.66,147.66 11.54,145.78 v1(11.54,144.08)
  BOTTOM w0.102: v1(246.01,82.36) 246.01,76.72 243.75,74.46 243.75,71.33 243.57,71.16 Q77.1 ; U46.A47 221.17,87.38 v1(221.26,87.47) ; v1(150.17,156.37) 150.15,156.37 149.99,156.22 Q124.3 148.91,156.22 Q124.6
WIRELESS_ON#/OFF: length 147.6
  TOP w0.254: v1(227.52,24.54) 227.49,24.52 JWL1.3 ; v1(224.52,70.6) 224.4,70.71 223.03,70.71 222.93,70.61 220.42,70.61 219.57,71.46 218.66,71.46 215.69,74.43 215.69,76.73 215.92,76.96 v1(215.92,77.37)
  IN3 w0.254: v1(227.52,24.54) 227.52,25.49 238.12,36.09 248.4,36.09 252.47,40.16 264.55,40.16 270.34,45.95 270.34,62.44 268.6,64.18 257.77,64.18 256.43,62.85 249.79,62.85 249.14,63.5 246.97,63.5 246.1,64.37 244.88,64.37 243.84,65.42 241.23,65.42 237.73,61.91 234.45,61.91 232.95,63.41 231,63.41 225.56,68.84 225.56,69.58 224.52,70.62 v1(224.52,70.6)
  BOTTOM w0.102: v4(220.43,70.13) 221.43,69.13 RP2.6
  BOTTOM w0.203: RP2.6 222.33,69.13 222.54,69.34 222.54,70.36 222.89,70.71
  BOTTOM w0.254: v1(224.52,70.6) 224.4,70.71 222.89,70.71 ; U46.B13 v1(215.92,77.37)
WLAN_LAN_DISB#: length 137.7
  TOP w0.102: U15.4 127.98,145.64 v1(128.41,146.06)
  IN1 w0.109: v1(222.79,76.46) 222.58,76.67 213.04,76.67 212.31,77.41 210.61,77.41 209.7,78.32 202.8,78.32 197.82,83.3 185.58,83.3 180.84,88.03 180.84,92.03 174.74,98.13 172.36,98.13 159.76,110.73 159.76,113.1 157.34,115.53 157.34,117.21 156.57,117.97 156.57,123.23 152.69,127.11 152.69,128.23 138.78,142.14 138.78,143.38 134.75,147.41 129.75,147.41 v1(128.41,146.06)
  BOTTOM w0.102: v4(224.74,76.46) v1(222.79,76.46) 223.37,77.04 U46.A64
WLAN_LED: length 78
  TOP w0.102: JIO1.96 14.27,82.8 v1(15.48,84.01) ; v2(11.46,142.82) 10.96,143.33 v1(10.96,144.08) 10.68,143.81 R939.2
  IN2 w0.127: v1(15.48,84.01) 15.48,83.98 14.82,83.32 14.03,83.32 12.73,84.61 12.73,90.54 11.59,91.69 11.59,92.73 10.63,93.69 10.63,95.2 10.24,95.58 10.24,96.89 8.64,98.49 8.64,110.55 9.31,111.21 9.31,113.11 9.66,113.47 10.95,113.47 14.16,116.68 14.16,123.55 11.31,126.39 11.31,133.44 13.12,135.25 13.12,138.76 13.72,139.37 13.72,140.69 10.96,143.46 v1(10.96,144.08)
WLAN_LED#: length 5.9
  BOTTOM w0.102: Q124.1 148.62,157.52 R718.1 147.2,158.94 v2(146.44,158.94) 146.44,158.94 JMINI4.44
WLAN_RADIO_DIS#: length 116.3
  TOP w0.102: v1(149.26,148.8) 150.08,148.8 v2(150.17,148.89)
  IN3 w0.127: v1(149.26,148.8) 149.26,148.07 152.95,144.37 152.95,142.02 155,139.98 155,138.57 156.18,137.39 156.18,128.23 159.02,125.39 159.02,124.36 162.48,120.9 168.55,120.9 172.73,116.72 172.73,107.17 180.95,98.94 196.12,98.94 202.82,92.24 206.43,92.24 209.28,89.39 215.82,89.39 216.17,89.04 221.5,89.04 222.33,88.21 v1(222.33,88.13)
  BOTTOM w0.102: U46.A48 221.67,87.47 v1(222.33,88.13) ; D31.1 149.26,148.18 v1(149.26,148.8)
WLAN_RADIO_DIS#_R: length 5.3
  BOTTOM w0.102: R695.1 147.42,146.84 D31.2 147.42,148.09 v2(146.63,148.88) 146.17,149.34 JMINI4.20
WWAN_RADIO_DIS#: length 39.8
  TOP w0.102: v1(244.18,72.73) 241.61,75.3 229.98,75.3 227.67,77.61 227.67,78.4 226.45,79.61 226.45,81.32 v1(225.54,82.23) 224.8,82.23 v1(224.12,82.91)
  BOTTOM w0.102: RP1.5 225.14,82.46 225.37,82.23 v1(225.54,82.23) ; U46.A53 224,83.02 v1(224.12,82.91) ; JMINI2.20 251.07,77.8 250.12,78.75 247.71,78.75 v2(246.55,77.59) 246.26,77.3 246.26,76.19 244.18,74.1 v1(244.18,72.73)
XDP_DBRESET#_R: length 5.6
  TOP w0.102: JCPU1.AP33 v1(74.12,73.75)
  BOTTOM w0.102: v1(74.12,73.75) 73.67,74.2 73.06,74.2 v2(71.99,75.28) 71.28,75.98 RC26.2 RC19.2
XDP_FN0: length 3
  TOP w0.102: JXDP2.9 30.3,124.24 v1(30.38,124.32)
  BOTTOM w0.102: RH3.2 30.64,124.06 v1(30.38,124.32) 30.38,124.7 v2(30.58,124.9)
XDP_FN1: length 4.1
  TOP w0.102: v1(29.8,121.07) JXDP2.11
  BOTTOM w0.102: v2(29.19,120.84) 29.42,121.07 v1(29.8,121.07) 29.75,121.12 RH4.2
XDP_FN2: length 4.5
  TOP w0.102: JXDP2.15 28.8,124.41 v1(29.29,124.9)
  BOTTOM w0.102: RH6.2 28.86,124.47 v1(29.29,124.9) 29.29,125.03 29.07,125.26 v2(28.77,125.26)
XDP_FN3: length 4.7
  TOP w0.102: v1(27.8,124.9) 28.3,124.4 JXDP2.17
  BOTTOM w0.102: v2(26.98,125.14) 27.55,125.14 v1(27.8,124.9) 28.23,124.47 28.23,123.94 RH7.2
XDP_FN4: length 4.1
  TOP w0.102: v1(26.3,121.28) 25.8,121.78 JXDP2.27
  BOTTOM w0.102: RH8.2 26.07,121.51 v1(26.3,121.28) 25.92,121.28 v2(25.6,120.95)
XDP_FN5: length 4.9
  TOP w0.102: v1(24.8,125.49) 25.3,124.98 JXDP2.29
  BOTTOM w0.102: v1(24.8,125.49) 25.23,125.05 v2(25.23,124.61) 25.23,123.73 RH9.2
XDP_FN6: length 4.6
  TOP w0.102: JXDP2.33 24.3,124.4 v1(24.8,124.9)
  BOTTOM w0.102: v2(24.06,125.12) 24.28,124.9 v1(24.8,124.9) 24.29,124.39 RH17.2
XDP_FN7: length 3
  TOP w0.102: JXDP2.35 23.8,123.82 v1(23.3,124.32) 23.41,124.32 v2(23.78,124.69)
  BOTTOM w0.102: v1(23.3,124.32) 23.28,124.29 RH10.2
XDP_FN8: length 8.1
  TOP w0.102: JXDP2.10 30.3,118.19 31.4,119.29 35.52,119.29 RH11.2
XDP_FN9: length 8.3
  TOP w0.102: JXDP2.12 29.8,118.07 31.25,119.52 36.18,119.52 RH13.2
XDP_FN10: length 11.7
  TOP w0.102: RH12.2 30.77,120.18 28.8,118.21 JXDP2.16 28.8,115.74 28.69,115.62 v2(28.69,115.02)
XDP_FN11: length 11.7
  TOP w0.102: v2(36.51,122.2) 36.41,122.1 RH14.2 36,120.66 30.64,120.66 28.3,118.32 JXDP2.18
XDP_FN12: length 6.9
  TOP w0.102: RH16.2 21.32,115.25 v2(22.03,115.25) 22.12,115.34 24.41,115.34 24.62,115.12 25.03,115.12 25.8,115.9 JXDP2.28
XDP_FN13: length 17
  TOP w0.102: JXDP2.30 25.3,118.18 23.35,120.13 21.17,120.13 20.4,120.89 17.56,120.89 15.91,119.24 15.91,115.02 RH19.2
XDP_FN14: length 15.7
  TOP w0.102: RH20.2 16.14,115.33 16.14,119.14 17.65,120.66 20.2,120.66 20.99,119.87 22.64,119.87 24.3,118.21 JXDP2.34
XDP_FN15: length 15.1
  TOP w0.102: RH22.2 17.59,114.67 16.37,115.89 16.37,119.05 17.75,120.43 20.11,120.43 20.89,119.64 22.41,119.64 23.8,118.25 JXDP2.36
XDP_FN16: length 8.4
  TOP w0.102: JXDP2.4 31.8,118.11 32.06,118.37 32.65,118.37 32.9,118.12 35.47,118.12 35.98,117.62 35.98,117.05 RH24.2 36.41,116.36 v2(35.45,115.4)
XDP_FN17: length 8.7
  TOP w0.102: RH25.2 35.57,118.35 33,118.35 32.74,118.6 31.73,118.6 31.3,118.17 JXDP2.6 v2(31.3,115.24)
XDP_OBS0: length 96.5
  TOP w0.102: RC30.2 79.03,79.61 79.03,77.94 77.99,76.9 v1(77.99,76.41) ; JXDP1.21 66.7,13.87 65.03,15.53 61.22,15.53 60.87,15.89 v2(60.87,19.44) v1(60.87,20.05)
  IN3 w0.127: v1(77.99,76.41) 78.04,76.36 78.04,74.28 76.69,72.93 76.69,69.45 76.87,69.28 83.5,69.28 83.85,68.92 83.85,46.75 84.64,45.96 84.64,40.37 78.98,34.7 78.98,28.94 74.58,24.55 74.1,24.55 72.07,22.52 68.1,22.52 66.98,21.4 62.21,21.4 v1(60.87,20.05)
XDP_OBS0_R: length 5.6
  TOP w0.102: RC30.1 78.52,78.09 77.2,76.77 77.2,74.67 JCPU1.AR30
XDP_OBS1: length 96.2
  TOP w0.102: RC31.2 76.26,80.12 76.56,79.82 76.56,78.88 75.85,78.17 75.85,76.97 76.26,76.57 76.26,75.98 v1(76.13,75.86) ; v1(65.46,22.31) v2(64.88,22.31) 61.1,18.53 61.1,15.98 61.32,15.76 65.13,15.76 66.92,13.96 66.92,13.22 67.2,12.95 JXDP1.23
  IN3 w0.127: v1(76.13,75.86) 76.13,75.83 76.79,75.17 76.79,73.72 76.34,73.26 76.01,73.26 75.68,72.93 75.68,68.51 75.88,68.31 83.27,68.31 83.6,67.98 83.6,39.69 78.72,34.81 78.72,29.05 74.6,24.93 74.12,24.93 71.96,22.77 67.99,22.77 67.05,21.83 65.95,21.83 v1(65.46,22.31)
XDP_OBS1_R: length 8
  TOP w0.102: RC31.1 76.11,79.18 75.62,78.69 75.62,76.64 v1(75.88,76.39) ; JCPU1.AN31 v1(76.12,72.75)
  BOTTOM w0.102: v1(75.88,76.39) 75.75,76.26 75.75,75.66 76.51,74.89 v2(76.51,73.14) v1(76.12,72.75)
XDP_OBS2_R: length 14.2
  TOP w0.102: v1(78.12,72.75) JCPU1.AN29
  BOTTOM w0.102: T1.1 70.28,77.63 75.17,77.63 76.59,76.22 76.59,75.96 78.12,74.42 v1(78.12,72.75)
XDP_OBS3_R: length 5.9
  TOP w0.102: JCPU1.AP31 v1(76.12,73.75)
  BOTTOM w0.089: T2.1 71.56,73.76
  BOTTOM w0.102: 71.56,73.76 71.96,73.37 75.74,73.37 v1(76.12,73.75)
XDP_OBS4_R: length 8.7
  TOP w0.102: T3.1 77.94,80.55 77.94,77.89 76.97,76.92 76.97,75.55 77,75.52 77,73.87 JCPU1.AP30
XDP_OBS5_R: length 10.6
  TOP w0.102: JCPU1.AN28 v1(79.12,72.75)
  BOTTOM w0.102: T4.1 70.8,74.18 71.84,73.14 75.29,73.14 75.6,72.83 75.6,72.73 76.01,72.32 78.7,72.32 v1(79.12,72.75)
XDP_OBS6_R: length 7.2
  TOP w0.102: T5.1 79.49,77.9 78.39,76.81 78.39,76.05 77.99,75.64 77.99,73.88 JCPU1.AP29
XDP_OBS7_R: length 10.9
  TOP w0.102: JCPU1.AP28 v1(79.12,73.75)
  BOTTOM w0.089: v1(79.12,73.75) 79.06,73.75 76.77,76.03 76.77,76.29 76.69,76.38 76.69,76.73 76.17,77.25
  BOTTOM w0.102: 76.17,77.25 75.43,77.99 71.55,77.99 T6.1
XDP_PRDY#: length 6.4
  TOP w0.102: RC47.1 82.2,79.04 79.66,76.5 79.66,76.24 79.16,75.73 79.16,74.84 JCPU1.AR29
XDP_PRDY#_R: length 99.4
  TOP w0.102: v1(87.46,80.73) v2(86.15,82.04) 85.38,82.81 82.71,82.81 82.2,82.31 RC47.2 ; JXDP1.5 v1(62.7,10.45)
  IN3 w0.127: v1(62.7,10.45) 62.7,10.6 67.12,15.02 68.77,15.02 70.7,16.95 71.11,16.95 84,29.84 86.03,29.84 89.62,33.43 89.62,44.92 92.36,47.66 92.36,68.74 92.03,69.07 89.29,69.07 87.59,70.78 87.59,72.98 87.31,73.26 86.98,73.26 86.72,73.52 86.72,78.9 87.46,79.64 v1(87.46,80.73)
XDP_PREQ#: length 7.4
  TOP w0.102: JCPU1.AT29 78.59,76.68 79.96,78.05 79.96,78.74 RC32.2 80.43,79.23 RC48.1 81.31,80.87 v2(81.8,81.35)
XDP_PREQ#_R: length 96.7
  TOP w0.102: RC48.2 81.31,78.86 79.23,76.78 v1(79.23,76.39) ; JXDP1.3 v1(62.2,13.55)
  IN3 w0.127: v1(79.23,76.39) 79.59,76.74 85.23,76.74 85.63,76.34 85.63,73.52 85.91,73.24 86.37,73.24 86.7,72.91 86.7,70.6 88.73,68.57 91.52,68.57 91.86,68.24 91.86,47.79 88.65,44.59 88.65,34.94 88.91,34.68 88.91,33.08 85.92,30.1 83.89,30.1 71,17.21 65.85,17.21 62.2,13.56 v1(62.2,13.55)
  BOTTOM w0.089: v2(78.8,76.92) 79.23,76.49 v1(79.23,76.39)
XDP_RST#_R: length 3
  TOP w0.102: v1(72.86,16.17) 72.82,16.17 72.7,16.29 JXDP1.46
  BOTTOM w0.102: v1(72.86,16.17) 73.05,16.36 73.05,17.04 RC8.2
XDP_TCLK: length 33.3
  TOP w0.102: JCPU1.AM34 73,71.87 71.78,71.87 69.88,73.76 RC40.2 70.52,80.99 70.52,82.08 71.33,82.89 74.53,82.89 74.91,82.51 v2(79.4,82.51) 81.83,82.51 82.54,83.22 85.58,83.22 87.87,80.94 87.87,80.33 RC50.1
XDP_TCLK_R: length 82.8
  TOP w0.102: v1(73.21,15.68) 73.21,15.43 75.7,12.94 JXDP1.57 ; RC50.2 87.16,78.7 87.16,76.35 v1(87.14,76.34)
  IN3 w0.127: v1(73.21,15.68) 73.82,15.68 74.13,15.99 74.13,19.61 84.1,29.59 86.2,29.59 90.56,33.95 90.56,44.84 92.87,47.15 92.87,68.87 92.29,69.45 89.67,69.45 88.22,70.9 88.22,75.26 v1(87.14,76.34)
  BOTTOM w0.102: v4(72.6,15.58) 73.11,15.58 v1(73.21,15.68)
XDP_TDI: length 66.6
  TOP w0.102: v1(74.06,23.87) 75.2,22.74 JXDP1.56
  IN4 w0.109: v1(74.06,23.87) 73.88,24.05 73.88,24.23 68.68,29.43 68.68,30.27 58.38,40.57 58.38,52.43 57.54,53.26 57.54,73.63 58.38,74.46 58.38,74.69 v1(58.43,74.74)
  BOTTOM w0.102: v4(74.89,24.08) 74.68,23.87 v1(74.06,23.87) ; v1(58.43,74.74) 58.91,74.74 RC23.2
XDP_TDI_R: length 22.4
  TOP w0.102: JCPU1.AM31 v1(76.12,71.75)
  BOTTOM w0.102: v1(76.12,71.75) 75.78,71.41 73.36,71.41 72.52,72.25 71.2,72.25 70.7,72.76 69.71,72.76 69,73.47 69,75.65 66.79,77.86 63.05,77.86 v2(61.72,76.54) 61.17,75.98 RC29.2 RC23.1
XDP_TDO: length 69.3
  TOP w0.102: v1(73.2,23) 74.2,22 JXDP1.52 ; RC24.2 58.7,76.62 58.32,77 57.97,77 57.74,76.77 57.74,75.78 v1(57.87,75.65)
  IN4 w0.109: v1(57.87,75.65) 57.76,75.54 57.76,74.52 57.07,73.83 57.07,53.04 57.91,52.2 57.91,40.37 68.21,30.08 68.21,29.24 72.73,24.71 72.73,23.47 v1(73.2,23)
  BOTTOM w0.102: v4(72.73,23.75) 72.73,23.47 v1(73.2,23)
XDP_TDO_R: length 18.5
  TOP w0.102: JCPU1.AL33 74.59,70.28 74.05,70.83 73.44,70.83 73.14,71.13 73.14,71.36 72.83,71.66 71.4,71.66 66.99,76.08 66.99,76.97 66.33,77.63 v2(64.08,77.63) 63.88,77.63 63.32,77.07 61.5,77.07 RC35.2 RC24.1
XDP_TMS: length 12.2
  TOP w0.102: v1(74.12,72.75) JCPU1.AN33 ; v1(73.14,76.34) v2(73.14,78.79) 73.14,79.94 73.68,80.49 73.68,80.85 RC27.2 RC56.1
  IN4 w0.102: v1(74.12,72.75) 73.75,72.75 73.31,73.19 72.93,73.19 72.68,73.44 72.68,75.88 v1(73.14,76.34)
XDP_TMS_R: length 79.4
  TOP w0.102: RC56.2 73.72,78.73 v1(73.72,76.34) ; JXDP1.58 75.7,23.23 74.65,24.28 71.56,24.28 v1(71.32,24.04)
  IN3 w0.127: v1(73.72,76.34) 73.69,76.31 73.69,66.46 73.9,66.25 81.26,66.25 81.52,66 81.52,39.1 77.71,35.29 77.71,29.47 74.18,25.94 73.7,25.94 72.3,24.55 71.83,24.55 v1(71.32,24.04)
  BOTTOM w0.089: v4(72.81,76.92) 73.15,76.92 73.72,76.35 v1(73.72,76.34)
XDP_TRST#: length 20.5
  TOP w0.102: v1(75.09,71.79) 75.09,71.78 JCPU1.AM33
  BOTTOM w0.102: v1(75.09,71.79) 73.25,71.79 72.56,72.48 71.54,72.48 v2(71.27,72.74) 71.03,72.99 69.8,72.99 69.22,73.57 69.22,75.75 66.88,78.09 60.51,78.09 RC41.2 RC62.1
XDP_TRST#_R: length 69.4
  TOP w0.102: v1(73.63,23.44) 74.7,22.38 JXDP1.54
  IN4 w0.109: v1(73.63,23.44) 73.19,23.89 73.19,24.59 68.44,29.34 68.44,30.17 58.15,40.47 58.15,52.33 57.31,53.17 57.31,73.73 58,74.42 58,74.97 v1(58.35,75.32)
  BOTTOM w0.102: v4(57.88,74.92) 58.29,75.32 v1(58.35,75.32) 58.35,75.75 57.72,76.39 57.72,76.82 57.92,77.02 58.4,77.02 58.56,76.87 RC62.2
XTAL25_IN: length 11.7
  TOP w0.102: YH2.1 41.89,115.33 41.89,113.85 41.49,113.45 40.98,113.45 CH14.2 40.47,112.91 RH153.2 39.61,111.85 v2(38.85,111.08) 38.54,111.08 37.18,109.73 37.18,108.75 37.3,108.63 37.3,108.27 37.6,107.97 UH1.AM43
XTAL25_OUT: length 8.7
  TOP w0.102: YH2.3 39.2,114.62 39.94,113.88 39.94,113.27 CH13.2 38.72,112.05 RH153.1 v2(37.26,110.62) 36.95,110.31 36.95,108.69 37.1,108.54 37.1,108.03 UH1.AL44
XTALI: length 6.3
  BOTTOM w0.102: U31.10 123.74,154.6 123.71,154.62 123.71,155.74 124.01,156.04 124.14,156.04 v2(124.33,156.22) 124.96,156.86 125.99,156.86 C471.1 126.79,156.7 Y3.3
XTALO: length 8.8
  BOTTOM w0.102: Y3.1 128.18,157.26 126.45,157.26 C470.1 v2(125.21,157.57) 123.48,155.84 123.48,155.02 123.34,154.88 U31.9
Z2805: length 6
  TOP w0.102: T156.22 v1(159.36,156.12)
  BOTTOM w0.102: R574.1 163.03,157.14 162.98,157.19 160.42,157.19 v1(159.36,156.12)
Z2806: length 4.1
  TOP w0.102: T156.16 v1(166.98,156.12)
  BOTTOM w0.102: R573.1 165.26,156.22 165.36,156.12 v1(166.98,156.12)
Z2807: length 5.8
  TOP w0.102: v1(160.63,156.12) T156.21
  BOTTOM w0.102: R572.1 163.1,155.87 161.2,155.87 160.94,156.12 v1(160.63,156.12)
Z2808: length 3.9
  TOP w0.102: T156.15 v1(168.25,156.12)
  BOTTOM w0.102: v1(168.25,156.12) 168.11,156.12 167.09,157.14 R571.1
Z4012: length 2.6
  BOTTOM w0.102: PR1.2 42.15,154.75 v2(42.29,154.61)
  BOTTOM w0.508: PR1.2 42.15,156.24 PD1.2
Z4304: length 62.9
  IN1 w0.109: v1(202.62,25.18) 202.36,24.92 201.85,24.92 201.53,25.23 195.28,25.23 194.01,23.96 186.5,23.96 185.41,25.05 185.41,25.62 185.55,25.76 185.79,25.76 v1(185.99,25.56)
  BOTTOM w0.102: v1(185.99,25.56) 185.89,25.66 PR3.4 ; PBATT1.3 165.34,17.79 165.34,18.21 165.7,18.58 172.63,18.58 174.53,20.48 187.99,20.48 189.26,21.75 193.96,21.75 197.09,24.88 v2(197.1,24.88) 199.38,24.88 199.82,24.43 200.5,24.43 PD2.2 200.8,24.13 201.57,24.13 v1(202.62,25.18)
Z4305: length 63.4
  IN1 w0.109: v1(202.62,24.42) 202.36,24.68 201.75,24.68 201.43,25 195.38,25 194.11,23.73 186.4,23.73 185.17,24.95 185.17,25.72 185.45,25.99 185.82,25.99 v1(185.99,26.16)
  BOTTOM w0.102: v1(202.62,24.42) 201.53,23.32 PD2.3 199.38,24.55 v2(198.46,24.55) 197.08,24.55 194.06,21.52 189.36,21.52 188.09,20.25 174.63,20.25 172.72,18.35 165.8,18.35 165.56,18.12 165.56,17.79 PBATT1.4 ; v1(185.99,26.16) PR3.3
Z4306: length 51.3
  IN2 w0.127: v1(185.96,27.77) 186.24,27.77 190.1,23.91 197.49,23.91 v1(198.13,23.28)
  BOTTOM w0.102: 185.51,26.66 186.16,26.66 186.5,26.32 186.5,25.16 v2(186.67,24.99) ; 185.51,26.66 PR3.2 ; 185.51,26.66 185.96,27.11 v1(185.96,27.77) ; PBATT1.5 169.51,17.96 173.19,17.96 174.82,19.59 188.25,19.59 189.65,20.99 194.99,20.99 196.77,22.77 197.27,22.77 197.75,22.28 PD3.2 198.13,22.42 v1(198.13,23.28)
ZODD_WAKE#: length 358.9
  TOP w0.102: v2(42.02,28.62) 41.32,29.32 R796.2 41.06,31.23 Q81.6 41,32.42 v1(40.93,32.42)
  IN1 w0.109: v1(224.68,80.6) 224.78,80.7 227.44,80.7 230.53,77.62 238.36,77.62 240.12,79.38 242.44,79.38 242.97,78.84 251,78.84 253.29,81.13 261.51,81.13 272.42,70.22 272.42,46.37 262.7,36.66 261.19,36.66 260.45,37.4 258.1,37.4 257.28,36.58 251.93,36.58 250.73,35.38 237.07,35.38 222.84,21.15 200.55,21.15 199.76,20.36 131.78,20.36 131.2,20.95 106.84,20.95 103.49,24.3 84.34,24.3 83.8,23.76 83.8,23.35 82.38,21.93 82.22,21.93 77.59,17.31 77.59,14.78 74.12,11.31 74.12,9.49 72.84,8.21 56.35,8.21 55.41,7.28 51.72,7.28 45.58,13.41 45.58,17.82 43.93,19.47 43.93,25.27 40.93,28.28 v1(40.93,32.42)
  BOTTOM w0.102: v1(224.68,80.6) 224.1,80.02 U46.A59
N265433: length 2.4
  TOP w0.508: PQ8.2 18.07,66.33 18.32,66.08 18.7,66.08 19.02,66.39 PQ8.1
N16717680: length 11.2
  TOP w0.508: PQ8.4 17.12,70.46 17.56,70.9 PR22.1 PR20.1 18.12,72.22 v2(18.82,72.92) 19.33,73.43 v1(20.47,73.43)
  BOTTOM w0.508: PR16.2 22.34,75.6 PC9.1 19.69,74.31 PQ5.4 v1(20.47,73.43)
N16751240: length 166.7
  IN3 w0.254: v1(28.56,67.22) 28.56,75.65 29.5,76.59 32.31,76.59 32.75,77.02 34.21,77.02 34.45,76.78 38.07,76.78 38.79,76.06 39.25,76.06 39.96,76.77 46.19,76.77 48.4,78.98 51.62,78.98 52.36,79.72 56.12,79.72 57.72,81.32 57.72,82.54 v1(60.36,85.18)
  BOTTOM w0.254: PR700.2 150.15,113.64 149.65,113.14 149.65,112 148.51,110.86 145.65,110.86 144.61,111.9 143.96,111.9 140.6,108.55 v2(140.17,108.55) 134.45,102.83 134.45,101.79 134.04,101.38 133.12,101.38 128.9,97.16 127.46,97.16 123.43,93.13 122.26,93.13 118.19,97.19 115.35,97.19 113.52,99.02 112.1,99.02 110.7,100.42 110.7,100.65 110.24,101.1 109.84,101.1 109.1,100.37 109.1,95.82 104.61,91.32 100.5,91.32 94.7,85.53 94.7,82.76 91.56,79.61 72.75,79.61 67.19,85.18 v1(60.36,85.18) ; PQ701.4 v1(28.56,67.22)
N16759342: length 18.1
  TOP w0.102: v2(19.06,74.9) 19.91,75.75 PC700.2
  TOP w0.254: PC700.2 19.67,76.73 PR703.1 19.67,78.22 20.35,78.9 25.41,78.9 v1(26.15,78.17)
  BOTTOM w0.254: PQ700.2 27.53,79.32 26.5,80.35 25.71,80.35 24.7,79.33 PQ702.2 25.23,78.32 25.99,78.32 v1(26.15,78.17)
N16759370: length 17.1
  TOP w0.102: v1(89.49,114.95) 89.7,114.74 PR714.2 PR712.2 88.57,114.08 PQ703.3 86.14,114.08 85.86,113.8 85.86,112.69 86.37,112.18 PQ703.1 87.69,112.18 88.03,111.83 v2(88.51,111.83) ; PR709.2 v1(82.97,114.89)
  IN2 w0.127: v1(82.97,114.89) 83.55,114.31 89.16,114.31 89.49,114.64 v1(89.49,114.95)
N16759478: length 14.4
  IN4 w0.109: v1(27.34,78.17) 27.14,77.97 27.14,77.17 31.3,73.01 31.3,70.53 v1(31.57,70.27)
  BOTTOM w0.102: v1(27.34,78.17) 27.16,77.99 27.16,77.51 27.43,77.24 PQ700.1 ; v1(31.57,70.27) 31.21,69.91 31.21,69.8 31.01,69.59 PR701.2
N16762870: length 8.4
  TOP w0.102: v1(232.27,64.25) 232.32,64.3 233.97,64.3 v1(235.87,62.39)
  BOTTOM w0.102: v1(235.87,62.39) PQ706.6 ; PQ706.3 232.36,63.69 232.33,63.66 PR739.1 231.76,64.02 231.99,64.25 v1(232.27,64.25) 232.27,64.49 v2(231.89,64.87)
N16762920: length 20.4
  TOP w0.102: v1(237.98,63.84) 238.39,63.43 238.39,62.62 235.75,59.98 229.32,59.98 v1(228.74,60.56) 226.58,62.72 v1(225.59,62.72)
  BOTTOM w0.102: v2(229.24,59.75) 228.74,60.26 v1(228.74,60.56) ; PU704.1 238.07,63.76 v1(237.98,63.84)
  BOTTOM w0.254: PR749.2 v1(228.74,60.56) ; PQ707.6 226.16,62.15 v1(225.59,62.72)
N16762966: length 3.5
  BOTTOM w0.102: v2(236.9,61.07) PU704.4 236.45,62.46 235.86,63.04 PQ706.5
N16763030: length 7.4
  BOTTOM w0.102: v2(224.58,61.62) PR734.2
  BOTTOM w0.254: PR738.2 PR746.1 PR742.2 225.83,60.17 PR734.2 224.82,59.93 224.82,58.46 224.7,58.33 PU703.1
