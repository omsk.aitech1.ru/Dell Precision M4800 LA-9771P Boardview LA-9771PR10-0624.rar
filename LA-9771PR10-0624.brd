# Allegro board LA-9771PR10-0624.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BC_CLK_ECE5048: length 166.4
  IN1 w0.109: v1(211.16,83.53) 211.16,83.4 210.03,82.27 206.01,82.27 205.22,83.07 201.79,83.07 194.75,90.11 194.75,90.59 190.59,94.75 184.94,94.75 175.32,104.37 174.71,104.37 170,109.09 169.18,109.09 165.72,112.55 165.72,114.2 164.5,115.42 164.5,115.92 159.87,120.55 159.87,121.56 154.53,126.9 154.53,128.65 153.84,129.34 153.59,129.34 143.64,139.29 143.64,141.09 136.49,148.24 131.75,148.24 128.51,151.48 128.51,151.79 126.88,153.41 120.37,153.41 116.73,157.05 116.73,160.84 115.06,162.52 112.17,162.52 111.11,163.58 106.3,163.58 105.74,164.14 103.35,164.14 102.83,163.62 102.83,161.92 102.94,161.82 102.94,159.55 102.35,158.96 101.26,158.96 100.41,159.82 98.75,159.82 98.05,160.52 97.02,160.52 96.38,159.87 96.38,158.76 96.86,158.28 97.27,158.28 v1(97.6,157.95)
  BOTTOM w0.102: U51.A43 97.77,157.77 v1(97.6,157.95) ; v1(211.16,83.53) 211.66,84.02 U46.A30
BC_CLK_EMC4021: length 81.6
  TOP w0.102: U29.8 167.32,136.52 166.82,137.02 165.84,137.02 164.89,137.97 162.22,137.97 161.67,138.52 157.68,138.52 157.36,138.2 153.54,138.2 v2(152.48,139.25) 151.71,140.03 v1(151.71,140.7)
  IN3 w0.127: v1(151.71,140.7) 151.18,140.7 148.81,143.07 148.81,145.67 141.26,153.22 136.46,153.22 136.07,153.62 132.33,153.62 131.61,152.89 128.54,152.89 126.93,154.51 126.34,154.51 123.81,157.03 116.21,157.03 115.34,157.91 112.33,157.91 112.29,157.87 109.8,157.87 109.58,158.09 103.35,158.09 102,159.43 101.15,159.43 100.96,159.62 100.15,159.62 v1(99.83,159.31)
  BOTTOM w0.102: U51.B49 99.72,159.52 99.75,159.48 99.75,159.41 99.83,159.33 v1(99.83,159.31)
BC_DAT_ECE1117: length 112.9
  TOP w0.102: v1(105.8,153.2) 106.36,152.64 R817.2 ; JKB1.13 JKB1.14 175.94,115.5 175.55,115.89 v1(175.52,115.89) 174.95,115.89 v2(174.56,116.28)
  IN4 w0.109: v1(105.8,153.2) 105.8,153.37 107.27,154.84 109.16,154.84 110.15,155.84 110.66,155.84 111.9,157.08 123.17,157.08 125.89,159.8 126.58,159.8 126.91,159.48 130.25,159.48 132.72,157.01 133.73,157.01 140.28,150.46 148.57,150.46 150.68,148.35 150.68,145.92 150.24,145.48 150.24,140.89 156.6,134.53 164.34,134.53 166.19,132.67 170.57,132.67 172.55,130.69 173.3,130.69 174.46,129.54 174.46,118.98 175.47,117.97 175.62,117.97 175.98,117.61 175.98,116.34 v1(175.52,115.89)
  BOTTOM w0.102: U51.B21 106.25,152.75 v1(105.8,153.2)
BC_DAT_ECE5048: length 165.9
  TOP w0.102: v1(100.18,157.29) 100.14,157.34 99.63,157.34 R814.2
  IN1 w0.109: v1(100.18,157.29) 100.75,157.86 102.03,157.86 103.41,159.24 103.41,162.02 103.31,162.12 103.31,163.43 103.55,163.67 105.54,163.67 106.1,163.11 110.91,163.11 111.97,162.05 114.81,162.05 116.24,160.61 116.24,156.88 120.18,152.94 126.68,152.94 127.72,151.9 127.72,150.58 130.53,147.77 135.93,147.77 142.29,141.41 142.29,140.31 153.49,129.11 153.74,129.11 154.29,128.56 154.29,126.81 159.63,121.46 159.63,120.45 164.27,115.82 164.27,115.32 165.44,114.15 165.44,111.01 171.18,105.28 173.25,105.28 187.18,91.35 187.18,88.2 189.78,85.61 198.92,85.61 201.7,82.83 205.12,82.83 205.91,82.03 210.13,82.03 210.98,82.89 213.06,82.89 v1(214,83.83)
  BOTTOM w0.102: U46.B31 213.95,83.77 v1(214,83.83) ; U51.B45 99.48,157.52 99.7,157.29 v1(100.18,157.29)
BC_DAT_EMC4021: length 82.9
  TOP w0.102: v1(152.21,140.19) 153.97,138.43 157.01,138.43 157.32,138.75 161.77,138.75 162.31,138.2 164.99,138.2 165.2,137.98 165.21,137.98 165.74,137.45 v2(166.29,137.45) 166.71,137.45 167.82,136.34 U29.7
  IN3 w0.127: v1(100.29,158.35) 100.29,158.36 100.89,158.96 102.11,158.96 103.24,157.83 109.48,157.83 109.69,157.62 110.27,157.62 112.1,155.79 114.77,155.79 v1(115.12,156.14) 115.32,156.35 118.4,156.35 120.58,154.16 126.91,154.16 128.44,152.64 131.86,152.64 132.58,153.36 135.96,153.36 136.36,152.97 141.16,152.97 148.56,145.56 148.56,142.96 151.33,140.19 v1(152.21,140.19)
  BOTTOM w0.102: v1(100.29,158.35) 100.31,158.35 100.29,158.33 99.98,158.33 99.29,159.02 U51.B48 ; v1(115.12,156.14) 115.02,156.25 R854.2
BC_INT#_ECE1117: length 109.5
  TOP w0.102: v2(174.57,114.5) v1(175.47,114.5) JKB1.12 JKB1.11
  IN4 w0.109: v1(175.47,114.5) 173.91,116.06 173.91,128.07 170.53,131.45 166.75,131.45 164.43,133.77 161.12,133.77 160.75,133.4 157.07,133.4 149.77,140.7 149.77,147.53 147.35,149.95 139.03,149.95 133.46,155.51 133.46,155.85 132.8,156.51 131.16,156.51 130.84,156.19 125.84,156.19 125.27,156.76 124.74,156.76 124.59,156.61 113.75,156.61 112.98,155.84 111.32,155.84 110.85,155.36 110.35,155.36 108.3,153.31 108.3,151.2 106.66,149.57 v1(106.66,149.52)
  BOTTOM w0.102: U51.A19 106.5,150.75 106.88,150.37 106.88,149.92 106.66,149.71 v1(106.66,149.52)
BC_INT#_ECE5048: length 170.2
  TOP w0.102: v2(95.73,158.66) 96.54,157.85 v1(96.88,157.85)
  IN1 w0.109: v1(96.88,157.85) 96.05,158.68 96.05,160.08 96.72,160.75 98.27,160.75 98.97,160.05 100.52,160.05 101.36,159.21 102.18,159.21 102.7,159.73 102.7,161.72 102.6,161.82 102.6,163.72 103.25,164.38 105.84,164.38 106.39,163.82 111.21,163.82 112.27,162.76 115.15,162.76 116.97,160.94 116.97,157.15 120.47,153.65 126.98,153.65 128.8,151.83 128.8,151.52 131.85,148.48 136.59,148.48 143.88,141.19 143.88,139.39 153.68,129.58 153.94,129.58 154.76,128.75 154.76,127 160.11,121.66 160.11,120.65 164.74,116.02 164.74,115.52 165.96,114.3 165.96,112.64 169.28,109.32 170.1,109.32 174.81,104.61 175.42,104.61 184.74,95.29 190.39,95.29 194.99,90.69 194.99,90.21 201.83,83.37 206.88,83.37 207.48,82.77 210.19,82.77 210.63,83.2 210.63,84.24 210.93,84.54 211.31,84.54 211.74,84.11 v1(211.74,83.52)
  BOTTOM w0.102: U51.A42 97.69,157.27 97.11,157.85 v1(96.88,157.85) ; v1(211.74,83.52) U46.A29
BC_INT#_EMC4021: length 84.1
  TOP w0.102: v1(148.37,137.22) v2(148.84,137.69) 149.12,137.97 157.58,137.97 157.9,138.29 161.58,138.29 161.98,137.88 161.98,137.48 162.39,137.07 R426.2
  TOP w0.254: R426.2 165.31,137.07 166.6,135.78 U29.9
  IN3 w0.127: v1(148.37,137.22) 144.72,137.22 136.17,145.77 133.35,145.77 131.87,144.28 121.8,144.28 120.63,145.45 114.44,145.45 111.41,148.49 110.83,148.49 108.55,146.2 107.2,146.2 106.92,146.48 101.17,146.48 97.75,149.9 97.75,150.48 97.01,151.23 v1(97.01,152.33)
  BOTTOM w0.102: v1(97.01,152.33) 97.95,153.27 U51.A34
BCM5882_ALERT#: length 328
  TOP w0.102: JUSH1.7 v1(52.05,7.71)
  IN1 w0.109: v1(221.19,80.77) 221.2,80.77 221.7,80.27 221.94,80.27 222.03,80.18 225.05,80.18 225.34,80.47 227.34,80.47 230.43,77.38 238.46,77.38 240.21,79.14 242.19,79.14 242.77,78.56 251.05,78.56 253.39,80.89 261.41,80.89 272.17,70.13 272.17,46.47 262.6,36.9 261.28,36.9 260.55,37.63 258,37.63 257.18,36.81 251.83,36.81 250.65,35.63 236.97,35.63 222.74,21.41 200.46,21.41 199.66,20.6 131.93,20.6 131.34,21.19 106.96,21.19 103.61,24.53 84.24,24.53 83.54,23.83 83.54,23.42 82.29,22.17 82.12,22.17 77.35,17.4 77.35,14.88 73.88,11.41 73.88,9.58 72.81,8.51 52.96,8.51 52.16,7.71 v1(52.05,7.71)
  BOTTOM w0.102: v1(221.19,80.77) 221.69,80.27 U46.B62
BEEP: length 193.6
  TOP w0.102: JIO1.74 14,89.4 v1(14.28,89.11) ; v1(107.07,152.64) 107.07,152.27 107.59,151.75 111.79,151.75 114.38,154.34 114.38,156.46 115.25,157.33 115.25,168.46 v2(115.38,168.6) v1(115.76,168.97)
  IN2 w0.127: v1(14.28,89.11) 14.03,89.37 14.03,91.05 13.06,92.01 13.06,94.68 12.48,95.26 12.48,100.45 11.77,101.16 11.77,104.04 11.07,104.74 11.07,107.57 12.2,108.69 12.2,111.69 13.85,113.34 13.85,113.72 15.39,115.26 15.63,115.26 16.85,116.48 16.85,118.01 15.43,119.43 15.43,125.36 17.36,127.29 20.87,127.29 27.19,133.6 27.19,134.47 32.65,139.93 32.65,143.74 34.9,145.98 38.81,145.98 41.36,148.53 41.36,152.09 43.5,154.24 46.48,154.24 48.05,155.8 49.52,155.8 50.19,156.47 52,156.47 54.72,159.19 61.14,159.19 63.46,161.51 63.46,162.96 65.21,164.7 66.42,164.7 70.13,168.41 87.87,168.41 88.63,167.65 94.14,167.65 97.71,171.22 113.51,171.22 v1(115.76,168.97)
  BOTTOM w0.102: U51.B19 107.25,152.18 107.07,152.36 v1(107.07,152.64)
BIA_PWM_EC: length 75.1
  TOP w0.102: v1(104.38,152.59) v2(104.38,151.98)
  IN3 w0.127: v1(48.17,149.36) 48.17,150.05 47.76,150.45 47.76,151.29 50.99,154.52 50.99,155.48 51.34,155.84 51.8,155.84 52.61,155.03 57.24,155.03 60.65,158.44 62.44,158.44 64.51,160.51 77.62,160.51 78.15,161.05 85.25,161.05 85.94,160.36 86.42,160.36 87.03,160.97 88.15,160.97 90.31,158.81 90.31,154.18 92.04,152.45 94.6,152.45 96.85,154.7 98.03,154.7 98.43,154.29 100.85,154.29 101.23,153.91 101.74,153.91 102.26,153.4 102.26,153.03 102.89,152.4 104.19,152.4 v1(104.38,152.59)
  BOTTOM w0.102: v1(48.17,149.36) D71.2 ; U51.B25 104.25,152.46 v1(104.38,152.59)
BIA_PWM_LVDS: length 9.1
  TOP w0.254: JLVDS1.16 51.54,147.95 v1(51.62,147.86)
  BOTTOM w0.508: 51.62,147.84 51.95,148.17 51.95,149.18 52.36,149.59 R1137.1 53.56,149.95 D66.1 ; 51.62,147.84 v2(51.2,147.41) 50.22,146.43 D68.1 D71.1 ; 51.62,147.84 v1(51.62,147.86)
BIA_PWM_PCH: length 75.8
  TOP w0.102: v1(29.24,105.14) 29.7,104.68 UH1.N36 ; v1(73.62,142.71) R127.2 73.62,140.32 75.19,138.75 75.19,137.27 74.94,137.02 74.18,137.02 67.06,129.91 v2(61.36,129.91) 59.75,129.91 v1(59.72,129.93)
  IN1 w0.109: v1(29.24,105.14) 29.63,105.52 29.63,106.69 31.45,108.52 39,108.52 39.18,108.7 42.2,108.7 42.5,109 46.08,109 46.82,108.27 v1(47.02,108.27)
  BOTTOM w0.102: U23.21 74.29,143.66 74.05,143.42 74.05,143.14 v1(73.62,142.71) ; v1(47.02,108.27) 47.23,108.27 47.73,108.77 47.73,110.25 48.19,110.72 48.19,112.46 49.65,113.92 49.65,113.99 50.25,114.59 51.89,114.59 52.55,115.25 53.07,115.25 57.26,119.44 57.26,127.42 59.75,129.91 v1(59.72,129.93)
BIA_PWM_SW: length 34.7
  IN2 w0.127: v1(70.01,154.19) 71.92,152.28 71.92,146.01 74.1,143.83 74.1,143.14 74.51,142.73 v1(74.56,142.73)
  BOTTOM w0.102: v1(70.01,154.19) 68.79,154.19 65.97,157.01 v2(60.42,157.01) 55.52,152.11 D66.2 ; U23.19 75.09,143.72 74.68,143.32 74.68,142.86 v1(74.56,142.73)
BLK_MOSFET_GC: length 2.5
  BOTTOM w0.254: PR1006.2 156.18,120.56 v2(155.84,120.9) 155.45,121.28 PU1001.30
BLKNG_MOSFET_GC: length 3.1
  BOTTOM w0.254: PU1001.20 150.2,123.87 149.88,124.2
  BOTTOM w0.508: PR1009.2 148.75,125.32 v2(149.44,124.64) 149.88,124.2
BLUE_CRT: length 15
  TOP w0.102: L3.1 76.97,165.39 77.17,165.19 C22.1 R55.1 v1(77.17,162.46)
  BOTTOM w0.102: U19.31 81.8,162.67 81.47,163 78.13,163 78,162.88 78,161.35 77.87,161.22 v2(76.75,161.22) 76.22,161.22 76.09,161.35 76.09,161.73 76.22,161.86 77.05,161.86 77.17,161.99 v1(77.17,162.46)
BLUE_CRT_L: length 7.2
  TOP w0.102: L3.2 76.59,166.92 v2(76.59,167.56) JCRT1.3
BLUE_DOCK: length 48.3
  TOP w0.102: v1(80.25,156.35) 80.15,156.25 80.15,155.38 81.14,154.39 81.14,153.96 83.83,151.27 83.83,148.6 84.54,147.89 84.54,141.95 86.97,139.52 86.97,136.48 88.79,134.66 89.14,134.66 89.68,134.12 89.68,131.85 v2(90.21,131.32) 91.09,130.44 91.09,128.86 91.63,128.33 91.63,124.88 87.64,120.89 87.31,120.89 86.57,120.15 v1(85.3,120.15)
  BOTTOM w0.102: v1(80.25,156.35) 80.65,156.75 U19.22 ; JDOCK1.45 84.2,119.36 85,120.15 v1(85.3,120.15)
BOARD_ID: length 6.1
  TOP w0.102: v1(107.1,156.37) 107.53,155.94 107.83,155.94 108.09,156.2 108.87,156.2 C744.1 v2(110.26,155.74) R875.2
  BOTTOM w0.102: v1(107.1,156.37) 107.53,155.94 108.01,155.94 108.09,156.02 U51.B10
BOOT1:
  vias: v2(54.38,29.45)
BOOT2:
  vias: v2(49.6,26.9)
BOOT3:
  vias: v2(39.4,74.41)
BOOT_1.35V: length 2.2
  BOTTOM w0.203: PR200.2 177.63,73.96 177.63,74.62 177.89,74.88 PU200.18
BQ24737_VDD: length 88.1
  IN1 w0.254: v1(227.55,58.7) 227.55,56.34 226.98,55.76 215.68,55.76 214.61,54.7 213.44,54.7 212.3,55.84 206.03,55.84 205.24,56.63 202.9,56.63 202.12,55.84 197.21,55.84 196.12,54.75 192.95,54.75 192.11,53.91 187.51,53.91 183.83,50.23 v3(180.72,50.23)
  IN1 w0.508: v1(176.69,42.96) 176.67,42.99 176.67,44.28 174.7,46.25 174.7,52.4 172.25,54.85 v3(172.25,55.79)
  IN3 w0.508: v3(180.72,50.23) 180.72,51.94 178.14,54.52 175.52,54.52 174.15,55.89 172.35,55.89 v3(172.25,55.79)
  BOTTOM w0.254: v1(227.55,58.7) 227.87,59.01 PR738.1 ; PU700.16 180.38,49.5 180.72,49.83 v3(180.72,50.23)
  BOTTOM w0.508: PC745.1 181.96,50.48 PD703.2 180.84,50.35 v3(180.72,50.23) ; v3(172.25,55.79) 172.25,56.37 v2(171.73,56.88) PR772.1 ; PR771.1 176.67,42.99 v1(176.69,42.96)
BREATH_LED#: length 252.7
  IN3 w0.127: v1(42.92,149.18) 42.86,149.12 42.86,142.43 45.93,139.36 46.88,139.36 47.75,140.23 47.75,140.73 48.99,141.97 49.62,141.97 50.88,143.23 52.45,143.23 54.29,145.07 55.85,145.07 58.69,147.91 67.27,147.91 71.75,152.39 76.79,152.39 77.99,151.19 79.41,151.19 81.39,149.21 85.35,149.21 90.25,144.3 90.25,138.94 98.71,130.48 98.71,129.78 99.25,129.24 v1(99.25,129.23) 99.25,127.66 103.51,123.39 103.51,121.27 106.41,118.37 108.7,118.37 112.43,114.64 123.96,114.64 124.48,115.16 130.31,115.16 130.83,114.64 144.71,114.64 150.38,108.96 159.74,108.96 173.74,94.97 178.28,94.97 179.87,93.38 192.36,93.38 199.32,86.42 208.06,86.42 209.26,85.23 211.97,85.23 212.67,84.53 214.91,84.53 215.25,84.19 215.88,84.19 v1(216.32,84.62)
  BOTTOM w0.102: Q344.1 21.26,149.67 Q344.4 21.41,149.07 21.8,148.68 22.72,148.68 23.38,149.34 27.4,149.34 28.08,148.66 30.72,148.66 32.45,146.92 v2(39.63,146.92) 40.56,146.92 42.82,149.18 v1(42.92,149.18) ; JDOCK1.98 99.2,129.18 v1(99.25,129.23) ; v1(216.32,84.62) 215.88,85.05 215.88,85.55 215.92,85.58 U46.B39
BREATH_LED#_Q: length 84.7
  TOP w0.102: v1(15.55,85.2) v2(16.09,84.67) 16.49,84.26 16.49,83.86 14.24,81.6 JIO1.100
  IN2 w0.127: v1(18.12,149.74) 15.02,149.74 13.27,147.99 13.27,142.23 14.49,141.01 14.49,139.05 13.88,138.44 13.88,134.93 12.07,133.13 12.07,126.71 14.92,123.86 14.92,119.22 16.34,117.8 16.34,116.69 15.42,115.77 15.18,115.77 13.34,113.93 13.34,113.55 10.88,111.08 10.88,108.44 10.57,108.13 10.57,104.53 11.01,104.09 11.01,101.2 11.82,100.39 11.82,95.2 12.56,94.46 12.56,91.8 13.52,90.83 13.52,85.43 14.18,84.77 15.27,84.77 15.55,85.05 v1(15.55,85.2)
  BOTTOM w0.102: R956.2 18.47,150.1 v1(18.12,149.74)
BREATH_WHITE_LED: length 296.2
  TOP w0.102: v1(251.04,106.3) JPB1.4
  IN2 w0.127: v1(61.98,161.35) 60.41,161.35 59.58,160.51 54.6,160.51 51.58,157.49 48.3,157.49 46.37,155.56 43.39,155.56 40.34,152.52 40.34,148.95 38.39,147 27.31,147 26.37,147.94 v1(26.37,150.07)
  IN3 w0.127: v1(251.04,106.3) 251.39,105.95 251.39,101 246.64,96.25 235.06,96.25 232.84,94.03 226.97,94.03 226.14,93.2 210.65,93.2 209.03,94.83 203.34,94.83 197.34,100.82 181.23,100.82 175.88,106.17 175.88,107.09 174.25,108.71 174.25,117.5 166.76,125 166.76,127.61 164.31,130.06 161.2,130.06 158.56,132.71 158.56,139.47 155.53,142.5 155.53,145.03 153.28,147.28 153.28,148.83 151.06,151.05 150.02,151.05 143.44,157.63 140.54,157.63 136.05,162.13 128.93,162.13 128.6,162.45 125.71,162.45 123.54,164.63 116.94,164.63 115.15,162.84 112.69,162.84 111.34,164.2 102.02,164.2 101.63,163.82 89.73,163.82 89.26,163.35 78.76,163.35 77.11,161.69 75.98,161.69 75.81,161.53 73.52,161.53 73.34,161.71 72.98,161.71 72.73,161.45 62.09,161.45 v1(61.98,161.35)
  BOTTOM w0.102: v1(251.04,106.3) v2(251.04,106.98) ; v1(26.37,150.07) 23.28,150.07 R955.2
BST1_3V: length 1.8
  BOTTOM w0.102: 252.13,59.09 253.02,59.09 v2(253.67,59.74)
BST1_5V: length 1.5
  BOTTOM w0.102: PC111.1 v2(240.55,59.6)
BST_3V:
  vias: v2(249.27,58.96)
BST_5V: length 1.6
  BOTTOM w0.102: PR107.1 243.49,57.5 v2(244.13,56.87)
BST_+1.05VSP: length 1.1
  BOTTOM w0.102: PR301.1 18.7,144.63 18.54,144.79 18.54,145.22 v2(18.58,145.26)
BST_CHG: length 6.7
  BOTTOM w0.102: PD703.1 184.24,51.26 v2(184.67,51.69)
  BOTTOM w0.254: PU700.17 180.44,49 180.63,49.19 181.47,49.19 181.87,48.78 PR765.1
  BOTTOM w0.508: PD703.1 183.79,50.35 PR765.1
BST_CHG_IMON: length 244
  TOP w0.102: v1(192.87,97.5) 194.6,97.5 198.05,94.04 198.05,93.31 198.75,92.61 199.54,92.61 203.49,88.66 203.49,83.04 209.61,76.92 209.61,74.48 v1(209.71,74.38)
  IN3 w0.127: v1(104.25,159.4) 104.57,159.08 106.78,159.08 106.78,159.08 109.34,159.08 109.57,158.85 111.97,158.85 112.66,158.16 115.44,158.16 116.32,157.29 124.85,157.29 126.28,155.85 130.62,155.85 131.56,154.91 137.72,154.91 137.86,154.78 140.06,154.78 149.75,145.09 149.75,143.64 153.55,139.85 153.55,138.94 155.42,137.07 155.42,127.91 158.26,125.07 158.26,124.04 163.29,119.01 167.29,119.01 168.4,117.9 168.4,110.06 180.56,97.9 192.46,97.9 v1(192.87,97.5) ; v1(209.71,74.38) 209.71,73.44 209.84,73.32 209.84,64.15 208.59,62.9 208.59,59.15 215.88,51.86 215.88,46.9 212.37,43.38 197.49,43.38 195.77,45.11 177.62,45.11 176.28,46.45 174.29,46.45 173.61,47.13 171.83,47.13 170.72,46.02 169.24,46.02 168.87,46.39 168.66,46.39 168,47.05 v1(167.8,47.05)
  BOTTOM w0.102: PR705.1 167.42,47.43 v1(167.8,47.05) ; v1(209.71,74.38) 210.07,74.03 v2(210.07,73.96) ; U51.B61 104.25,160.62 104.32,160.55 104.32,159.46 v1(104.25,159.4)
BST_CHG_MODE#: length 43.1
  IN2 w0.127: v1(214.92,77.41) 214.92,75.74 215.13,75.52 216.9,75.52 217.12,75.31 217.12,73.44 216.7,73.02 216.7,72.07 215.64,71.02 209.39,71.02 206.49,73.91 v1(206.09,73.91)
  IN3 w0.127: v1(206.09,73.91) v1(206.09,65.63)
  BOTTOM w0.102: U46.B15 v1(214.92,77.41)
  BOTTOM w0.254: v1(206.09,65.63) 206.09,63.02 v2(211.14,57.97) 212.1,57.01 212.64,57.01 213.15,57.52 213.15,57.9 213.43,58.18 PR718.2 214.7,58.18 PR716.2
BT_LED: length 84.6
  TOP w0.102: JIO1.94 14.28,83.4 v1(14.89,84.01)
  IN2 w0.127: v1(11.15,152.64) 12.53,151.26 12.53,142.24 13.98,140.8 13.98,139.26 13.37,138.65 13.37,135.14 11.57,133.34 11.57,126.5 14.41,123.65 14.41,119.01 15.83,117.59 15.83,116.9 15.21,116.28 14.97,116.28 13.42,114.73 12.56,114.73 11.24,113.4 11.24,112.28 8.9,109.94 8.9,104.02 10.5,102.42 10.5,95.69 10.89,95.3 10.89,93.79 11.87,92.81 11.87,91.77 12.99,90.65 12.99,84.72 14.13,83.58 14.49,83.58 14.89,83.98 v1(14.89,84.01)
  BOTTOM w0.102: R941.2 v1(11.15,152.64) 12.06,152.64 v2(12.98,153.55)
BT_LED#: length 5.2
  BOTTOM w0.102: R725.1 147.8,162.02 Q89.3 146.89,160.96 v2(146.55,160.62) 145.67,159.74 JMINI4.46
BT_LED#_Q: length 189.2
  IN3 w0.127: v1(14.89,147.2) 14.26,147.84 13.37,147.84 12.62,147.09 11.04,147.09 9.91,148.22 9.91,152 14.23,156.32 14.23,161.83 18.09,165.69 20.83,165.69 21.7,166.56 24.49,166.56 25.33,167.4 38.41,167.4 42.12,163.68 42.12,155.89 42.91,155.1 47.38,155.1 48.01,155.74 50.52,155.74 51.13,156.35 55.45,156.35 56.57,157.47 58.6,157.47 60.59,159.46 61.06,159.46 61.88,160.28 61.88,160.79 61.53,161.15 61.53,161.52 61.78,161.77 70.99,161.77 74.28,165.06 77.4,165.06 78.23,164.24 88.9,164.24 89.36,164.7 92.82,164.7 96.63,168.51 105.88,168.51 108.42,171.05 122.71,171.05 123.73,170.04 139.12,170.04 149.7,159.46 v1(149.7,159.34)
  BOTTOM w0.102: v1(14.89,147.2) 14.89,147.64 v2(14.73,147.79) R938.2 13.09,148.78 11.07,150.8 Q318.3 ; Q89.1 v1(149.7,159.34)
BT_RADIO_DIS#: length 148.8
  TOP w0.102: v1(134.58,160.69) v2(133.8,160.69) 132.73,160.69 D30.1
  IN1 w0.109: v1(204.48,85.41) 202.64,85.41 197.01,91.03 197.01,94 192.67,98.35 185.81,98.35 176.98,107.17 175.81,107.17 172.04,110.95 171.67,110.95 171.15,111.47 171.15,112.23 171.81,112.89 171.81,119.49 169.69,121.62 169.69,127.14 167.06,129.76 167.06,131.3 165.75,132.61 158.99,132.61 154.55,137.04 154.55,139.24 149.83,143.96 149.83,146.19 150.58,146.94 150.58,148.45 148.75,150.28 147.09,150.28 139.67,157.69 137.58,157.69 v1(134.58,160.69)
  BOTTOM w0.102: v1(204.48,85.41) 204.48,80.99 205.19,80.27 205.19,79.51 204.63,78.95 204.63,73.85 207.86,70.62 212.43,70.62 214.84,73.04 214.84,73.39 215.67,74.22 U46.A13
BT_RADIO_DIS#_R: length 10.1
  TOP w0.102: v1(137.96,161.71) 137.5,162.16 v2(136.74,162.16) 135,162.16 134.11,161.28 131.91,161.28 D30.2 130.45,160.95 R696.1
  BOTTOM w0.102: JMINI4.51 137.92,161.74 v1(137.96,161.71)
CAM_MIC_CBL_DET#: length 99.1
  TOP w0.102: v1(51.35,149.85) 51.25,149.95 JLVDS1.12 ; v1(28.65,95.42) 28.95,95.72 UH1.L15
  IN2 w0.089: v1(28.65,95.42) 28.25,95.82 26.58,95.82
  IN2 w0.127: 26.58,95.82 26.02,95.26 25.66,95.26 24.6,94.19 22.48,94.19 22.46,94.17 20.97,94.17 20.1,95.04 20.1,95.23 19.77,95.56 19.77,96.82 19.34,97.25 19.34,101.09 17.84,102.58 17.84,106.37 17.98,106.5 17.98,108.72 20.69,111.43 20.69,113.77 21.28,114.36 21.28,114.65 22.88,116.25 23.27,116.25 26.73,119.71 26.73,123.82 27.11,124.2 27.11,127.87 29.53,130.29 36.15,130.29 43.84,137.98 45.5,137.98 47.33,139.81 47.33,140.47 48.95,142.1 49.34,142.1 51.05,143.81 51.05,149.54 v1(51.35,149.85)
  BOTTOM w0.102: v1(28.65,95.42) 28.25,95.82 26.48,95.82 26.12,95.46 25.71,95.46 23.92,97.26 22.3,97.26 21.23,98.32 19.95,98.32 19.3,98.97 v2(18.96,98.97) RH86.2
CARD_SMBCLK: length 164.1
  TOP w0.102: v1(14.46,107.99) 14.29,107.81 14.07,107.81 13.89,108 JIO1.12
  IN1 w0.109: v1(92.77,166.58) 92.97,166.78 92.97,167.18 90.61,169.53 66.89,169.53 59.34,161.99 55.58,161.99 53.24,164.33 53.24,165.29 50.19,168.34 45.04,168.34 44.48,167.78 26.23,167.78 24.8,166.35 21.46,166.35 20.83,165.72 18.53,165.72 14.11,161.3 14.11,156.12 12.41,154.43 12.41,152.95 11.62,152.16 11.62,149.39 10.84,148.61 10.84,147.17 12.46,145.55 12.46,143.02 13.99,141.49 13.99,135.26 12.18,133.44 12.18,126.07 14.82,123.43 14.82,119.14 16.06,117.89 16.06,116.83 13.24,114.01 13.24,111.59 13.6,111.24 13.6,108.29 14.08,107.8 14.28,107.8 v1(14.46,107.99)
  BOTTOM w0.102: U51.A49 100,162.26 99.91,162.35 99.91,163.76 99.12,164.55 99.12,166.2 97.44,167.88 93.81,167.88 92.95,167.02 92.95,166.76 v1(92.77,166.58)
CARD_SMBDAT: length 165.4
  TOP w0.102: v1(14.46,107.38) 14.26,107.59 14.06,107.59 13.88,107.4 JIO1.14
  IN1 w0.109: v1(14.46,107.38) 14.28,107.57 13.98,107.57 13.36,108.19 13.36,111.14 13.01,111.49 13.01,114.1 15.83,116.92 15.83,117.79 14.58,119.04 14.58,123.33 11.94,125.97 11.94,133.54 13.76,135.36 13.76,141.39 12.23,142.92 12.23,145.45 10.6,147.08 10.6,148.71 11.38,149.49 11.38,152.25 12.18,153.05 12.18,154.53 13.87,156.22 13.87,161.4 18.43,165.96 20.74,165.96 21.36,166.58 24.7,166.58 26.13,168.01 44.39,168.01 44.94,168.57 50.29,168.57 53.48,165.39 53.48,164.42 55.68,162.22 59.24,162.22 66.79,169.77 90.71,169.77 93.2,167.27 93.2,166.79 v1(93.4,166.58)
  BOTTOM w0.102: v1(93.4,166.58) 93.18,166.81 93.18,166.92 93.91,167.65 97.35,167.65 98.89,166.11 98.89,164.45 99.68,163.66 99.68,161.55 99.75,161.48 U51.B52
CARDCLK_REQ#: length 76.2
  TOP w0.102: v1(36.84,81.39) 36.74,81.49 RH120.2 37.19,82.46 37.19,85.18 37.3,85.28 37.3,86.32 36.97,86.65 36.71,86.65 v2(36.57,86.79) 35.72,87.64 35.72,88.15 35.42,88.45 35.42,89.61 35.47,89.66 35.47,89.91 35.29,90.09 35.28,90.09 35.26,90.11 35.26,90.59 UH1.AF3 ; RH22.1 17.26,113.32 16.09,113.32 15.66,112.89 15.15,112.89 14.44,113.6 12.76,113.6 v1(11.92,112.76) 10.98,111.82 9.76,111.82 9.05,112.53 8.39,112.53 7.85,111.99 JIO1.1
  IN4 w0.109: v1(11.92,112.76) 11.69,112.53 11.69,112.09 10.59,110.99 10.59,110.96 9.21,109.58 9.21,103.72 10.63,102.31 10.63,93.64 11.79,92.49 11.79,92.49 13.87,90.41 14.54,90.41 15.91,89.04 15.91,88.48 17.74,86.65 18.58,86.65 19.41,85.82 19.41,85.38 20.03,84.76 24.93,84.76 25.89,83.8 26.18,83.8 27.08,82.9 33.75,82.9 35.4,81.25 36.7,81.25 v1(36.84,81.39)
CCD_OFF: length 202.5
  TOP w0.102: Q24.2 59.62,148.07 58.66,149.03 58.66,150.63 58.35,150.94 58.35,152.04 v2(58.84,152.52) v1(58.84,153.27)
  IN3 w0.127: v1(58.84,153.27) 58.84,153.4 61.45,156.02 79.02,156.02 80.17,154.87 81.3,154.87 81.91,155.48 84.55,155.48 85.71,154.33 85.71,154.01 92.97,146.75 92.97,146.31 102.47,136.82 105.83,136.82 112.4,130.24 144.71,130.24 147.53,127.42 147.53,124.04 148.52,123.05 148.52,117.83 151.26,115.1 152.96,115.1 155.77,112.29 156.88,112.29 158.86,110.31 159.83,110.31 170.16,99.99 174.42,99.99 180.26,94.14 192.79,94.14 199.7,87.23 211.16,87.23 212.66,85.74 217.2,85.74 217.71,85.23 v1(217.71,85.2)
  BOTTOM w0.102: U46.B43 217.92,85.41 v1(217.71,85.2)
CD3301_DCIN: length 4.7
  BOTTOM w0.203: 153.94,116.58 153.7,116.82 PU1001.1
  BOTTOM w0.508: PR1011.2 156.23,114.83 PC1006.1 154.4,115.35 153.94,115.82 v2(153.94,115.99) 153.94,116.58
CD3301_NBDOCK_DC_IN_SS: length 130.2
  IN1 w0.109: v1(146.57,125.69) 146.35,125.47 146.35,115.61 146.16,115.43 146.16,113.51 146.92,112.76 146.92,109.1 154.51,101.51 159.91,101.51 177.58,83.83 179.2,83.83 179.43,84.06 181.4,84.06 184.41,81.04 195.86,81.04 205.31,71.59 210.94,71.59 213.03,73.69 214.57,73.69 215.06,73.2 221.31,73.2 222.81,71.71 225.73,71.71 226.52,72.5 235.37,72.5 v1(235.94,73.08)
  BOTTOM w0.102: PR1070.2 v1(235.94,73.08) ; PR1024.1 v1(146.57,125.69) 146.43,125.69 v2(146.06,125.32)
  BOTTOM w0.254: PR1024.1 147.74,125.54 149.7,123.57 PU1001.19
CD3301_SDC_IN: length 2.5
  BOTTOM w0.254: PR1015.2 151.2,115.02 PU1001.6
CD_PBATT_OFF: length 3.2
  BOTTOM w0.254: PU1001.26 153.2,123.81 v2(153.96,124.56) 154.85,125.45 PR1016.1
CFD_PWRBTN#_XDP: length 4.1
  TOP w0.102: v2(72.34,9.79) 71.7,10.43 v1(71.7,10.45) JXDP1.41
  BOTTOM w0.102: RC6.2 72.17,11.31 71.7,10.84 v1(71.7,10.45)
CFG0: length 109.2
  TOP w0.102: v2(63.13,9.78) 63.7,10.34 v1(63.7,10.42) JXDP1.9 ; JCPU1.AT20 87.59,75.3 v1(87.15,75.74)
  IN4 w0.109: v1(87.15,75.74) 88.52,74.37 88.52,70.71 89.17,70.06 93.01,70.06 94.83,68.25 94.83,53.07 95.61,52.28 103.31,52.28 103.51,52.08 103.51,51.62 103.64,51.5 103.64,48.93 103.56,48.85 103.56,46.24 103.67,46.14 103.67,39.1 101.68,37.12 95.96,37.12 92.41,33.57 92.41,31.39 87.4,26.38 84.19,26.38 79.79,21.98 79.79,19.44 77.54,17.19 77.54,15.72 72.89,11.07 70.43,11.07 69.3,9.94 64.17,9.94 v1(63.7,10.42)
CFG1: length 100.4
  TOP w0.102: JCPU1.AR20 87.59,74.29 v1(87.14,74.74) ; v2(64.96,9.68) 64.3,10.34 v1(64.3,10.45) 64.2,10.55 JXDP1.11
  IN4 w0.109: v1(64.3,10.45) 65.63,11.78 72.59,11.78 76.64,15.83 76.64,17.29 79.08,19.74 79.08,22.27 83.89,27.09 85.8,27.09 86.52,27.81 86.52,28.68 95.75,37.91 98.94,37.91 100.64,39.61 100.64,48.98 100.36,49.26 95.46,49.26 93.63,51.09 93.23,51.09 92.85,51.47 92.85,67.52 91.79,68.59 89.05,68.59 87.55,70.09 87.55,72.91 87.22,73.24 87.03,73.24 86.7,73.57 86.7,74.31 v1(87.14,74.74)
CFG2: length 101.5
  TOP w0.102: v1(87.14,73.75) 87.59,73.3 JCPU1.AP20 ; JXDP1.15 v1(65.2,10.45)
  IN4 w0.109: v1(65.2,10.45) 66.29,11.54 72.69,11.54 76.88,15.73 76.88,17.2 79.32,19.64 79.32,22.18 83.99,26.85 86.69,26.85 87.56,27.72 87.56,29.39 95.77,37.59 100.38,37.59 101.66,38.87 101.66,49.95 101.35,50.25 95.92,50.25 94.04,52.13 94.04,67.92 92.96,69 89.14,69 87.88,70.26 87.88,73 v1(87.14,73.75)
  BOTTOM w0.102: v1(65.2,10.45) 65.19,10.46 v2(65.19,10.97) RC76.1
CFG3: length 97.4
  TOP w0.102: v1(65.44,14.54) 65.7,14.29 JXDP1.17 ; v1(85.16,73.75) 85.59,73.31 JCPU1.AP22
  IN4 w0.109: v1(85.16,73.75) 84.54,73.13 84.54,70.22 88.02,66.74 88.02,51.3 90.39,48.92 90.83,48.92 93.99,45.76 94.8,45.76 95.54,45.02 95.54,39.37 86.75,30.58 85.38,30.58 76.25,21.45 76.25,20.03 72.99,16.77 72.17,16.77 71.8,16.4 71.8,15.72 71.59,15.51 71.59,14.79 70.86,14.06 70.01,14.06 69.53,14.54 v1(65.44,14.54)
  BOTTOM w0.102: RC64.2 R566.1 74.77,15.92 74.05,15.2 v2(66.81,15.2) 66.1,15.2 v1(65.44,14.54)
CFG3_R: length 4.1
  TOP w0.102: JXDP1.60 v1(76.2,19.17) 76.6,19.17 v2(76.96,19.53)
  BOTTOM w0.102: RC64.1 75.66,18.64 v1(76.2,19.17)
CFG4: length 104.3
  TOP w0.102: JXDP1.27 v1(68.2,10.45) ; JCPU1.AT22 85.59,75.35 v1(85.17,75.78)
  IN4 w0.109: v1(68.2,10.45) 69.05,11.31 72.79,11.31 77.3,15.82 77.3,17.29 79.55,19.54 79.55,22.08 84.09,26.61 87.23,26.61 89.61,28.99 89.61,31.1 95.87,37.36 100.6,37.36 102.6,39.36 102.6,50.94 102.27,51.27 95.8,51.27 94.51,52.56 94.51,67.93 92.83,69.61 89.09,69.61 88.19,70.51 88.19,74.28 87.21,75.27 85.68,75.27 85.17,75.77 85.17,75.78 v1(85.17,75.78)
  BOTTOM w0.102: v1(68.2,10.45) 68.2,10.67 v2(67.93,10.93) 67.73,11.14 RC77.1
CFG5: length 83.1
  TOP w0.102: v1(85.16,72.75) 85.59,72.32 JCPU1.AN22 ; JXDP1.29 v1(68.7,13.45)
  IN4 w0.109: v1(85.16,72.75) 84.77,72.36 84.77,70.42 88.65,66.54 89.81,66.54 91.5,64.85 91.5,48.98 93.75,46.73 94.48,46.73 95.97,45.25 96.27,45.25 96.58,44.94 96.58,39.66 96.27,39.36 95.86,39.36 86.85,30.35 85.48,30.35 76.84,21.7 76.84,19.21 74.2,16.57 74.2,16.07 73.15,15.02 72.16,15.02 70.96,13.82 69.91,13.82 69.85,13.88 69.12,13.88 v1(68.7,13.45)
  BOTTOM w0.102: v1(68.7,13.45) 68.7,13.15 v2(69.19,12.66)
CFG6: length 89.8
  TOP w0.102: JXDP1.33 v1(69.7,13.45) ; JCPU1.AT25 v1(82.12,75.75)
  IN4 w0.109: v1(82.12,75.75) 82.12,75.75 81.62,75.25 81.06,75.25 80.68,74.86 80.68,74.71 80.32,74.36 79.18,74.36 78.65,73.82 78.65,65.54 78.9,65.29 80.3,65.29 80.58,65.01 80.58,43.7 81.03,43.24 84.36,43.24 84.73,42.87 84.73,37.46 80.45,33.18 80.45,29.33 73.66,22.53 73.66,22.27 71.92,20.53 64.93,20.53 v1(63.61,19.21)
  BOTTOM w0.102: v1(63.61,19.21) 63.61,19.19 64.47,18.32 v2(64.47,17.82) 64.47,14.79 65.29,13.98 69.16,13.98 v1(69.7,13.45)
CFG7: length 80.7
  TOP w0.102: JCPU1.AN23 84.59,72.29 v1(84.14,72.75) ; JXDP1.35 v1(70.2,14.49)
  IN4 w0.109: v1(70.2,14.49) 70.2,14.72 70.7,15.23 70.98,15.23 71.56,15.81 71.56,16.5 72.07,17 72.9,17 76.02,20.12 76.02,21.55 82.82,28.35 82.82,30.87 83.49,31.55 83.49,32.8 85.5,34.8 89.74,34.8 94.65,39.71 94.65,45.04 94.27,45.43 93.86,45.43 90.84,48.45 90.28,48.45 87.65,51.08 87.65,66.69 83.74,70.59 83.74,72.35 v1(84.14,72.75)
  BOTTOM w0.102: v2(69.55,14.74) 69.81,14.49 v1(70.2,14.49)
CFG8: length 83.2
  TOP w0.102: v1(63.92,16.17) 63.7,16.38 JXDP1.10 ; JCPU1.AR24 v1(83.12,74.75)
  IN4 w0.109: v1(83.12,74.75) 82.61,74.23 82.61,73.62 82.33,73.34 81.82,73.34 81.52,73.04 81.52,69.73 81.97,69.28 82.3,69.28 82.61,68.97 82.61,68.54 82.94,68.21 83.7,68.21 84.26,67.65 84.26,47.25 85.23,46.29 88.3,46.29 88.73,45.86 88.73,44.97 89.62,44.08 89.62,39.69 87.13,37.2 86.22,37.2 81.63,32.61 81.63,28.84 74.84,22.04 74.84,20.62 72.66,18.44 66.19,18.44 v1(63.92,16.17)
  BOTTOM w0.089: v1(83.12,74.75) 83.12,74.8 v2(82.7,75.22)
CFG9: length 80.9
  TOP w0.102: v1(84.14,75.75) 84.15,75.75 84.59,75.3 JCPU1.AT23 ; JXDP1.12 v1(64.2,19.19) v2(64.2,19.87)
  IN4 w0.109: v1(64.2,19.19) 65.29,20.28 72,20.28 73.89,22.18 73.89,22.43 80.69,29.23 80.69,33.08 85.73,38.13 85.73,43.8 85.36,44.18 82.74,44.18 81.64,45.27 81.64,65.82 81.26,66.2 79.84,66.2 79.51,66.53 79.51,73.77 79.89,74.15 81.19,74.15 81.62,74.59 81.62,74.84 81.95,75.17 83.56,75.17 v1(84.14,75.75)
CFG10: length 94.9
  TOP w0.102: JCPU1.AN20 87.59,72.3 v1(87.14,72.75) ; v1(67.34,13.47) 67.34,13.93 65.2,16.08 JXDP1.16
  IN4 w0.109: v1(67.34,13.47) 68.31,12.51 70.65,12.51 72.45,14.31 73.45,14.31 74.91,15.77 74.91,16.28 78.27,19.64 78.27,22.13 85.65,29.51 87.02,29.51 96.1,38.59 98.61,38.59 99.68,39.66 99.68,47.97 99.35,48.3 95.72,48.3 93.81,50.2 92.97,50.2 92.45,50.72 92.45,67.26 91.42,68.3 88.84,68.3 86.7,70.44 86.7,72.31 v1(87.14,72.75)
  BOTTOM w0.089: v1(87.14,72.75) 87.29,72.75 v2(87.63,73.09)
CFG11: length 81.5
  TOP w0.102: JXDP1.18 v1(65.7,16.17) ; JCPU1.AP24 v1(83.12,73.75)
  IN4 w0.109: v1(65.7,16.17) 67.73,18.2 72.76,18.2 75.07,20.52 75.07,21.94 81.87,28.74 81.87,32.51 86.32,36.96 87.91,36.96 90.56,39.61 90.56,45.22 89.19,46.59 85.53,46.59 84.51,47.61 84.51,67.93 82.25,70.19 82.08,70.19 81.72,70.55 81.72,72.91 81.95,73.14 82.51,73.14 v1(83.12,73.75)
  BOTTOM w0.102: v2(65.08,15.82) 65.43,16.17 v1(65.7,16.17)
CFG12: length 72.6
  TOP w0.102: v2(67.43,19.73) 67.95,19.21 v1(68.2,19.21) JXDP1.28 ; v1(81.12,73.75) JCPU1.AP26
  IN4 w0.109: v1(68.2,19.21) 69.01,20.03 72.08,20.03 74.13,22.08 74.13,22.34 80.93,29.13 80.93,32.98 86.65,38.71 86.65,43.85 86.03,44.47 84.26,44.47 82.63,46.09 82.63,65.85 82.2,66.28 81.72,66.28 81.52,66.48 81.52,66.94 81.16,67.3 80.93,67.3 80.58,67.65 80.58,67.85 80.22,68.21 79.99,68.21 79.71,68.49 79.71,73.01 79.97,73.26 80.64,73.26 v1(81.12,73.75)
CFG13: length 77.9
  TOP w0.102: JXDP1.30 v1(68.7,16.17) ; JCPU1.AN25 v1(82.12,72.75)
  IN4 w0.109: v1(68.7,16.17) 70.49,17.96 72.85,17.96 75.31,20.42 75.31,21.85 82.11,28.64 82.11,32.41 86.42,36.72 88.64,36.72 91.58,39.66 91.58,44.97 89.7,46.85 85.68,46.85 84.77,47.76 84.77,68.18 82.51,70.44 82.51,72.36 v1(82.12,72.75)
  BOTTOM w0.102: v1(68.7,16.17) 68.7,16.47 v2(68.97,16.74)
CFG14: length 72.3
  TOP w0.102: v2(69.19,19.63) 69.54,19.27 v1(69.54,19.21) 69.7,19.06 JXDP1.34 ; v1(81.12,72.75) JCPU1.AN26
  IN4 w0.109: v1(81.12,72.75) 80.73,72.36 80.73,69.54 80.97,69.3 81.24,69.3 81.59,68.95 81.59,68.64 82.03,68.21 82.25,68.21 82.69,67.78 82.69,67.6 82.97,67.32 83.27,67.32 84.01,66.58 84.01,46.77 84.67,46.11 84.67,45.57 84.99,45.25 87.61,45.25 88.53,44.33 88.53,39.58 86.6,37.65 86.34,37.65 81.4,32.71 81.4,28.94 74.6,22.14 74.6,20.71 72.56,18.67 70.08,18.67 v1(69.54,19.21)
CFG15: length 72.6
  TOP w0.102: v1(70.14,19.21) 70.2,19.16 JXDP1.36 ; JCPU1.AP25 v1(82.12,73.75)
  IN4 w0.109: v1(70.14,19.21) 70.44,18.91 72.46,18.91 74.36,20.81 74.36,22.24 81.16,29.03 81.16,32.89 87.61,39.34 87.61,43.9 87.17,44.35 86.84,44.35 86.46,44.72 84.57,44.72 83.73,45.56 83.73,65.92 83.4,66.25 82.94,66.25 82.61,66.58 82.61,66.89 82.25,67.24 81.95,67.24 81.64,67.55 81.64,67.96 81.36,68.24 81.01,68.24 80.53,68.72 80.53,72.78 81.01,73.26 81.24,73.26 81.72,73.75 v1(82.12,73.75)
  BOTTOM w0.102: v2(69.83,19.94) 70.14,19.63 v1(70.14,19.21)
CFG16: length 94.6
  TOP w0.102: v1(86.2,74.75) 86.59,74.35 JCPU1.AR21 ; JXDP1.6 v1(62.7,16.17)
  IN4 w0.109: v1(86.2,74.75) 85.56,74.11 85.56,70.21 88.6,67.16 89.58,67.16 91.74,65.01 91.74,49.5 93.05,48.19 93.99,48.19 95.84,46.34 97.19,46.34 97.65,45.88 97.65,39.69 97.06,39.1 95.94,39.1 86.82,29.98 85.45,29.98 77.07,21.6 77.07,19.12 74.43,16.48 74.43,15.97 73.25,14.78 72.25,14.78 70.46,12.99 68.56,12.99 68.23,13.32 68.23,13.54 67.63,14.14 66.13,14.14 66.07,14.08 64.78,14.08 v1(62.7,16.17)
  BOTTOM w0.102: v1(62.7,16.17) v2(62.7,17.14)
CFG17: length 97
  TOP w0.102: v1(62.09,16.17) 62.2,16.27 JXDP1.4 ; JCPU1.AP21 86.59,73.35 v1(86.2,73.75)
  IN4 w0.109: v1(86.2,73.75) 85.81,73.36 85.81,70.43 88.56,67.68 89.45,67.68 92.07,65.05 92.07,50.24 93.15,49.16 94.04,49.16 95.89,47.31 98.23,47.31 98.61,46.92 98.61,39.53 97.93,38.85 96.02,38.85 86.92,29.75 85.55,29.75 77.5,21.69 77.5,19.21 74.67,16.38 74.67,15.87 73.35,14.55 72.35,14.55 70.56,12.75 68.47,12.75 68,13.22 68,13.44 67.54,13.9 67.12,13.9 66.86,13.65 66.86,13.55 66.38,13.07 64.52,13.07 63.97,13.63 63.97,14.29 v1(62.09,16.17)
  BOTTOM w0.102: v1(62.09,16.17) v2(62.09,15.45)
CFG18: length 84.4
  TOP w0.102: JXDP1.24 67.2,16.31 v1(67.34,16.17) ; v1(84.14,74.75) 84.59,74.3 JCPU1.AR23
  IN4 w0.109: v1(84.14,74.75) 84.14,74.75 83.52,74.14 83.52,73.59 83.09,73.16 82.99,73.16 82.74,72.91 82.74,70.57 85.02,68.29 85.02,47.92 85.84,47.1 90.64,47.1 92.59,45.15 92.59,39.63 89.44,36.49 86.51,36.49 82.34,32.32 82.34,28.54 75.55,21.75 75.55,20.32 72.95,17.73 71.17,17.73 69.85,16.41 69.85,16.14 69.45,15.73 67.78,15.73 v1(67.34,16.17)
  BOTTOM w0.102: v2(67.13,17.05) 67.34,16.84 v1(67.34,16.17)
CFG19: length 83.8
  TOP w0.102: JCPU1.AP23 84.59,73.29 v1(84.14,73.75) ; JXDP1.22 v1(66.7,16.18)
  IN4 w0.109: v1(84.14,73.75) 83.52,73.13 83.52,70.32 85.28,68.57 85.28,49.76 85.76,49.28 86.78,49.28 88.71,47.36 91.3,47.36 93.58,45.07 93.58,39.63 88.98,35.04 85.4,35.04 83.26,32.9 83.26,31.65 82.58,30.97 82.58,28.45 75.78,21.65 75.78,20.22 73.05,17.49 71.26,17.49 70.09,16.31 70.09,16.04 69.55,15.5 67.38,15.5 v1(66.7,16.18)
  BOTTOM w0.089: v1(84.14,73.75) 84.1,73.75 v2(83.65,73.3)
CFG_RCOMP: length 4.2
  TOP w0.254: JCPU1.AT31 76.59,77.93 77.25,78.59 RC58.1
CHARGER_SMBCLK: length 195.6
  TOP w0.102: RP5.6 101.64,164.71 101.51,164.58 101.51,164.3 100.92,163.71 100.32,163.71 99.04,162.43 99.04,159.27 99.65,158.66 99.77,158.66 100.31,159.21 v1(100.44,159.21)
  IN1 w0.109: v1(100.44,159.21) 100.31,159.21 99.74,158.63 99.3,158.63 99.13,158.46 99.13,156.9 99.72,156.3 100.65,156.3 101.71,157.36 103.08,157.36 105.18,159.47 105.18,160.66 105.6,161.08 111.25,161.08 112.12,160.21 114.19,160.21 114.64,159.76 114.64,156.04 116.55,154.13 116.55,146.31 114.89,144.65 114.89,144.2 114.26,143.57 114.26,139.11 116.37,137 116.37,131.87 122.06,126.17 122.06,111.66 121.5,111.11 121.5,108.6 119.83,106.93 119.83,102.7 121.19,101.33 121.19,99.62 122.39,98.42 122.39,98.08 125.02,95.45 137.24,95.45 137.75,94.94 161.87,94.94 v1(162.06,95.13)
  BOTTOM w0.102: v1(100.44,159.21) 100.44,159.38 99.8,160.02 U51.B50 ; v1(162.06,95.13) 162.26,94.93 162.49,94.93 162.75,94.68 162.75,93.85 162.11,93.21 162.11,72.96 168.33,66.74 168.33,54.99 168.88,54.44 168.88,50.42 169.32,49.98 172.97,49.98 PR766.2
CHARGER_SMBDAT: length 193.8
  TOP w0.102: v1(97.52,160.11) 97.54,160.13 97.87,160.13 98.81,161.07 v3(98.81,162.2) 98.81,162.53 100.23,163.94 100.82,163.94 101.28,164.4 101.28,164.58 101.14,164.72 RP5.5
  IN1 w0.109: v1(97.52,160.11) 97.52,159.97 98.89,158.6 98.89,156.8 99.62,156.07 100.75,156.07 101.81,157.13 103.18,157.13 105.42,159.37 105.42,160.56 105.7,160.84 111.15,160.84 112.02,159.97 114.09,159.97 114.4,159.66 114.4,155.94 116.32,154.03 116.32,146.41 114.65,144.74 114.65,144.3 114.02,143.66 114.02,139.01 116.13,136.9 116.13,131.77 121.83,126.07 121.83,111.76 121.27,111.2 121.27,108.7 119.59,107.02 119.59,102.6 120.96,101.23 120.96,99.52 122.16,98.32 122.16,97.98 124.93,95.21 137.14,95.21 137.65,94.7 161.88,94.7 v1(162.06,94.52)
  BOTTOM w0.102: U51.A47 97.86,159.77 v1(97.52,160.11) ; PR763.2 173,49.75 169.22,49.75 168.65,50.32 168.65,54.35 168.11,54.89 168.11,66.64 161.88,72.86 161.88,93.3 162.52,93.94 162.52,94.58 162.4,94.7 162.24,94.7 v1(162.06,94.52)
CHG:
  vias: v2(211.98,51.01)
CLK_80H: length 9.1
  TOP w0.102: UH1.F36 26.56,104.56 26.81,104.81 v1(26.81,104.81)
  BOTTOM w0.102: v1(26.81,104.81) 26.81,104.87 27.54,105.6 27.54,106.51 27.21,106.84 27.21,107.07 26.48,107.81 24.57,107.81 v2(23.83,108.55) 23.15,109.23 23.15,109.46 RH159.2
CLK_BUF_BCLK: length 4.9
  TOP w0.102: v1(39.29,99.89) 39.53,99.64 39.53,99.4
  BOTTOM w0.076: 41.51,100.21 41.36,100.21 41.3,100.28 39.67,100.28 v1(39.29,99.89)
  BOTTOM w0.102: RPH3.3 42.83,99.46 42.3,99.99 41.74,99.99 41.51,100.21
CLK_BUF_BCLK#: length 6.4
  TOP w0.102: v1(38.69,99.89) 38.93,99.64 UH1.AR24
  BOTTOM w0.076: 41.61,100.44 38.98,100.44 v2(38.9,100.35) 38.69,100.14 v1(38.69,99.89)
  BOTTOM w0.102: 41.61,100.44 41.88,100.18 42.74,100.18 43.33,99.59 RPH3.4
CLK_BUF_CKSSCD: length 6.5
  TOP w0.102: RH150.1 46.74,89.27 45,89.27 44.18,90.08 44.18,91.02 43.72,91.48 43.72,91.5 43.4,91.83 43.14,91.83 42.78,92.19 UH1.BC6
CLK_BUF_CKSSCD#: length 6.4
  TOP w0.102: UH1.BE6 43.33,92.09 43.51,92.09 43.99,91.61 43.99,91.59 44.45,91.13 44.45,90.19 45.11,89.53 47.24,89.53 47.3,89.6 47.3,89.72 RH149.1
CLK_BUF_DMI: length 2.6
  TOP w0.102: UH1.AW24 40.72,99.65 v1(40.48,99.89)
  BOTTOM w0.102: v1(40.48,99.89) 40.48,99.62 40.69,99.41 v2(40.7,99.41) 41.28,99.41 41.37,99.5 41.7,99.5 41.83,99.38 RPH3.1
CLK_BUF_DMI#: length 2.2
  TOP w0.102: v1(41.14,99.89) 41.32,99.7 UH1.AY24
  BOTTOM w0.102: RPH3.2 42.33,99.35 41.91,99.77 41.26,99.77 v1(41.14,99.89)
CLK_BUF_DOT96: length 4.3
  TOP w0.102: v1(26.93,103.83) 26.93,103.84 27.16,103.6 UH1.G33
  BOTTOM w0.089: 26.02,103.3 26.44,103.3 26.93,103.79 v1(26.93,103.83)
  BOTTOM w0.102: RH148.1 24.27,104.3 24.27,104.07 24.32,104.02 24.89,104.02 v3(25.37,103.53) 25.57,103.34 25.98,103.34 26.02,103.3
CLK_BUF_DOT96#: length 4.5
  TOP w0.102: v1(27.51,103.85) 27.76,103.6 UH1.H33
  BOTTOM w0.089: 26.02,103.07 26.06,103.11 26.5,103.11 26.83,103.44 27.16,103.44 27.51,103.79 v1(27.51,103.85)
  BOTTOM w0.102: 26.02,103.07 25.46,103.07 24.78,103.75 24.6,103.75 RH147.1
CLK_CPU_DMI: length 141.3
  TOP w0.102: JCPU1.E26 81.59,44.22 v1(81.12,43.75) ; v1(35.71,106.29) 35.49,106.51 35.26,106.51 UH1.AF40
  IN1 w0.089: 37.12,102.43 37.12,102.44 37.07,102.49 37.07,102.78 36.31,103.54 36.31,105.82 36.07,106.06 35.95,106.06 35.72,106.29 v1(35.71,106.29)
  IN1 w0.117: v1(88.48,33.82) 88.45,33.84 88.45,34.42 88.16,34.71 86.93,34.71 85.91,33.69 82.43,33.69 80.53,31.79 80.53,31.3 76.39,27.16 72.53,27.16 69.81,29.88 69.81,33.06 65.7,37.17 65.7,44.56 65.03,45.22 65.03,48.58 60.41,53.2 60.41,77.72 58,80.12 52.61,80.12 51.82,80.91 51.82,82.38 50.04,84.16 48.52,84.16 45.65,87.03 45.65,87.23 44.69,88.2 43.32,88.2 43.09,87.97 41.56,87.97 40.7,88.83 38.36,88.83 36.84,90.36 35.67,90.36 35.17,90.86 35.17,91.31 35.4,91.54 35.4,94.9 35.14,95.15 35.14,96.37 35.92,97.15 35.92,97.42 37.09,98.58 37.09,99.25 36.72,99.62 36.72,101.09 37.12,101.49 37.12,102.43
  BOTTOM w0.076: 81.74,40.57 81.74,40.58 81.69,40.63 81.69,43.17 81.46,43.41 81.23,43.41 81.12,43.51 v1(81.12,43.75)
  BOTTOM w0.102: v1(88.48,33.82) 88.26,34.03 88.26,36.65 86.47,38.44 v3(84.86,38.44) 83.09,38.44 82.02,39.52 82.02,39.78 81.74,40.05 81.74,40.57
CLK_CPU_DMI#: length 141.2
  TOP w0.102: JCPU1.D26 81.59,43.22 v1(81.12,42.75) ; UH1.AF39 35.47,105.88 v1(35.71,105.64)
  IN1 w0.089: 36.84,102.43 36.84,102.44 36.89,102.49 36.89,102.71 36.13,103.47 36.13,105.75 36,105.88 35.8,105.88 35.71,105.8 v1(35.71,105.64)
  IN1 w0.117: v1(87.79,33.82) 87.89,33.82 88.17,34.1 88.17,34.31 88.05,34.43 87.05,34.43 86.03,33.41 82.55,33.41 80.81,31.67 80.81,31.18 76.51,26.88 72.41,26.88 69.52,29.76 69.52,32.94 65.41,37.05 65.41,44.44 64.75,45.1 64.75,48.46 60.12,53.08 60.12,77.6 57.89,79.84 52.49,79.84 51.54,80.79 51.54,82.26 49.93,83.87 48.41,83.87 45.37,86.91 45.37,87.12 44.57,87.91 43.43,87.91 43.2,87.69 41.45,87.69 40.58,88.55 38.24,88.55 36.72,90.07 35.55,90.07 34.88,90.74 34.88,91.43 35.11,91.65 35.11,94.78 34.86,95.03 34.86,96.48 35.64,97.27 35.64,97.54 36.8,98.7 36.8,99.13 36.43,99.5 36.43,101.2 36.84,101.61 36.84,102.43
  BOTTOM w0.076: 81.48,40.57 81.48,40.58 81.53,40.63 81.53,43.11 81.39,43.24 81.19,43.24 81.12,43.18 v1(81.12,42.75)
  BOTTOM w0.102: 81.48,40.57 81.48,39.94 81.75,39.67 81.75,39.41 82.98,38.17 86.36,38.17 87.99,36.54 87.99,34.02 v1(87.79,33.82)
CLK_CPU_DPLL: length 146.7
  TOP w0.102: v1(35.71,104.41) 35.71,104.44 35.47,104.68 UH1.AF36 ; v1(79.12,46.75) 79.59,47.22 JCPU1.H28
  IN1 w0.089: 32.14,99.96 32.12,99.98 32.12,100.05 31.91,100.26 31.91,100.82 32.75,101.66 33.79,101.66 34.3,102.17 34.3,102.5 35.11,103.31 35.11,104.2 35.27,104.35 35.65,104.35 v1(35.71,104.41)
  IN1 w0.117: 32.14,99.96 32.86,99.24 32.86,95.66 33.79,94.74 33.79,91.87 33.25,91.34 33.25,89.4 36.2,86.45 37.09,86.45 38.16,85.38 44.53,85.38 51.44,78.47 53.52,78.47 54.1,79.05 57.55,79.05 59.34,77.26 59.34,52.74 63.96,48.11 63.96,44.78 64.63,44.12 64.63,36.72 68.74,32.61 68.74,29.42 72.86,25.31 76.21,25.31 82.18,31.28 82.18,31.8 83.01,32.62 85.2,32.62 85.69,32.14 86.09,32.14 v1(86.22,32.01)
  BOTTOM w0.076: 80.74,39.58 80.74,39.6 80.68,39.65 80.68,45.95 80.26,46.38 79.71,46.38 79.63,46.45 79.24,46.45 79.12,46.58 v1(79.12,46.75)
  BOTTOM w0.102: v1(86.22,32.01) 86.36,32.15 86.73,32.15 87.09,32.51 87.09,33.14 86.53,33.7 86.53,36.34 85.31,37.56 82.52,37.56 80.74,39.35 80.74,39.58
CLK_CPU_DPLL#: length 146.5
  TOP w0.102: JCPU1.G28 79.59,46.22 v1(79.12,45.75) ; UH1.AF35 35.39,104.09 v1(35.71,103.76)
  IN1 w0.089: v1(35.71,103.76) 35.71,103.88 35.42,104.18 35.34,104.18 35.29,104.13 35.29,103.24 34.48,102.42 34.48,102.09 33.87,101.48 32.83,101.48 32.09,100.75 32.09,100.34 32.25,100.18 32.33,100.18 32.34,100.16
  IN1 w0.117: v1(86.22,32.83) 86.22,32.55 86.09,32.42 85.81,32.42 85.32,32.91 82.89,32.91 81.9,31.91 81.9,31.4 81.67,31.17 81.51,31.17 81.21,30.87 81.21,30.72 80.96,30.47 80.81,30.47 80.51,30.17 80.51,30.01 76.09,25.59 72.97,25.59 69.02,29.54 69.02,32.73 64.91,36.84 64.91,44.23 64.25,44.9 64.25,48.23 59.62,52.86 59.62,77.38 57.67,79.33 53.98,79.33 53.4,78.76 51.56,78.76 44.65,85.66 38.28,85.66 37.21,86.73 36.32,86.73 33.54,89.52 33.54,91.22 34.07,91.76 34.07,94.85 33.14,95.78 33.14,99.36 32.34,100.16
  BOTTOM w0.076: v1(79.12,45.75) 79.12,46.18 79.23,46.29 79.56,46.29 79.64,46.21 80.19,46.21 80.52,45.89 80.52,39.65 80.47,39.6 80.47,39.58
  BOTTOM w0.102: v1(86.22,32.83) 86.22,32.52 86.32,32.42 86.62,32.42 86.83,32.62 86.83,33.03 86.27,33.59 86.27,36.23 85.2,37.3 82.41,37.3 80.47,39.24 80.47,39.58
CLK_CPU_ITP: length 172.6
  TOP w0.102: v1(35.66,109.96) 35.88,109.96 36.1,109.74 36.1,108.8 36.2,108.7 36.2,108.52 36.09,108.41 35.98,108.41
  IN1 w0.117: v1(70.52,16.17) 70.69,16.34 70.69,16.5 69.51,17.69 59.83,17.69 59.22,18.29 52.32,18.29 50.37,16.34 48.02,16.34 47.5,16.86 47.5,20.83 44.68,23.65 44.68,25.55 42.78,27.45 42.78,31.41 39.5,34.69 39.5,36.11 37.52,38.09 37.52,47.56 40.9,50.94 40.9,54.14 38.59,56.46 38.59,65.79 36.52,67.86 36.52,77.79 37.12,78.39 37.12,80.07 35.14,82.05 35.14,83.73 34.89,83.98 25.87,83.98 25.12,84.73 22.66,84.73 20.12,87.27 20.12,88.86 19.21,89.77 19.21,95.84 19.28,95.91 19.28,96.59 18.73,97.14 18.73,98.08 17.64,99.17 17.64,99.6 17.2,100.04 17.2,102.98 17.81,103.6 17.81,108.14 22.03,112.35 23.94,112.35 24.21,112.63 25.84,112.63 26.27,113.07 38.85,113.07 39.07,113.29 39.07,113.48 v1(38.9,113.65)
  BOTTOM w0.102: RH107.2 70.7,16.54 70.7,16.35 v1(70.52,16.17) ; v1(38.9,113.65) 39.08,113.47 39.08,112.54 37.34,110.79 37.26,110.79 37.18,110.79 36.96,110.57 36.96,110.42 36.75,110.2 36.59,110.2 36.38,109.99 36.38,109.83 36.11,109.56 35.97,109.56 35.66,109.88 v1(35.66,109.96)
CLK_CPU_ITP#: length 172.6
  TOP w0.102: v1(35.66,109.3) 35.84,109.12 35.84,108.71 35.66,108.53 35.66,108.28 35.88,108.06 35.88,107.6 35.98,107.5
  IN1 w0.117: v1(39.53,113.65) 39.35,113.47 39.35,113.17 38.97,112.78 26.39,112.78 25.96,112.35 24.33,112.35 24.05,112.07 22.15,112.07 18.1,108.02 18.1,103.48 17.48,102.86 17.48,100.16 17.92,99.72 17.92,99.29 19.01,98.2 19.01,97.26 19.57,96.7 19.57,95.79 19.49,95.72 19.49,89.89 20.4,88.98 20.4,87.39 22.78,85.01 25.24,85.01 25.99,84.26 35.01,84.26 35.42,83.85 35.42,82.17 37.4,80.18 37.4,78.27 36.8,77.67 36.8,67.98 38.87,65.91 38.87,56.57 41.19,54.26 41.19,50.82 37.81,47.44 37.81,38.21 39.79,36.23 39.79,34.81 43.07,31.53 43.07,27.57 44.97,25.67 44.97,23.77 47.79,20.95 47.79,16.97 48.14,16.62 50.25,16.62 52.21,18.58 59.34,18.58 59.94,17.97 69.62,17.97 70.98,16.62 70.98,16.34 v1(71.15,16.17)
  BOTTOM w0.102: v1(39.53,113.65) 39.35,113.47 39.35,112.42 37.21,110.29 36.9,109.98 36.22,109.3 v1(35.66,109.3) ; v1(71.15,16.17) 70.97,16.35 70.97,16.54 RH108.2
CLK_CPU_SSC_DPLL: length 149.9
  TOP w0.102: JCPU1.E27 80.59,44.22 v1(80.12,43.75) ; v1(36.69,105.64) 36.45,105.88 UH1.AJ39
  IN1 w0.089: 36.01,107.29 36.02,107.28 36.1,107.28 36.31,107.07 36.31,106.11 36.48,105.93 36.57,105.93 36.69,105.81 v1(36.69,105.64)
  IN1 w0.117: 36.01,107.29 35.73,107.57 32.17,107.57 30.79,106.2 30.79,103.13 30.04,102.39 30.04,95.55 30.36,95.24 31.28,95.24 31.81,94.7 31.81,89.62 36.42,85 37.34,85 37.82,84.52 42.09,84.52 43.24,83.36 43.24,82.94 46.39,79.79 49.41,79.79 51.24,77.96 53.91,77.96 54.49,78.55 57.29,78.55 57.72,78.12 57.72,77.13 57.44,76.85 57.44,75.37 58,74.81 58,74.33 58.84,73.48 58.84,52.52 63.46,47.9 63.46,44.57 64.12,43.91 64.12,36.52 68.24,32.41 68.24,29.19 72.62,24.81 76.45,24.81 83.32,31.68 83.32,31.78 83.65,32.12 84.21,32.12 84.46,31.86 84.46,31.58 84.64,31.41 v1(84.69,31.41)
  BOTTOM w0.076: v1(80.12,43.75) 80.12,44.18 80.02,44.28 79.84,44.28 79.7,44.15 79.7,39.42 79.75,39.37 79.75,39.35
  BOTTOM w0.102: v1(84.69,31.41) 84.5,31.6 84.5,34.34 83.24,35.6 81.15,37.69 79.75,39.09 79.75,39.35
CLK_CPU_SSC_DPLL#: length 149.9
  TOP w0.102: v1(80.12,44.75) 80.59,45.22 JCPU1.F27 ; v1(36.69,106.29) 36.47,106.51 36.24,106.51 UH1.AJ40
  IN1 w0.089: v1(36.69,106.29) 36.48,106.5 36.48,107.15 36.22,107.41 36.22,107.48 36.21,107.49
  IN1 w0.117: 36.21,107.49 35.84,107.86 32.05,107.86 30.51,106.32 30.51,103.25 29.76,102.5 29.76,95.43 30.24,94.95 31.16,94.95 31.52,94.58 31.52,89.5 36.31,84.72 37.22,84.72 37.71,84.24 41.97,84.24 42.96,83.25 42.96,82.82 46.27,79.51 49.29,79.51 51.12,77.68 54.03,77.68 54.61,78.26 57.17,78.26 57.43,78 57.43,77.24 57.15,76.96 57.15,75.25 57.71,74.7 57.71,74.21 58.56,73.37 58.56,52.41 63.18,47.79 63.18,44.45 63.84,43.79 63.84,36.4 67.95,32.29 67.95,29.07 72.5,24.52 76.56,24.52 83.6,31.56 83.6,31.66 83.77,31.83 84.09,31.83 84.18,31.74 84.18,31.52 84.19,31.51 v1(84.08,31.41)
  BOTTOM w0.076: v1(80.12,44.75) 80.12,44.58 79.99,44.45 79.77,44.45 79.54,44.21 79.54,39.42 79.49,39.37 79.49,39.35
  BOTTOM w0.102: 79.49,39.35 79.49,38.98 80.96,37.5 83.06,35.41 83.06,35.41 84.23,34.23 84.23,31.55 v1(84.08,31.41)
CLK_DDC2_CRT: length 26.5
  BOTTOM w0.102: U19.35 83.4,161.1 83.32,161.18 83.32,162.44 84.49,163.61 86.47,163.61 87.08,164.22 87.08,167.32 86.11,168.29 78.57,168.29 v3(78.21,168.65) 76.54,170.32 76.54,171.21 76.84,171.51 79.36,171.51 JCRT1.15
CLK_DDC2_DOCK: length 37.6
  IN1 w0.109: v1(79.92,158.46) 80.11,158.26 80.45,158.26 81.4,157.31 81.4,155.59 79.8,153.99 79.8,141.58 82.37,139.01 82.37,135.83 81.87,135.33 81.87,133.55 82.37,133.06 82.37,130.5 v1(82.66,130.21)
  BOTTOM w0.102: v1(82.66,130.21) 82.46,130.01 82.46,129.73 84.56,127.62 84.56,127.34 84.7,127.21 JDOCK1.48 ; U19.26 80.63,158.35 80.54,158.27 80.11,158.27 v1(79.92,158.46)
CLK_KBD: length 38.5
  TOP w0.102: RP6.7 93.98,155.99 94.01,156.02 96.86,156.02 v2(97.1,155.78) 97.57,155.31 v1(97.57,155.3)
  IN1 w0.109: v1(94.7,130.59) 94.7,139.55 93.42,140.83 93.42,143.05 93.18,143.3 93.18,146.29 93.99,147.1 94.14,147.1 97.46,150.42 97.46,150.97 96.29,152.13 96.29,154.16 96.91,154.77 97.16,154.77 97.57,155.18 v1(97.57,155.3)
  BOTTOM w0.102: JDOCK1.78 93.2,129.42 94.37,130.59 v1(94.7,130.59) ; U51.A38 97.6,155.27 v1(97.57,155.3)
CLK_MSE: length 54.7
  TOP w0.102: v1(96.96,155.28) 96.53,155.72 95.1,155.72 v2(95.07,155.69) 95.06,155.69 94.57,155.2 94.17,155.2 93.88,155.49 RP6.6
  IN2 w0.127: v1(90.05,120.97) 90.05,120.94 90.36,121.24 90.36,125.29 91.25,126.18 91.25,130.08 90.86,130.47 90.86,134.55 97.32,141.01 97.32,143.06 96.66,143.72 96.66,145.98 96.99,146.31 96.99,146.67 100.03,149.71 100.03,150.63 101.33,151.93 101.73,151.93 102.27,152.47 102.27,154.44 101.55,155.15 99.4,155.15 99.07,154.82 97.32,154.82 96.96,155.18 v1(96.96,155.28)
  BOTTOM w0.102: JDOCK1.71 91.7,119.7 90.41,120.99 90.08,120.99 v1(90.05,120.97) ; U51.A39 97.45,155.77 v1(96.96,155.28)
CLK_PCH_14M: length 6.6
  TOP w0.102: v2(24.46,111.87) 24.35,111.97 RH146.1 23.4,111.7 25.66,109.43 25.79,109.43 26.12,109.1 26.7,109.1 27.01,108.79 UH1.F45
CLK_PCI_5048: length 297.1
  IN1 w0.109: v1(60.23,160.16) 60.23,160.36 62.47,162.6 65.6,162.6 66.91,163.91 71.79,163.91 73.17,165.29 81.44,165.29 82.18,164.55 86.47,164.55 87,164.02 93.79,164.02 101.97,172.2 111.04,172.2 113.83,169.4 116.55,169.4 117.43,168.52 119.15,168.52 125.9,161.77 127.63,161.77 128.41,160.99 130.67,160.99 135.29,156.37 138.28,156.37 147.8,146.85 147.8,142.61 153.16,137.25 153.16,135.16 157.67,130.65 163.99,130.65 167.02,127.62 167.02,121.83 168.16,120.69 168.16,112.78 169.41,111.53 169.41,111.22 170.6,110.04 170.6,109.7 175.05,105.24 175.66,105.24 184.02,96.89 189.66,96.89 195.6,90.95 195.6,90.47 202.09,83.98 207.13,83.98 207.72,83.4 v1(209.94,83.4)
  BOTTOM w0.102: v1(60.23,160.16) 60.16,160.23 v2(59.6,160.23) 51.92,160.23 50.14,158.46 49.84,158.46 48.93,157.54 48.75,157.54 48.32,157.11 48.32,156.55 46.39,154.62 43.67,154.62 42.6,153.55 42.11,153.55 41.33,152.78 41.33,150.49 41.66,150.16 43.31,150.16 43.85,149.62 43.85,148.78 40.95,145.88 34.04,145.88 32.26,144.1 32.26,142.73 32.25,142.73 32.25,139.05 29.63,136.42 29.63,134.63 30.64,133.61 30.64,128.48 32.57,126.55 32.57,120.6 30.22,118.25 26.82,118.25 25.27,116.7 23.46,116.7 20.56,113.79 20.56,111.69 20.94,111.31 CH15.1 21.19,109 RH158.2 ; v1(209.94,83.4) 209.91,83.37 R795.1 210.61,83.02 U46.A28
