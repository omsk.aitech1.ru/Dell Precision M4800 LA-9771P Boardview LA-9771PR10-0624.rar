# Allegro board LA-9771PR10-0624.brd (continued)
## Text on the board (continued)
COMPVAL_TYPE_BOTTOM: 26.09 | 7.20 | 4.70 | 4.05 | 11.15 | 14.10 | 28.81 | 124.61 | 130.17 | 140.76 | 144.42 | 133.21 | 92.70 | 213.00 | 225.25 | 234.80 | 92.95 | 114.75 | 141.85 | 30.30 | 8.70 | 2.63 | 0.10 | 83.00 | 80.25 | 51.20 | 156.96 | 154.35 | 151.44 | 119.15 | 117.20 | 28.70 | 23.18 | 14.95 | 0.67 | 0.00 | 10.10 | 2.90 | 9.90 | 19.74 | 67.86 | 102.55 | 116.15 | 132.30 | 137.30 | 190.35 | 86.50
COMPVAL_TYPE_TOP: 139.00 | 114.20 | 105.50 | 56.00 | 0.00 | 25.65 | 0.60 | 46.80 | 79.30 | 100.99 | 135.50 | 26.65 | 102.55 | 116.15 | 124.75 | 121.94 | 121.04 | 199.16 | 217.25 | 47.50 | 8.70 | 2.10
USER_PART_NUM_BOTTOM: 161.20 | 0.00 | 236.40
DEVICE_TYPE_BOTTOM: 161.90 | 0.00 | 236.40
USER_PART_NUM_TOP: 27.20 | 10.20 | {\Fgdt;n}\Ftxt;6.00 | {\Fgdt;n}\Ftxt;2.80 | 8.68 | {\Fgdt;n}\Ftxt;4.20 | 17.57 | 17.80 | {\Fgdt;n}\Ftxt;3.80 | {\Fgdt;n}\Ftxt;7.00 | 38.46 | {\Fgdt;n}\Ftxt;8.00 | 92.57 | 123.60 | {\Fgdt;n}\Ftxt;5.00 | 149.80 | 149.13 | 109.13 | 88.20 | 224.80 | 225.80 | 230.30 | 2.00 | 2.10 | 154.40 | 83.50 | 72.27 | 10.54 | 0.40 | 146.00 | 142.00 | 72.00 | 67.00 | 3.00 | 3.20 | 15.00 | 6.50 | 4.00 | 0.00 | {\Fgdt;n}\Ftxt;3.20 | {\Fgdt;n}\Ftxt;3.30 | {\Fgdt;n}\Ftxt;2.30 | 35.31 | 58.93 | 63.30 | 62.43 | 0.10 | 114.80 | {\Fgdt;n}\Ftxt;4.10 | 152.35 | {\Fgdt;n}\Ftxt;5.50 | 223.80 | 228.95
DEVICE_TYPE_TOP: 54.60 | 48.00 | 0.00 | 8.50 | {\Fgdt;n}\Ftxt;8.00 | {\Fgdt;n}\Ftxt;7.00 | {\Fgdt;n}\Ftxt;4.20 | {\Fgdt;n}\Ftxt;2.90 | {\Fgdt;n}\Ftxt;5.50 | 34.00 | 27.60
PAGE_OUTLINE: 236.40 | 161.90 | 39.15 | 0.00 | 16.80
User.10: 161.20 | 0.00 | 236.40
User.11: 161.90 | 0.00 | 236.40
User.12: 26.09 | 7.20 | 4.70 | 4.05 | 11.15 | 14.10 | 28.81 | 124.61 | 130.17 | 140.76 | 144.42 | 133.21 | 92.70 | 213.00 | 225.25 | 234.80 | 92.95 | 114.75 | 141.85 | 30.30 | 8.70 | 2.63 | 0.10 | 83.00 | 80.25 | 51.20 | 156.96 | 154.35 | 151.44 | 119.15 | 117.20 | 28.70 | 23.18 | 14.95 | 0.67 | 0.00 | 10.10 | 2.90 | 9.90 | 19.74 | 67.86 | 102.55 | 116.15 | 132.30 | 137.30 | 190.35 | 86.50
User.13: 139.00 | 114.20 | 105.50 | 56.00 | 0.00 | 25.65 | 0.60 | 46.80 | 79.30 | 100.99 | 135.50 | 26.65 | 102.55 | 116.15 | 124.75 | 121.94 | 121.04 | 199.16 | 217.25 | 47.50 | 8.70 | 2.10
User.14: 161.20 | 0.00 | 236.40
User.15: 161.90 | 0.00 | 236.40
User.16: 27.20 | 10.20 | 8.68 | 17.57 | 17.80 | 38.46 | 92.57 | 123.60 | 149.80 | 149.13 | 109.13 | 88.20 | 224.80 | 225.80 | 230.30 | 2.00 | 2.10 | 154.40 | 83.50 | 72.27 | 10.54 | 0.40 | 146.00 | 142.00 | 72.00 | 67.00 | 3.00 | 3.20 | 15.00 | 6.50 | 4.00 | 0.00 | 35.31 | 58.93 | 63.30 | 62.43 | 0.10 | 114.80 | 152.35 | 223.80 | 228.95
User.17: 54.60 | 48.00 | 0.00 | 8.50 | 34.00 | 27.60
User.18: 236.40 | 161.90 | 39.15 | 0.00 | 16.80
User.19: 26.09 | 7.20 | 4.70 | 4.05 | 11.15 | 14.10 | 28.81 | 124.61 | 130.17 | 140.76 | 144.42 | 133.21 | 92.70 | 213.00 | 225.25 | 234.80 | 92.95 | 114.75 | 141.85 | 30.30 | 8.70 | 2.63 | 0.10 | 83.00 | 80.25 | 51.20 | 156.96 | 154.35 | 151.44 | 119.15 | 117.20 | 28.70 | 23.18 | 14.95 | 0.67 | 0.00 | 10.10 | 2.90 | 9.90 | 19.74 | 67.86 | 102.55 | 116.15 | 132.30 | 137.30 | 190.35 | 86.50
User.20: 139.00 | 114.20 | 105.50 | 56.00 | 0.00 | 25.65 | 0.60 | 46.80 | 79.30 | 100.99 | 135.50 | 26.65 | 102.55 | 116.15 | 124.75 | 121.94 | 121.04 | 199.16 | 217.25 | 47.50 | 8.70 | 2.10
User.21: 161.20 | 0.00 | 236.40
User.22: 161.90 | 0.00 | 236.40
User.23: 27.20 | 10.20 | {\Fgdt;n}\Ftxt;6.00 | {\Fgdt;n}\Ftxt;2.80 | 8.68 | {\Fgdt;n}\Ftxt;4.20 | 17.57 | 17.80 | {\Fgdt;n}\Ftxt;3.80 | {\Fgdt;n}\Ftxt;7.00 | 38.46 | {\Fgdt;n}\Ftxt;8.00 | 92.57 | 123.60 | {\Fgdt;n}\Ftxt;5.00 | 149.80 | 149.13 | 109.13 | 88.20 | 224.80 | 225.80 | 230.30 | 2.00 | 2.10 | 154.40 | 83.50 | 72.27 | 10.54 | 0.40 | 146.00 | 142.00 | 72.00 | 67.00 | 3.00 | 3.20 | 15.00 | 6.50 | 4.00 | 0.00 | {\Fgdt;n}\Ftxt;3.20 | {\Fgdt;n}\Ftxt;3.30 | {\Fgdt;n}\Ftxt;2.30 | 35.31 | 58.93 | 63.30 | 62.43 | 0.10 | 114.80 | {\Fgdt;n}\Ftxt;4.10 | 152.35 | {\Fgdt;n}\Ftxt;5.50 | 223.80 | 228.95
User.24: 54.60 | 48.00 | 0.00 | 8.50 | {\Fgdt;n}\Ftxt;8.00 | {\Fgdt;n}\Ftxt;7.00 | {\Fgdt;n}\Ftxt;4.20 | {\Fgdt;n}\Ftxt;2.90 | {\Fgdt;n}\Ftxt;5.50 | 34.00 | 27.60
User.25: 236.40 | 161.90 | 39.15 | 0.00 | 16.80
User.45: Width/space | 5.5mil | 5.5 / 4.7 | 4 / 5 | 4.5 / 10 | 3.5 / 10 | 4 / 10 | 7/5.5 | 9/4.5 | 100 ohm | (no ref) | FIGURE | SIZE | 8.0 | 9.0 | 10.0 | 20.0 | 22.0 | 24.0 | 30.0 | 31.0 | 35.0 | 36.0 | 39.0 | 55.0 | 91.0 | 110.0 | 126.0 | 130.0 | 150.0 | 161.0 | 40.0 | 43.0 | 63.0 | 65.0 | 67.0 | 39.0x33.0 | 45.0x37.0 | 55.0x31.0 | 59.0x31.0 | 63.0x24.0 | 67.0x20.0 | 75.0x24.0 | 75.0x37.0 | 83.0x39.0 | 94.0x24.0 | 94.0x31.0 | 94.0x39.0 | 102.0x31.0 | 112.0x39.0 | 118.0x33.0 | 120.0x39.0 | 67.0x43.0 | 161.0x83.0 | 244.0x126.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | PLATED | NON-PLATED | QTY | 5308 | 9 | 1440 | 20 | 19 | 15 | 7 | 18 | 8 | 4 | 16 | 2 | 1 | 3
