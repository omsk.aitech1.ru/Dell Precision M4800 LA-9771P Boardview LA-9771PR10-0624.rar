# Allegro board LA-9771PR10-0624.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
TYCO_2-2041070-0_20P-T
  oval 0.305x1.295 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0) 11(-5,0) 12(-5.5,0) 13(-6,0) 14(-6.5,0) 15(-7,0) 16(-7.5,0) 17(-8,0) 18(-8.5,0) 19(-9,0) 20(-9.5,0)
  rect 2.489x1.905 smd: 21(-11.65,3.3) 22(2.15,3.3)
W25Q32FVSSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25Q64FVSSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
WGI217LM-QPN9-A2_QFN48_6X6
  oval 0.203x1.041 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 25(4.4,5.95) 26(4,5.95) 27(3.6,5.95) 28(3.2,5.95) 29(2.8,5.95) 30(2.4,5.95) 31(2,5.95) 32(1.6,5.95) 33(1.2,5.95) 34(0.8,5.95) 35(0.4,5.95) 36(0,5.95)
  oval 1.041x0.203 smd: 13(5.175,0.775) 14(5.175,1.175) 15(5.175,1.575) 16(5.175,1.975) 17(5.175,2.375) 18(5.175,2.775) 19(5.175,3.175) 20(5.175,3.575) 21(5.175,3.975) 22(5.175,4.375) 23(5.175,4.775) 24(5.175,5.175) 37(-0.775,5.175) 38(-0.775,4.775) 39(-0.775,4.375) 40(-0.775,3.975) 41(-0.775,3.575) 42(-0.775,3.175) 43(-0.775,2.775) 44(-0.775,2.375) 45(-0.775,1.975) 46(-0.775,1.575) 47(-0.775,1.175) 48(-0.775,0.775)
  rect 2.997x2.997 smd: 49(2.2,2.975)
Y_Q13FC135000040_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_Q22FA2380049900_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.6) 4(0,1.6)
Y_X3G025000DI1H-H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)

## Nets
0.75V_DDR_VTT_ON: PR208.1 RP4.3 U46.A60
1.05V_0.8V_PWROK: PR517.1 R883.2 U50.4
1.05V_A_PWRGD: PR300.1 PU300.1 U51.B28
1.05V_RUN_ENABLE: C773.1 Q63.4 Q304.3 R933.2 R1611.1
1.5V_RUN_PWRGD: PR400.2 PU400.4 U50.1
1.5VSP_FB: PC402.2 PR402.2 PR405.1 PU400.6
1.5VSP_LX: PL401.1 PR401.1 PU400.2 PU400.3
1.5VSP_VIN: PC400.1 PJP400.1 PU400.8 PU400.9 PU400.10
1.35V_B+: PC202.1 PC203.1 PC204.1 PC205.1 PJP200.1 PQ201.5 PR205.1
1.35V_FB: PC211.1 PR204.2 PR207.2 PR211.2 PR218.1 PU200.6
1.35V_SUS_PWRGD: CC138.1 PR209.2 PU200.10 U51.B9 UC2.1
3.3V_RUN_GFX_ON: Q87.2 QH3.2 R301.1 U34.3 U35.3 U46.A55
3V_5V_EN: PC120.1 PR111.2 PR112.2 PU101.6 PU101.20
3V_PWROK#: R410.2 U29.12
+0.9V_LAN: C462.1 C463.1 C466.1 C467.1 C468.1 C469.1 C1177.1 L29.2 U31.8 U31.11 U31.16 U31.22 U31.37 U31.40 U31.43 U31.46 U31.47
+0.675V_DDR_VTT: CD15.1 CD16.1 CD17.1 CD18.1 CD37.1 CD38.1 CD39.1 CD40.1 CD59.1 CD60.1 CD61.1 CD62.1 CD81.1 CD82.1 CD83.1 CD84.1 JDIMM1.203 JDIMM1.204 JDIMM2.203 JDIMM2.204 JDIMM3.203 JDIMM3.204 JDIMM4.203 JDIMM4.204 PJP202.1
+0.675V_P: PC207.1 PC208.1 PJP202.2 PU200.2 PU200.20
+1.05V_M: CH28.1 CH29.1 CH30.1 PJP301.1 PJP302.1 Q63.5 Q63.6 Q63.7 Q63.8 RH234.1 RH236.2 RH239.1 UH1.AA18 UH1.L17 UH1.R18 UH1.U18 UH1.U20 UH1.U22 UH1.U24 UH1.V18 UH1.V20 UH1.V22 UH1.V24 UH1.Y18 UH1.Y20 UH1.Y22
+1.05V_MP: PC301.1 PJP301.2 PJP302.2 PL301.2 PR306.1
+1.5V_RUN: C593.1 C594.1 C724.1 CH26.1 CH31.1 CH32.1 CH33.1 CH52.1 JIO1.80 JIO1.82 JMINI2.6 JMINI2.28 JMINI2.48 LH1.1 PJP401.1 RH57.2 RH99.1 RH100.1 RH165.2 RH192.1 UH1.AF34 UH1.AK26 UH1.AK28 UH1.AM45 UH1.AN11 UH1.AT45 UH1.AW40 UH1.BB44 UH1.BD4 UH1.BE16 UH1.BE22 UH1.BE30
+1.05V_RUN: C772.1 CH21.1 CH22.1 CH23.1 CH24.1 CH25.1 CH34.1 CH35.1 CH36.1 CH37.1 CH38.1 CH47.1 CH50.1 CH93.1 JXDP2.40 Q63.1 Q63.2 Q63.3 R105.1 R866.2 R931.1 RC27.1 RC29.1 RC32.1 RC35.1 RC69.1 RC99.2 RC126.1 RH206.1 RH241.1 RH244.1 UH1.AA24 UH1.AA26 UH1.AD20 UH1.AD22 UH1.AD24 UH1.AD26 UH1.AD28 UH1.AE18 UH1.AE20 UH1.AE22 UH1.AE24 UH1.AE26 UH1.AG18 UH1.AG20 UH1.AG22 UH1.AG24 UH1.AK18 UH1.AK20 UH1.AK22 UH1.AM18 UH1.AM20 UH1.AM22 UH1.AN34 UH1.AN35 UH1.AP22 UH1.AR22 UH1.AT22 UH1.U30 UH1.U35 UH1.U36 UH1.V28 UH1.V30 UH1.Y26 UH1.Y30
+1.05V_RUN_VCC: LH2.1 RH241.2
+1.5V_RUNP: PC402.1 PC403.1 PC404.1 PJP401.2 PL401.2 PR402.1
+1.05VSP_B+: PC302.1 PC303.1 PC304.1 PC305.1 PJP300.2 PQ301.5
+1.35V_MEM: CC33.1 CC34.1 CC35.1 CC36.1 CC37.1 CC38.1 CC39.1 CC40.1 CC41.1 CC42.1 CC43.1 CC161.1 CC162.1 CC163.1 CC164.1 CC165.1 CC166.1 CC167.1 CC168.1 CC169.1 CC170.1 CC171.1 CC172.1 CD3.1 CD4.1 CD5.1 CD6.1 CD7.1 CD8.1 CD9.1 CD10.1 CD11.1 CD12.1 CD13.1 CD14.1 CD24.1 CD25.1 CD27.1 CD28.1 CD29.1 CD30.1 CD31.1 CD32.1 CD33.1 CD34.1 CD35.1 CD36.1 CD47.1 CD48.1 CD49.1 CD50.1 CD51.1 CD52.1 CD53.1 CD54.1 CD55.1 CD56.1 CD57.1 CD58.1 CD67.1 CD68.1 CD69.1 CD70.1 CD73.1 CD74.1 CD75.1 CD76.1 CD77.1 CD78.1 CD79.1 CD80.1 JCPU1.AB2 JCPU1.AB5 JCPU1.AB8 JCPU1.AB11 JCPU1.AE2 JCPU1.AE5 JCPU1.AE8 JCPU1.AE11 JCPU1.AH11 JCPU1.K11 JCPU1.N8 JCPU1.N11 JCPU1.T2 JCPU1.T5 JCPU1.T8 JCPU1.T11 JCPU1.W2 JCPU1.W5 JCPU1.W8 JCPU1.W11 JDIMM1.75 JDIMM1.76 JDIMM1.81 JDIMM1.82 JDIMM1.87 JDIMM1.88 JDIMM1.93 JDIMM1.94 JDIMM1.99 JDIMM1.100 JDIMM1.105 JDIMM1.106 JDIMM1.111 JDIMM1.112 JDIMM1.117 JDIMM1.118 JDIMM1.123 JDIMM1.124 JDIMM2.75 JDIMM2.76 JDIMM2.81 JDIMM2.82 JDIMM2.87 JDIMM2.88 JDIMM2.93 JDIMM2.94 JDIMM2.99 JDIMM2.100 JDIMM2.105 JDIMM2.106 JDIMM2.111 JDIMM2.112 JDIMM2.117 JDIMM2.118 JDIMM2.123 JDIMM2.124 JDIMM3.75 JDIMM3.76 JDIMM3.81 JDIMM3.82 JDIMM3.87 JDIMM3.88 JDIMM3.93 JDIMM3.94 JDIMM3.99 JDIMM3.100 JDIMM3.105 JDIMM3.106 JDIMM3.111 JDIMM3.112 JDIMM3.117 JDIMM3.118 JDIMM3.123 JDIMM3.124 JDIMM4.75 JDIMM4.76 JDIMM4.81 JDIMM4.82 JDIMM4.87 JDIMM4.88 JDIMM4.93 JDIMM4.94 JDIMM4.99 JDIMM4.100 JDIMM4.105 JDIMM4.106 JDIMM4.111 JDIMM4.112 JDIMM4.117 JDIMM4.118 JDIMM4.123 JDIMM4.124 PJP203.1 PJP204.1 RC16.1 RD5.1 RD44.1 RD47.1 RD49.1
+1.35V_MEN_P: PC201.1 PC211.2 PC214.1 PJP201.1 PJP203.2 PJP204.2 PL201.1 PR204.1 PU200.5
+3.3V_ALW: C90.1 C289.1 C723.1 C726.1 C736.1 C739.1 C756.1 C757.1 C1349.1 JAPS1.7 JIO1.2 JKB1.7 JKB1.8 PC733.2 PC1080.2 PC1081.2 PJP29.1 PJP65.1 PJP100.2 PJP101.2 PJP400.2 PR2.1 PR8.2 PR21.1 PR119.2 PR209.1 PR213.1 PR216.1 PR221.1 PR222.1 PR300.2 PR749.1 PR757.1 PR764.1 PR1025.2 PR1083.1 PU704.5 PU1080.5 PU1081.5 R11.1 R19.1 R396.1 R515.1 R709.1 R755.1 R759.1 R763.1 R768.1 R784.2 R798.1 R805.1 R814.1 R817.1 R838.1 R839.1 R840.1 R841.1 R847.1 R848.1 R849.1 R854.1 R855.1 R864.1 R871.1 R872.1 R875.1 R932.1 R937.1 R938.1 R1125.1 R1630.2 R1980.1 R1981.1 RH238.1 RH240.1 RP1.1 RP1.2 RP1.3 RP1.4 RP2.1 RP2.2 RP2.3 RP5.1 RP5.2 RP5.3 RP5.4 RP9.5 RP9.6 RP9.7 RP9.8 U7.5 U16.5 U17.5 U34.1 U34.2 U34.6 U34.7 U35.6 U35.7 U38.1 U38.2 U43.1 U43.2 U50.5 U51.A22 U51.A58 U54.5 U56.1 U56.2 U57.6 U57.7 U58.5 U62.5 U63.1 U63.2 U63.6 U63.7
+3.3V_ALW2: PC114.2 PQ1072.3 PR103.1 PR737.1 PR741.1 PR1013.1 PR1022.1 PR1073.1 PR1100.1 PU101.3 R874.2 R909.1 R2192.1 UH2.5
+3.3V_ALW_PCH: CH2.1 CH43.1 CH45.1 CH51.1 JAPS1.1 JXDP2.43 JXDP2.44 PJP4.1 R796.1 R808.1 R1622.2 RC124.1 RH35.1 RH46.1 RH52.1 RH60.1 RH75.1 RH84.1 RH123.2 RH124.2 RH125.2 RH128.2 RH129.1 RH130.1 RH144.2 RH145.2 RH166.1 RH170.1 RH171.1 RH210.2 RH211.1 RH212.2 RH213.2 RH222.2 RH246.1 RH247.1 RH248.1 RH249.1 RH254.2 RPH5.5 RPH5.6 RPH5.7 RPH5.8 RPH7.5 RPH7.6 RPH7.7 RPH7.8 UH1.A26 UH1.AJ30 UH1.AJ32 UH1.R20 UH1.R22 UH1.R24 UH1.R26 UH1.R28 UH1.U26
+3.3V_ALW_PCH_JTAG: RH46.2 RH48.1 RH50.1
+3.3V_ALW_PCH_U34: C760.1 PJP4.2 U34.8 U34.9
+3.3V_ALW_U46: C708.1 C709.1 C710.1 C717.1 C718.1 C719.1 PJP29.2 U46.A17 U46.A43 U46.A54 U46.B5 U46.B30
+3.3V_ALW_VTR: C777.1 C780.1 C781.1 C782.1 C1345.1 C1348.1 C1355.1 PJP65.2 U51.A11 U51.A26 U51.A41 U51.A52 U51.B3 U51.B35
+3.3V_LAN: C472.1 C473.1 C474.1 C478.1 C481.1 C483.1 C1167.1 C1178.1 JLOM1.9 JLOM1.12 PJP1.1 R209.2 R549.1 R553.1 R554.1 RH174.1 RH175.1 U15.5 U32.1 U32.4 U32.8 U32.14 U32.21 U32.30 U32.39
+3.3V_LAN_OUT: C464.1 R209.1 U31.4 U31.5 U31.15 U31.19 U31.29
+3.3V_LAN_U63: C770.1 PJP1.2 U63.13 U63.14
+3.3V_M: CH59.1 JSPI1.16 PJP6.1 R392.1 R402.1 R426.1 R818.1 R893.1 RH185.1 UH1.AD12
+3.3V_M_U35: C360.1 PJP6.2 U35.8 U35.9
+3.3V_MXM: C8.1 C95.1 C332.1 JMXM1.306 JMXM1.308 PJP3.1 Q5.2 Q295.2 Q295.5 R1.1 R2.1 R3.1 R4.1 R5.1 R6.1 R10.1 R36.1 R37.1 R38.1 R1977.1 R1978.1 R1979.1 RH113.1 U14.5 U25.5 U27.5
+3.3V_MXM_U34: C449.1 PJP3.2 U34.13 U34.14
+3.3V_PCIE_FLASH: C624.1 C633.1 C634.1 C637.2 C638.2 C639.1 C765.1 JMINI3.2 JMINI3.24 JMINI3.39 JMINI3.41 JMINI3.52 U56.7 U56.8
+3.3V_PCIE_WWAN: C610.1 C611.1 C612.1 C613.1 C614.1 C615.1 C1176.1 C1179.1 C1312.1 C1313.1 JMINI2.2 JMINI2.24 JMINI2.39 JMINI2.41 JMINI2.52 PJP2.1 Q77.2 R550.1 R560.1 R568.1 R719.2 R785.1 R1159.1 R1160.1 U637.10 U637.20
+3.3V_PCIE_WWAN_U43: C764.1 PJP2.2 U43.7 U43.8
+3.3V_RTC_LDO: PD1.3 PR103.2
+3.3V_RUN: C52.1 C243.1 C248.1 C301.1 C359.1 C391.1 C392.1 C402.1 C403.1 C404.1 C405.1 C410.1 C437.1 C450.1 C453.1 C494.1 C495.1 C496.1 C497.1 C499.1 C504.1 C722.1 C766.1 C783.1 C1145.1 C1149.1 C1181.1 CD21.1 CD22.1 CD43.1 CD44.1 CD65.1 CD66.1 CD87.1 CD88.1 CH27.1 CH48.1 CH49.1 CH65.1 D91.2 JDIMM1.199 JDIMM2.199 JDIMM3.199 JDIMM4.199 JIO1.122 JIO1.124 JIO1.126 JIO1.128 JIO1.130 JLVDS1.7 JSATA1.8 JSATA1.9 JUSH1.13 L60.2 L61.2 PJP8.1 PJP77.1 PR400.1 PR519.2 Q24.3 Q345.3 Q345.6 QH4.2 QH4.5 R13.1 R18.1 R22.1 R23.1 R24.1 R25.1 R26.1 R27.1 R28.1 R30.1 R45.1 R56.1 R58.1 R64.1 R65.1 R68.1 R70.1 R71.1 R72.1 R76.1 R78.1 R80.1 R98.2 R99.2 R117.2 R118.2 R119.2 R120.2 R124.2 R159.1 R160.1 R339.1 R405.1 R407.1 R408.1 R409.1 R415.1 R501.1 R502.1 R503.1 R504.1 R513.1 R518.1 R782.2 R799.1 R822.1 R823.2 R824.2 R829.1 R1118.1 R1123.1 R1124.1 R1165.2 R1197.1 R1530.1 R1532.1 R1539.1 R1986.1 R1990.2 R1994.1 R2151.1 R2152.1 R2154.1 R2157.1 R2161.1 R2190.1 R2191.1 RC19.1 RD8.2 RD26.2 RD27.2 RD36.2 RH34.1 RH36.2 RH37.2 RH40.1 RH74.1 RH77.1 RH83.1 RH86.1 RH90.1 RH120.1 RH140.2 RH168.1 RH200.1 RH202.2 RH205.2 RH208.2 RH225.2 RH226.2 RH228.2 RH229.2 RH242.1 RH245.1 RH255.1 RH256.1 RH328.1 RP3.1 RP3.2 RP3.3 RP3.4 RPH1.5 RPH1.6 RPH1.7 RPH1.8 RPH8.1 RPH8.2 RPH8.3 RPH8.4 RPH9.1 RPH9.2 RPH9.3 RPH10.1 RPH10.2 RPH10.3 RPH10.4 U3.5 U8.1 U9.14 U9.28 U9.41 U9.56 U11.35 U13.35 U19.11 U20.14 U22.1 U22.6 U22.12 U22.25 U22.32 U22.36 U88.1 U88.7 U88.8 U88.14 U629.21 U629.26 U629.35 U629.49 U629.60 U638.9 U638.25 UH1.AE14 UH1.AF12 UH1.AG14 UH1.AK30 UH1.AK32 UH1.L24 UH1.M31 UH1.R30 UH1.R32 UH3.5
+3.3V_RUN_R: JSATA1.10 R45.2
+3.3V_RUN_TPM: C45.1 C48.1 C550.1 C551.1 C552.1 C553.1 PJP77.2 U39.5 U39.10 U39.19 U39.24
+3.3V_RUN_U38: C358.1 PJP8.2 U38.7 U38.8
+3.3V_SPI: C746.1 C1216.1 JSPI1.15 R3664.1 R3665.1 R3666.1 R3668.1 RH185.2 U52.8 U53.8
+3.3V_SUS: C53.1 C725.1 JIO1.86 JUSH1.8 JUSH1.9 JUSH1.10 PJP9.1 R585.1 R589.1
+3.3V_SUS_U57: C361.1 PJP9.2 U57.8 U57.9
+3.3V_VCCPRTCSUS: CH53.1 RH240.2 UH1.K8
+3.3V_WLAN: C604.1 C605.1 C606.2 C607.2 C608.1 C761.1 JMINI4.2 JMINI4.24 JMINI4.39 JMINI4.41 JMINI4.52 Q89.2 Q124.2 Q124.5 R692.2 R695.2 R696.2 R705.2 R718.2 R725.2 U63.8 U63.9
+3VALWP: PC101.1 PJP100.1 PJP101.1 PL103.2 PR100.1
+5V_ALW: C669.1 C670.1 C675.1 C676.1 C715.1 C721.1 JIO1.91 JIO1.93 JIO1.95 JIO1.97 JIO1.99 JIO1.101 JIO1.103 JIO1.105 JIO1.107 JIO1.109 JPB1.2 PC213.1 PC308.1 PC727.1 PC728.1 PJP102.2 PJP103.2 PR11.1 PR203.1 PR501.2 PR520.2 PR531.2 PR735.2 PR1012.2 PU1.5 PU200.12 PU300.7 PU703.8 Q75.3 Q79.3 Q86.3 R816.2 R1614.2 R1629.1 U2.5 U34.4 U35.1 U35.2 U35.4 U37.1 U37.2 U37.4 U38.4 U43.4 U45.2 U45.3 U48.2 U48.3 U56.4 U57.1 U57.2 U57.4 U63.4
+5V_ALW2: PC118.1 PU101.13
+5V_ALW_R: C290.1 R1629.2 U4.1
+5V_ESATA_PWR: C667.1 C668.1 JESA1.1 U48.8 U48.9
+5V_HDD: C395.1 C406.1 JSATA1.14 JSATA1.15 JSATA1.16 PJP33.1
+5V_MOD: C428.1 C429.1 C767.1 JODD1.9 JODD1.10 U57.13 U57.14
+5V_MXM: C7.1 C328.1 JMXM1.37 JMXM1.39 JMXM1.41 JMXM1.43 JMXM1.45 PJP5.1
+5V_MXM_U35: C356.1 PJP5.2 U35.13 U35.14
+5V_RUN: C56.1 C329.1 C330.1 C364.1 C370.1 C758.1 C763.1 C1182.1 JFAN1.4 JFAN2.4 JIO1.129 JIO1.131 JIO1.133 JKB1.9 JKB1.10 JUSH1.14 PJP7.1 PJP33.2 Q80.3 R12.1 R1537.1 R2153.1 R2193.1 RP6.1 RP6.2 RP6.3 RP6.4 U5.1 U6.1 U19.21 U19.29
+5V_RUN_U37: C357.1 PJP7.2 U37.7 U37.8
+5V_USB_PWR1: C324.1 C793.1 JUSB1.1 U45.8
+5V_USB_PWR2: C323.1 C794.1 JUSB2.1 U45.9
+5VALWP: PC102.1 PJP102.1 PJP103.1 PL102.2 PR101.1 PU101.14
+AVCC33: C106.1 C107.1 C108.1 L61.1 U23.5
+DVCC33: C113.1 C114.1 C115.1 C116.1 C117.1 L60.1 U23.18 U23.22
+VCC_4021: C318.1 C1180.1 R392.2 R394.2 U29.1
+VCC_CORE: JCPU1.AA26 JCPU1.AA28 JCPU1.AA30 JCPU1.AA32 JCPU1.AA34 JCPU1.AB25 JCPU1.AB26 JCPU1.AB27 JCPU1.AB28 JCPU1.AB29 JCPU1.AB30 JCPU1.AB31 JCPU1.AB32 JCPU1.AB33 JCPU1.AB34 JCPU1.AB35 JCPU1.AC26 JCPU1.AC28 JCPU1.AC30 JCPU1.AC32 JCPU1.AC34 JCPU1.AD25 JCPU1.AD26 JCPU1.AD27 JCPU1.AD28 JCPU1.AD29 JCPU1.AD30 JCPU1.AD31 JCPU1.AD32 JCPU1.AD33 JCPU1.AD34 JCPU1.AD35 JCPU1.AE26 JCPU1.AE28 JCPU1.AE30 JCPU1.AE32 JCPU1.AE34 JCPU1.AF25 JCPU1.AF26 JCPU1.AF27 JCPU1.AF28 JCPU1.AF29 JCPU1.AF30 JCPU1.AF31 JCPU1.AF32 JCPU1.AF33 JCPU1.AF34 JCPU1.AF35 JCPU1.AG26 JCPU1.AG28 JCPU1.AG30 JCPU1.AG32 JCPU1.AG34 JCPU1.AH25 JCPU1.AH26 JCPU1.AH27 JCPU1.AH28 JCPU1.AH29 JCPU1.AH30 JCPU1.AH31 JCPU1.AH32 JCPU1.AH33 JCPU1.AH34 JCPU1.AH35 JCPU1.AJ25 JCPU1.AJ26 JCPU1.AJ27 JCPU1.AJ28 JCPU1.AJ29 JCPU1.AJ30 JCPU1.AJ31 JCPU1.AJ32 JCPU1.AJ33 JCPU1.AJ34 JCPU1.AJ35 JCPU1.F25 JCPU1.G25 JCPU1.H25 JCPU1.J25 JCPU1.K25 JCPU1.K26 JCPU1.L25 JCPU1.M25 JCPU1.N25 JCPU1.P25 JCPU1.R25 JCPU1.T25 JCPU1.U25 JCPU1.U26 JCPU1.V25 JCPU1.V26 JCPU1.W26 JCPU1.W27 JCPU1.Y25 JCPU1.Y26 JCPU1.Y27 JCPU1.Y28 JCPU1.Y29 JCPU1.Y30 JCPU1.Y31 JCPU1.Y32 JCPU1.Y33 JCPU1.Y34 JCPU1.Y35 PC900.1 PC901.1 PC902.1 PC903.1 PC904.1 PC905.1 PC907.1 PC908.1 PC909.1 PC910.1 PC911.1 PC912.1 PC913.1 PC914.1 PC916.1 PC917.1 PC918.1 PC919.1 PC920.1 PC921.1 PC922.1 PC923.1 PC924.1 PC925.1 PC926.1 PC935.1 PC936.1 PC937.1 PC938.1 PC939.1 PC940.1 PC941.1 PC942.1 PC943.1 PL500.1 PL501.1 PL502.1 PR512.2 PR544.1 PR555.1 RC66.1
+VCCADAC: CH18.1 CH19.1 CH20.1 LH1.2 UH1.P45
+VCCIO2PCH: CC137.1 CH60.1 CH61.1 CH62.1 R105.2 RC106.2 UH1.AJ12 UH1.AJ14
+VCCIO2PCH_R: JCPU1.A23 RC106.1
+VCCIO_OUT: CC65.1 CC66.1 JCPU1.AN35 JXDP1.43 JXDP1.44 PR500.2 PR503.2 PR504.2 R399.1 RC44.1 RC60.1 RC63.1 RC65.2 RC128.1
+VCCST: CC78.1 CC79.1 JCPU1.AK31 RC99.1
GND: C1.2 C2.2 C3.2 C4.2 C7.2 C8.2 C14.2 C15.2 C16.2 C20.2 C22.2 C23.2 C45.2 C46.2 C47.2 C48.2 C52.2 C53.2 C56.2 C86.2 C87.2 C88.2 C90.2 C95.2 C97.1 C106.2 C107.2 C108.2 C109.2 C110.2 C111.2 C112.2 C113.2 C114.2 C115.2 C116.2 C117.2 C119.2 C243.2 C248.2 C249.1 C278.2 C287.2 C289.2 C290.2 C296.2 C298.2 C299.2 C300.2 C301.2 C313.2 C318.2 C319.2 C323.2 C324.2 C327.2 C328.2 C329.2 C330.2 C332.2 C356.2 C357.2 C358.2 C359.2 C360.2 C361.2 C364.2 C370.2 C391.2 C392.2 C395.2 C402.2 C403.2 C404.2 C405.2 C406.2 C410.2 C428.2 C429.2 C435.2 C436.2 C437.2 C449.2 C450.2 C453.2 C462.2 C463.2 C464.2 C466.2 C467.2 C468.2 C469.2 C470.2 C471.2 C472.2 C473.2 C474.2 C478.2 C479.2 C480.2 C481.2 C482.2 C483.2 C484.2 C485.1 C486.2 C494.2 C495.2 C496.2 C497.2 C499.2 C504.2 C541.2 C542.2 C543.2 C544.2 C545.2 C546.2 C547.2 C548.2 C549.2 C550.2 C551.2 C552.2 C553.2 C554.2 C555.2 C593.2 C594.2 C595.2 C604.2 C605.2 C606.1 C607.1 C608.2 C610.2 C611.2 C612.2 C613.2 C614.2 C615.2 C616.2 C617.2 C624.2 C628.2 C629.2 C630.2 C631.2 C633.2 C634.2 C637.1 C638.1 C639.2 C667.2 C668.2 C669.2 C670.2 C675.2 C676.2 C695.2 C696.2 C702.2 C703.2 C704.2 C708.2 C709.2 C710.2 C712.2 C713.2 C714.2 C715.2 C716.2 C717.2 C718.2 C719.2 C721.2 C722.2 C723.2 C724.2 C725.2 C726.2 C734.2 C735.2 C736.2 C737.2 C739.2 C740.2 C741.2 C742.2 C743.2 C744.2 C746.2 C747.2 C756.2 C757.2 C758.2 C760.2 C761.2 C763.2 C764.2 C765.2 C766.2 C767.2 C769.2 C770.2 C772.2 C773.2 C774.2 C776.2 C777.2 C779.2 C780.2 C781.2 C782.2 C783.2 C793.2 C794.2 C1145.2 C1149.2 C1167.2 C1174.2 C1176.2 C1177.2 C1178.2 C1179.2 C1180.2 C1181.2 C1182.2 C1216.2 C1312.2 C1313.2 C1323.2 C1324.2 C1325.2 C1326.2 C1327.2 C1332.2 C1333.2 C1334.2 C1335.2 C1336.2 C1337.2 C1338.2 C1339.2 C1340.2 C1341.2 C1345.2 C1347.2 C1348.2 C1349.2 C1352.2 C1353.2 C1355.2 CC33.2 CC34.2 CC35.2 CC36.2 CC37.2 CC38.2 CC39.2 CC40.2 CC41.2 CC42.2 CC43.2 CC65.2 CC66.2 CC78.2 CC79.2 CC137.2 CC138.2 CC161.2 CC162.2 CC163.2 CC164.2 CC165.2 CC166.2 CC167.2 CC168.2 CC169.2 CC170.2 CC171.2 CC172.2 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD21.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD30.2 CD31.2 CD32.2 CD33.2 CD34.2 CD35.2 CD36.2 CD37.2 CD38.2 CD39.2 CD40.2 CD41.2 CD42.2 CD43.2 CD44.2 CD45.2 CD46.2 CD47.2 CD48.2 CD49.2 CD50.2 CD51.2 CD52.2 CD53.2 CD54.2 CD55.2 CD56.2 CD57.2 CD58.2 CD59.2 CD60.2 CD61.2 CD62.2 CD63.2 CD64.2 CD65.2 CD66.2 CD67.2 CD68.2 CD69.2 CD70.2 CD71.2 CD72.2 CD73.2 CD74.2 CD75.2 CD76.2 CD77.2 CD78.2 CD79.2 CD80.2 CD81.2 CD82.2 CD83.2 CD84.2 CD85.2 CD86.2 CD87.2 CD88.2 CE1.2 CE2.2 CE3.2 CE8.2 CE9.2 CH2.2 CH4.1 CH5.1 CH6.1 CH7.1 CH9.2 CH13.1 CH14.1 CH15.2 CH16.2 CH17.2 CH18.2 CH19.2 CH20.2 CH21.2 CH22.2 CH23.2 CH24.2 CH25.2 CH26.2 CH27.2 CH28.2 CH29.2 CH30.2 CH31.2 CH32.2 CH33.2 CH34.2 CH35.2 CH36.2 CH37.2 CH38.2 CH39.2 CH40.2 CH41.2 CH42.2 CH43.2 CH44.2 CH45.2 CH46.2 CH47.2 CH48.2 CH49.2 CH50.2 CH51.2 CH52.2 CH53.2 CH54.2 CH55.2 CH56.2 CH57.2 CH58.2 CH59.2 CH60.2 CH61.2 CH62.2 CH63.2 CH64.2 CH65.2 CH66.2 CH67.2 CH68.2 CH69.2 CH70.2 CH71.2 CH72.2 CH73.2 CH74.2 CH75.2 CH76.2 CH77.2 CH78.2 CH79.2 CH80.2 CH93.2 CMOS1.1 D14.3 D15.1 D16.3 D17.1 D33.1 D73.1 D88.1 H2.1(TP-1) H3.1(TP-1) H4.1(TP-1) H5.1(TP-1) H7.1(TP-1) H8.1(TP-1) H9.1(TP-1) H10.1(TP-1) H11.1(TP-1) H13.1(TP-1) H14.1(TP-1) H15.1(TP-1) H16.1(TP-1) H17.1(TP-1) H18.1(TP-1) H19.1(TP-1) H20.1(TP-1) H21.1(TP-1) H22.1(TP-1) H23.1(TP-1) H24.1(TP-1) H25.1(TP-1) JAPS1.8 JAPS1.10 JAPS1.12 JAPS1.14 JAPS1.17 JAPS1.18 JCPU1.A3 JCPU1.A4 JCPU1.A7 JCPU1.A10 JCPU1.A13 JCPU1.A16 JCPU1.A19 JCPU1.A22 JCPU1.A25 JCPU1.A27 JCPU1.A29 JCPU1.A31 JCPU1.A33 JCPU1.AA11 JCPU1.AA25 JCPU1.AA27 JCPU1.AA29 JCPU1.AA31 JCPU1.AA33 JCPU1.AA35 JCPU1.AB1 JCPU1.AB3 JCPU1.AB4 JCPU1.AB6 JCPU1.AB7 JCPU1.AB9 JCPU1.AB10 JCPU1.AC11 JCPU1.AC25 JCPU1.AC27 JCPU1.AC29 JCPU1.AC31 JCPU1.AC33 JCPU1.AC35 JCPU1.AD7 JCPU1.AD11 JCPU1.AE1 JCPU1.AE3 JCPU1.AE4 JCPU1.AE6 JCPU1.AE7 JCPU1.AE9 JCPU1.AE10 JCPU1.AE25 JCPU1.AE27 JCPU1.AE29 JCPU1.AE31 JCPU1.AE33 JCPU1.AE35 JCPU1.AF6 JCPU1.AF8 JCPU1.AF11 JCPU1.AG6 JCPU1.AG11 JCPU1.AG25 JCPU1.AG27 JCPU1.AG29 JCPU1.AG31 JCPU1.AG33 JCPU1.AG35 JCPU1.AH1 JCPU1.AH2 JCPU1.AH3 JCPU1.AH4 JCPU1.AH5 JCPU1.AH6 JCPU1.AH7 JCPU1.AH8 JCPU1.AH9 JCPU1.AH10 JCPU1.AJ5 JCPU1.AJ11 JCPU1.AK5 JCPU1.AK11 JCPU1.AK25 JCPU1.AK26 JCPU1.AK28 JCPU1.AK29 JCPU1.AK30 JCPU1.AK32 JCPU1.AK34 JCPU1.AL1 JCPU1.AL2 JCPU1.AL3 JCPU1.AL4 JCPU1.AL5 JCPU1.AL6 JCPU1.AL7 JCPU1.AL8 JCPU1.AL9 JCPU1.AL10 JCPU1.AL11 JCPU1.AL12 JCPU1.AL14 JCPU1.AL15 JCPU1.AL17 JCPU1.AL18 JCPU1.AL19 JCPU1.AL20 JCPU1.AL21 JCPU1.AL22 JCPU1.AL23 JCPU1.AL24 JCPU1.AL31 JCPU1.AL32 JCPU1.AM4 JCPU1.AM7 JCPU1.AM10 JCPU1.AM13 JCPU1.AM16 JCPU1.AM19 JCPU1.AM20 JCPU1.AM21 JCPU1.AM22 JCPU1.AM23 JCPU1.AM24 JCPU1.AM25 JCPU1.AM32 JCPU1.AN2 JCPU1.AN4 JCPU1.AN7 JCPU1.AN10 JCPU1.AN13 JCPU1.AN16 JCPU1.AN19 JCPU1.AN21 JCPU1.AN24 JCPU1.AN27 JCPU1.AN30 JCPU1.AN34 JCPU1.AP1 JCPU1.AP4 JCPU1.AP7 JCPU1.AP10 JCPU1.AP13 JCPU1.AP16 JCPU1.AP19 JCPU1.AP27 JCPU1.AP34 JCPU1.AP35 JCPU1.AR2 JCPU1.AR4 JCPU1.AR7 JCPU1.AR10 JCPU1.AR13 JCPU1.AR16 JCPU1.AR19 JCPU1.AR22 JCPU1.AR25 JCPU1.AR26 JCPU1.AR28 JCPU1.AR31 JCPU1.AR34 JCPU1.AT3 JCPU1.AT4 JCPU1.AT7 JCPU1.AT10 JCPU1.AT13 JCPU1.AT16 JCPU1.AT19 JCPU1.AT21 JCPU1.AT24 JCPU1.AT27 JCPU1.AT30 JCPU1.AT32 JCPU1.AT33 JCPU1.AT34 JCPU1.B2 JCPU1.B4 JCPU1.B7 JCPU1.B10 JCPU1.B13 JCPU1.B16 JCPU1.B19 JCPU1.B22 JCPU1.B34 JCPU1.C1 JCPU1.C2 JCPU1.C4 JCPU1.C7 JCPU1.C10 JCPU1.C13 JCPU1.C16 JCPU1.C19 JCPU1.C22 JCPU1.C24 JCPU1.C26 JCPU1.C28 JCPU1.C30 JCPU1.C32 JCPU1.C34 JCPU1.D4 JCPU1.D7 JCPU1.D10 JCPU1.D13 JCPU1.D16 JCPU1.D19 JCPU1.D22 JCPU1.D25 JCPU1.D27 JCPU1.D29 JCPU1.D31 JCPU1.D33 JCPU1.D35 JCPU1.E1 JCPU1.E4 JCPU1.E7 JCPU1.E10 JCPU1.E13 JCPU1.E16 JCPU1.E19 JCPU1.E22 JCPU1.E25 JCPU1.F4 JCPU1.F6 JCPU1.F7 JCPU1.F8 JCPU1.F9 JCPU1.F10 JCPU1.F11 JCPU1.F12 JCPU1.F14 JCPU1.F15 JCPU1.F17 JCPU1.F18 JCPU1.F19 JCPU1.F20 JCPU1.F21 JCPU1.F23 JCPU1.F24 JCPU1.F26 JCPU1.F28 JCPU1.F30 JCPU1.F32 JCPU1.F34 JCPU1.G1 JCPU1.G2 JCPU1.G3 JCPU1.G4 JCPU1.G5 JCPU1.G11 JCPU1.G27 JCPU1.G29 JCPU1.G31 JCPU1.G33 JCPU1.G35 JCPU1.H6 JCPU1.H7 JCPU1.H10 JCPU1.H11 JCPU1.H26 JCPU1.J6 JCPU1.J11 JCPU1.J26 JCPU1.J28 JCPU1.J30 JCPU1.J32 JCPU1.J34 JCPU1.K1 JCPU1.K2 JCPU1.K3 JCPU1.K4 JCPU1.K5 JCPU1.K7 JCPU1.K8 JCPU1.K9 JCPU1.K10 JCPU1.K29 JCPU1.K31 JCPU1.K33 JCPU1.K35 JCPU1.L6 JCPU1.L11 JCPU1.L26 JCPU1.M6 JCPU1.M11 JCPU1.M26 JCPU1.M28 JCPU1.M30 JCPU1.M32 JCPU1.M34 JCPU1.N1 JCPU1.N2 JCPU1.N3 JCPU1.N4 JCPU1.N5 JCPU1.N6 JCPU1.N7 JCPU1.N9 JCPU1.N10 JCPU1.N29 JCPU1.N31 JCPU1.N33 JCPU1.N35 JCPU1.P5 JCPU1.P11 JCPU1.P26 JCPU1.R5 JCPU1.R10 JCPU1.R11 JCPU1.R26 JCPU1.R28 JCPU1.R30 JCPU1.R32 JCPU1.R34 JCPU1.T1 JCPU1.T3 JCPU1.T4 JCPU1.T6 JCPU1.T7 JCPU1.T9 JCPU1.T10 JCPU1.T26 JCPU1.T29 JCPU1.T31 JCPU1.T33 JCPU1.T35 JCPU1.U11 JCPU1.U27 JCPU1.V10 JCPU1.V11 JCPU1.V28 JCPU1.V30 JCPU1.V32 JCPU1.V34 JCPU1.W1 JCPU1.W3 JCPU1.W4 JCPU1.W6 JCPU1.W7 JCPU1.W9 JCPU1.W10 JCPU1.W25 JCPU1.W33 JCPU1.W35 JCPU1.Y11 JCRT1.5 JCRT1.6 JCRT1.7 JCRT1.8 JCRT1.10 JCRT1.16 JCRT1.17 JCRT1.18 JCRT1.19 JDEG2.1 JDEG2.11 JDEG2.12 JDIMM1.2 JDIMM1.3 JDIMM1.8 JDIMM1.9 JDIMM1.11 JDIMM1.13 JDIMM1.14 JDIMM1.19 JDIMM1.20 JDIMM1.25 JDIMM1.26 JDIMM1.28 JDIMM1.31 JDIMM1.32 JDIMM1.37 JDIMM1.38 JDIMM1.43 JDIMM1.44 JDIMM1.46 JDIMM1.48 JDIMM1.49 JDIMM1.54 JDIMM1.55 JDIMM1.60 JDIMM1.61 JDIMM1.63 JDIMM1.65 JDIMM1.66 JDIMM1.71 JDIMM1.72 JDIMM1.127 JDIMM1.128 JDIMM1.133 JDIMM1.134 JDIMM1.136 JDIMM1.138 JDIMM1.139 JDIMM1.144 JDIMM1.145 JDIMM1.150 JDIMM1.151 JDIMM1.153 JDIMM1.155 JDIMM1.156 JDIMM1.161 JDIMM1.162 JDIMM1.167 JDIMM1.168 JDIMM1.170 JDIMM1.172 JDIMM1.173 JDIMM1.178 JDIMM1.179 JDIMM1.184 JDIMM1.185 JDIMM1.187 JDIMM1.189 JDIMM1.190 JDIMM1.195 JDIMM1.196 JDIMM1.205 JDIMM1.206 JDIMM2.2 JDIMM2.3 JDIMM2.8 JDIMM2.9 JDIMM2.11 JDIMM2.13 JDIMM2.14 JDIMM2.19 JDIMM2.20 JDIMM2.25 JDIMM2.26 JDIMM2.28 JDIMM2.31 JDIMM2.32 JDIMM2.37 JDIMM2.38 JDIMM2.43 JDIMM2.44 JDIMM2.46 JDIMM2.48 JDIMM2.49 JDIMM2.54 JDIMM2.55 JDIMM2.60 JDIMM2.61 JDIMM2.63 JDIMM2.65 JDIMM2.66 JDIMM2.71 JDIMM2.72 JDIMM2.127 JDIMM2.128 JDIMM2.133 JDIMM2.134 JDIMM2.136 JDIMM2.138 JDIMM2.139 JDIMM2.144 JDIMM2.145 JDIMM2.150 JDIMM2.151 JDIMM2.153 JDIMM2.155 JDIMM2.156 JDIMM2.161 JDIMM2.162 JDIMM2.167 JDIMM2.168 JDIMM2.170 JDIMM2.172 JDIMM2.173 JDIMM2.178 JDIMM2.179 JDIMM2.184 JDIMM2.185 JDIMM2.187 JDIMM2.189 JDIMM2.190 JDIMM2.195 JDIMM2.196 JDIMM2.205 JDIMM2.206 JDIMM3.2 JDIMM3.3 JDIMM3.8 JDIMM3.9 JDIMM3.11 JDIMM3.13 JDIMM3.14 JDIMM3.19 JDIMM3.20 JDIMM3.25 JDIMM3.26 JDIMM3.28 JDIMM3.31 JDIMM3.32 JDIMM3.37 JDIMM3.38 JDIMM3.43 JDIMM3.44 JDIMM3.46 JDIMM3.48 JDIMM3.49 JDIMM3.54 JDIMM3.55 JDIMM3.60 JDIMM3.61 JDIMM3.63 JDIMM3.65 JDIMM3.66 JDIMM3.71 JDIMM3.72 JDIMM3.127 JDIMM3.128 JDIMM3.133 JDIMM3.134 JDIMM3.136 JDIMM3.138 JDIMM3.139 JDIMM3.144 JDIMM3.145 JDIMM3.150 JDIMM3.151 JDIMM3.153 JDIMM3.155 JDIMM3.156 JDIMM3.161 JDIMM3.162 JDIMM3.167 JDIMM3.168 JDIMM3.170 JDIMM3.172 JDIMM3.173 JDIMM3.178 JDIMM3.179 JDIMM3.184 JDIMM3.185 JDIMM3.187 JDIMM3.189 JDIMM3.190 JDIMM3.195 JDIMM3.196 JDIMM3.205 JDIMM3.206 JDIMM4.2 JDIMM4.3 JDIMM4.8 JDIMM4.9 JDIMM4.11 JDIMM4.13 JDIMM4.14 JDIMM4.19 JDIMM4.20 JDIMM4.25 JDIMM4.26 JDIMM4.28 JDIMM4.31 JDIMM4.32 JDIMM4.37 JDIMM4.38 JDIMM4.43 JDIMM4.44 JDIMM4.46 JDIMM4.48 JDIMM4.49 JDIMM4.54 JDIMM4.55 JDIMM4.60 JDIMM4.61 JDIMM4.63 JDIMM4.65 JDIMM4.66 JDIMM4.71 JDIMM4.72 JDIMM4.127 JDIMM4.128 JDIMM4.133 JDIMM4.134 JDIMM4.136 JDIMM4.138 JDIMM4.139 JDIMM4.144 JDIMM4.145 JDIMM4.150 JDIMM4.151 JDIMM4.153 JDIMM4.155 JDIMM4.156 JDIMM4.161 JDIMM4.162 JDIMM4.167 JDIMM4.168 JDIMM4.170 JDIMM4.172 JDIMM4.173 JDIMM4.178 JDIMM4.179 JDIMM4.184 JDIMM4.185 JDIMM4.187 JDIMM4.189 JDIMM4.190 JDIMM4.195 JDIMM4.196 JDIMM4.205 JDIMM4.206 JDOCK1.1 JDOCK1.7 JDOCK1.8 JDOCK1.13 JDOCK1.14 JDOCK1.19 JDOCK1.20 JDOCK1.25 JDOCK1.26 JDOCK1.31 JDOCK1.32 JDOCK1.37 JDOCK1.38 JDOCK1.43 JDOCK1.44 JDOCK1.47 JDOCK1.49 JDOCK1.50 JDOCK1.51 JDOCK1.52 JDOCK1.55 JDOCK1.57 JDOCK1.58 JDOCK1.61 JDOCK1.63 JDOCK1.64 JDOCK1.69 JDOCK1.70 JDOCK1.75 JDOCK1.76 JDOCK1.81 JDOCK1.82 JDOCK1.87 JDOCK1.88 JDOCK1.91 JDOCK1.93 JDOCK1.94 JDOCK1.95 JDOCK1.96 JDOCK1.101 JDOCK1.102 JDOCK1.107 JDOCK1.108 JDOCK1.113 JDOCK1.114 JDOCK1.119 JDOCK1.120 JDOCK1.123 JDOCK1.125 JDOCK1.126 JDOCK1.131 JDOCK1.132 JDOCK1.137 JDOCK1.138 JDOCK1.145 JDOCK1.152 JDOCK1.153 JDOCK1.154 JDOCK1.155 JDOCK1.156 JDOCK1.157 JDOCK1.158 JDOCK1.159 JDOCK1.160 JDOCK1.161 JDOCK1.162 JDOCK1.163 JDOCK1.164 JDP1.2 JDP1.5 JDP1.8 JDP1.11 JDP1.16 JDP1.19 JDP1.21 JDP1.22 JDP1.23 JDP1.24 JEPWR1.2 JEPWR1.7 JEPWR1.8 JESA1.4 JESA1.5 JESA1.8 JESA1.11 JESA1.12 JESA1.13 JESA1.14 JESA1.15 JFAN1.1 JFAN1.5 JFAN1.6 JFAN2.1 JFAN2.5 JFAN2.6 JHDMI1.2 JHDMI1.5 JHDMI1.8 JHDMI1.11 JHDMI1.17 JHDMI1.20 JHDMI1.21 JHDMI1.22 JHDMI1.23 JIO1.3 JIO1.4 JIO1.9 JIO1.10 JIO1.15 JIO1.16 JIO1.21 JIO1.22 JIO1.27 JIO1.28 JIO1.33 JIO1.34 JIO1.39 JIO1.43 JIO1.46 JIO1.49 JIO1.55 JIO1.61 JIO1.67 JIO1.78 JIO1.84 JIO1.88 JIO1.89 JIO1.111 JIO1.113 JIO1.115 JIO1.117 JIO1.119 JIO1.120 JIO1.121 JIO1.123 JIO1.125 JIO1.127 JIO1.132 JIO1.134 JIO1.135 JIO1.136 JIO1.137 JIO1.138 JIO1.139 JIO1.140 JIO1.141 JIO1.142 JKB1.15 JKB1.16 JKB1.19 JKB1.20 JLOM1.14 JLOM1.15 JLVDS1.10 JLVDS1.29 JLVDS1.32 JLVDS1.35 JLVDS1.38 JLVDS1.41 JLVDS1.42 JLVDS1.43 JLVDS1.44 JLVDS1.45 JMINI2.4 JMINI2.9 JMINI2.15 JMINI2.18 JMINI2.21 JMINI2.26 JMINI2.27 JMINI2.29 JMINI2.34 JMINI2.35 JMINI2.37 JMINI2.43 JMINI2.50 JMINI2.53 JMINI2.54 JMINI3.4 JMINI3.9 JMINI3.15 JMINI3.18 JMINI3.21 JMINI3.26 JMINI3.27 JMINI3.29 JMINI3.34 JMINI3.35 JMINI3.43 JMINI3.50 JMINI3.53 JMINI3.54 JMINI4.4 JMINI4.9 JMINI4.15 JMINI4.18 JMINI4.21 JMINI4.26 JMINI4.27 JMINI4.29 JMINI4.34 JMINI4.35 JMINI4.43 JMINI4.50 JMINI4.53 JMINI4.54 JMXM1.19 JMXM1.20 JMXM1.21 JMXM1.22 JMXM1.23 JMXM1.24 JMXM1.25 JMXM1.26 JMXM1.27 JMXM1.28 JMXM1.29 JMXM1.30 JMXM1.31 JMXM1.32 JMXM1.33 JMXM1.34 JMXM1.35 JMXM1.36 JMXM1.47 JMXM1.49 JMXM1.51 JMXM1.53 JMXM1.72 JMXM1.73 JMXM1.82 JMXM1.83 JMXM1.88 JMXM1.89 JMXM1.94 JMXM1.95 JMXM1.100 JMXM1.101 JMXM1.106 JMXM1.107 JMXM1.112 JMXM1.113 JMXM1.118 JMXM1.119 JMXM1.124 JMXM1.125 JMXM1.130 JMXM1.131 JMXM1.136 JMXM1.137 JMXM1.142 JMXM1.143 JMXM1.148 JMXM1.149 JMXM1.154 JMXM1.155 JMXM1.160 JMXM1.161 JMXM1.162 JMXM1.163 JMXM1.168 JMXM1.169 JMXM1.174 JMXM1.175 JMXM1.180 JMXM1.181 JMXM1.187 JMXM1.194 JMXM1.202 JMXM1.203 JMXM1.208 JMXM1.209 JMXM1.214 JMXM1.215 JMXM1.220 JMXM1.221 JMXM1.226 JMXM1.227 JMXM1.232 JMXM1.233 JMXM1.238 JMXM1.239 JMXM1.244 JMXM1.245 JMXM1.250 JMXM1.251 JMXM1.256 JMXM1.272 JMXM1.278 JMXM1.281 JMXM1.284 JMXM1.287 JMXM1.290 JMXM1.293 JMXM1.296 JMXM1.299 JMXM1.305 JMXM1.311 JMXM1.312 JODD1.1 JODD1.4 JODD1.7 JODD1.12 JODD1.13 JODD1.14 JODD1.15 JPB1.5 JPB1.6 JPB1.7 JPB1.8 JRTC1.2 JRTC1.3 JRTC1.4 JSATA1.1 JSATA1.4 JSATA1.7 JSATA1.11 JSATA1.13 JSATA1.17 JSATA1.19 JSATA1.23 JSATA1.24 JSIM1.5 JSIM1.10 JSIM1.11 JSIM1.12 JSIM1.13 JSIM1.14 JSIM1.15 JSIM1.16 JSIM1.17 JSIM1.18 JSPI1.17 JSPI1.18 JSPI1.19 JSPI1.20 JSPI1.21 JSPI1.22 JTAG1.2 JUSB1.4 JUSB1.7 JUSB1.10 JUSB1.11 JUSB1.12 JUSB1.13 JUSB2.4 JUSB2.7 JUSB2.10 JUSB2.11 JUSB2.12 JUSB2.13 JUSH1.1 JUSH1.4 JUSH1.18 JUSH1.19 JUSH1.21 JUSH1.22 JWL1.1 JWL1.4 JWL1.5 JXDP1.1 JXDP1.2 JXDP1.7 JXDP1.8 JXDP1.13 JXDP1.14 JXDP1.19 JXDP1.20 JXDP1.25 JXDP1.26 JXDP1.31 JXDP1.32 JXDP1.37 JXDP1.38 JXDP1.49 JXDP1.50 JXDP1.59 JXDP2.1 JXDP2.2 JXDP2.7 JXDP2.8 JXDP2.13 JXDP2.14 JXDP2.19 JXDP2.20 JXDP2.25 JXDP2.26 JXDP2.31 JXDP2.32 JXDP2.37 JXDP2.38 JXDP2.49 JXDP2.50 JXDP2.59 JXDP2.60 ME1.1 PBATT1.6 PBATT1.8 PBATT1.9 PBATT1.10 PBATT1.11 PC1.2 PC2.2 PC4.2 PC5.2 PC8.2 PC11.2 PC14.2 PC15.2 PC16.2 PC30.2 PC31.2 PC101.2 PC102.2 PC104.2 PC105.2 PC106.2 PC107.2 PC109.2 PC110.2 PC114.1 PC116.2 PC117.2 PC118.2 PC119.2 PC120.2 PC201.2 PC202.2 PC203.2 PC204.2 PC205.2 PC207.2 PC208.2 PC209.2 PC210.2 PC212.2 PC213.2 PC214.2 PC215.2 PC216.2 PC217.2 PC219.2 PC220.2 PC301.2 PC302.2 PC303.2 PC304.2 PC305.2 PC307.2 PC308.2 PC309.2 PC400.2 PC403.2 PC404.2 PC406.2 PC407.2 PC500.2 PC502.2 PC503.2 PC504.2 PC508.1 PC509.1 PC510.2 PC511.2 PC512.2 PC513.2 PC514.2 PC515.2 PC516.2 PC519.2 PC525.1 PC526.1 PC527.1 PC529.2 PC530.2 PC531.2 PC533.2 PC534.2 PC535.2 PC542.1 PC546.1 PC547.2 PC701.2 PC702.1 PC704.2 PC705.2 PC706.2 PC707.2 PC708.2 PC715.2 PC717.2 PC718.2 PC719.2 PC727.2 PC728.2 PC729.2 PC730.2 PC731.2 PC732.2 PC733.1 PC735.2 PC736.2 PC744.1 PC745.2 PC746.2 PC783.2 PC786.2 PC791.2 PC900.2 PC901.2 PC902.2 PC903.2 PC904.2 PC905.2 PC907.2 PC908.2 PC909.2 PC910.2 PC911.2 PC912.2 PC913.2 PC914.2 PC916.2 PC917.2 PC918.2 PC919.2 PC920.2 PC921.2 PC922.2 PC923.2 PC924.2 PC925.2 PC926.2 PC935.2 PC936.2 PC937.2 PC938.2 PC939.2 PC940.2 PC941.2 PC942.2 PC943.2 PC1002.2 PC1003.2 PC1004.2 PC1005.2 PC1006.2 PC1007.2 PC1008.2 PC1009.2 PC1080.1 PC1081.1 PD2.1 PD3.1 PD8.2 PJPDC1.3 PJPDC1.4 PJPDC1.5 PJPDC1.6 PJPDC1.11 PQ3.3 PQ7.3 PQ8.6 PQ103.1 PQ103.2 PQ103.3 PQ104.1 PQ104.2 PQ104.3 PQ202.1 PQ202.2 PQ202.3 PQ204.1 PQ204.4 PQ205.1 PQ205.4 PQ303.1 PQ303.2 PQ303.3 PQ500.8 PQ502.8 PQ504.8 PQ705.1 PQ705.2 PQ705.3 PQ706.1 PQ706.4 PQ707.1 PQ707.4 PQ710.1 PQ710.4 PQ1010.3 PQ1011.3 PQ1071.1 PQ1071.4 PQ1080.1 PQ1080.4 PQ1082.3 PQ1083.6 PR12.1 PR18.2 PR19.2 PR22.2 PR102.1 PR104.1 PR105.2 PR106.2 PR207.1 PR217.2 PR220.2 PR224.2 PR225.2 PR302.1 PR305.2 PR307.1 PR404.2 PR405.2 PR507.1 PR509.1 PR514.1 PR515.2 PR521.2 PR525.1 PR529.1 PR542.2 PR554.2 PR558.1 PR717.2 PR732.1 PR744.2 PR745.2 PR746.2 PR748.2 PR758.2 PR1001.2 PR1003.2 PR1018.2 PR1026.1 PR1028.2 PR1031.1 PU1.2 PU101.21 PU200.1 PU200.3 PU200.14 PU200.21 PU300.11 PU400.11 PU500.33 PU501.4 PU501.9 PU700.4 PU700.14 PU700.21 PU701.1 PU701.2 PU703.4 PU704.3 PU1001.5 PU1001.14 PU1001.23 PU1001.32 PU1001.37 PU1080.3 PU1081.3 PWRSW1.2 Q22.3 Q29.1 Q29.4 Q45.3 Q52.3 Q55.3 Q81.4 Q87.3 Q110.1 Q110.4 Q304.1 Q304.4 Q322.3 Q326.3 Q336.1 Q336.4 Q338.3 Q339.1 Q339.4 Q346.1 Q346.4 QC5.3 QC6.3 QH3.3 R14.2 R17.1 R29.2 R39.2 R53.2 R54.2 R55.2 R57.1 R59.1 R61.1 R62.1 R63.1 R66.1 R67.1 R69.1 R73.1 R74.1 R75.1 R77.2 R79.2 R81.2 R82.2 R96.1 R101.1 R102.1 R115.2 R116.2 R121.2 R122.2 R123.2 R127.1 R222.1 R301.2 R336.1 R418.2 R420.2 R424.2 R429.1 R430.2 R431.2 R432.2 R491.1 R492.1 R514.2 R551.2 R558.2 R561.2 R562.2 R564.2 R566.2 R656.2 R717.2 R720.2 R733.2 R747.2 R757.2 R775.1 R783.2 R801.1 R803.2 R804.2 R820.1 R843.1 R869.1 R876.2 R883.1 R892.1 R931.2 R935.2 R1000.2 R1069.2 R1128.1 R1137.2 R1138.2 R1611.2 R1970.1 R1983.2 R1993.1 R1995.2 R2141.1 R2160.2 RC14.2 RC40.1 RC41.1 RC42.2 RC45.2 RC49.2 RC55.2 RC58.2 RC59.2 RC70.2 RC71.2 RC72.2 RC75.2 RC76.2 RC77.2 RC109.2 RC110.2 RC111.2 RC130.2 RD11.1 RD19.1 RD20.1 RD37.1 RD43.2 RD46.2 RD50.2 RH47.2 RH54.2 RH55.2 RH56.2 RH62.2 RH76.2 RH81.1 RH97.1 RH115.1 RH116.1 RH117.1 RH118.1 RH119.2 RH131.1 RH132.2 RH142.1 RH146.2 RH147.2 RH148.2 RH149.2 RH150.2 RH176.2 RH187.2 RH209.2 RH219.1 RH223.2 RH230.2 RP4.5 RP4.6 RP4.7 RP4.8 RP7.1 RP7.2 RP7.3 RP7.4 RP8.6 RP8.7 RP8.8 RPH3.5 RPH3.6 RPH3.7 RPH3.8 U2.9 U3.3 U4.2 U5.2 U6.2 U7.3 U8.2 U9.26 U9.35 U9.38 U9.43 U9.57 U10.3 U11.11 U11.37 U13.11 U13.37 U14.3 U15.3 U16.3 U17.3 U19.10 U19.20 U19.30 U19.41 U20.7 U22.3 U22.18 U22.24 U22.31 U22.49 U23.6 U23.16 U23.49 U25.3 U27.3 U29.2 U29.3 U29.6 U29.33 U31.49 U32.43 U34.11 U34.15 U35.11 U35.15 U37.5 U37.9 U38.5 U38.9 U39.1 U39.2 U39.3 U39.4 U39.8 U39.11 U39.18 U39.25 U43.5 U43.9 U45.1 U45.11 U46.B27 U46.C1 U48.1 U48.11 U50.3 U51.B11 U51.B18 U51.B54 U51.B60 U51.B66 U51.C1 U52.4 U53.4 U54.3 U56.5 U56.9 U57.11 U57.15 U58.3 U62.2 U63.11 U63.15 U88.5 U88.10 U88.12 U88.13 U88.15 U88.16 U629.8 U629.18 U629.33 U629.41 U629.53 U629.57 U629.61 U637.3 U637.6 U637.21 U638.3 U638.6 U638.19 U638.33 UC2.3 UH1.A2 UH1.A4 UH1.A5 UH1.A41 UH1.A43 UH1.A44 UH1.AA4 UH1.AA16 UH1.AA20 UH1.AA22 UH1.AA28 UH1.AB8 UH1.AB12 UH1.AB34 UH1.AB38 UH1.AC2 UH1.AC44 UH1.AD6 UH1.AD8 UH1.AD14 UH1.AD16 UH1.AD18 UH1.AD30 UH1.AD32 UH1.AD40 UH1.AE16 UH1.AE28 UH1.AF8 UH1.AF38 UH1.AG2 UH1.AG16 UH1.AG26 UH1.AG28 UH1.AG44 UH1.AJ6 UH1.AJ8 UH1.AJ16 UH1.AJ18 UH1.AJ20 UH1.AJ22 UH1.AJ24 UH1.AJ34 UH1.AJ38 UH1.AK14 UH1.AK16 UH1.AK24 UH1.AK43 UH1.AK45 UH1.AL2 UH1.AL8 UH1.AL12 UH1.AL34 UH1.AL38 UH1.AM14 UH1.AM16 UH1.AM24 UH1.AM26 UH1.AM28 UH1.AM30 UH1.AM32 UH1.AN8 UH1.AN36 UH1.AN40 UH1.AN42 UH1.AP13 UH1.AP24 UH1.AP31 UH1.AP43 UH1.AR2 UH1.AT10 UH1.AT15 UH1.AT17 UH1.AT20 UH1.AT26 UH1.AT29 UH1.AT36 UH1.AT38 UH1.AT43 UH1.AV6 UH1.AV7 UH1.AV13 UH1.AV22 UH1.AV24 UH1.AV31 UH1.AV33 UH1.AV40 UH1.AW2 UH1.AY7 UH1.AY10 UH1.AY15 UH1.AY20 UH1.AY26 UH1.AY29 UH1.AY36 UH1.B1 UH1.B2 UH1.B7 UH1.B11 UH1.B15 UH1.B19 UH1.B23 UH1.B27 UH1.B31 UH1.B35 UH1.B39 UH1.B44 UH1.B45 UH1.BA1 UH1.BA40 UH1.BB25 UH1.BB42 UH1.BC1 UH1.BC16 UH1.BC22 UH1.BC28 UH1.BD1 UH1.BD2 UH1.BD7 UH1.BD11 UH1.BD15 UH1.BD19 UH1.BD31 UH1.BD35 UH1.BD39 UH1.BD44 UH1.BD45 UH1.BE2 UH1.BE3 UH1.BE41 UH1.C45 UH1.D1 UH1.D4 UH1.D25 UH1.D42 UH1.E1 UH1.E45 UH1.F8 UH1.F15 UH1.F20 UH1.F29 UH1.F33 UH1.F43 UH1.G2 UH1.G8 UH1.G38 UH1.G44 UH1.H7 UH1.H10 UH1.H13 UH1.H17 UH1.H22 UH1.H24 UH1.H26 UH1.H31 UH1.H36 UH1.H40 UH1.K10 UH1.K15 UH1.K20 UH1.K29 UH1.K33 UH1.K39 UH1.L2 UH1.L44 UH1.M17 UH1.M22 UH1.M24 UH1.N6 UH1.N10 UH1.N12 UH1.N35 UH1.N39 UH1.P22 UH1.P24 UH1.P26 UH1.P28 UH1.P30 UH1.P32 UH1.P43 UH1.R2 UH1.R8 UH1.R12 UH1.R14 UH1.R16 UH1.R34 UH1.R38 UH1.R44 UH1.T43 UH1.U6 UH1.U10 UH1.U16 UH1.U28 UH1.U34 UH1.U38 UH1.U39 UH1.U42 UH1.V14 UH1.V16 UH1.V26 UH1.V43 UH1.W2 UH1.W44 UH1.Y8 UH1.Y14 UH1.Y16 UH1.Y24 UH1.Y28 UH1.Y34 UH1.Y36 UH1.Y40 UH2.3 UH3.3 Y3.2 Y3.4 YH2.2 YH2.4
GND_CHASSIS: C485.2 R571.2 R572.2 R573.2 R574.2
V1N: PR516.1 PR546.2
V2N: PR518.1 PR556.2
V3N: PR547.2 PR557.2
VCC_PGOOD: PR522.2 PU500.3
VCCSENSE: JCPU1.AL35 PC520.1 PC542.2 PC544.1 PR536.1 RC66.2
VDD_1.35V: PC210.1 PR201.1 PR203.2 PU200.11
VDD_PWRGD: R402.2 U29.13
VIN: T137.1(TP-1) U51.B15
VSSSENSE: JCPU1.AK35 PC544.2 PC546.2 PU500.13 RC70.1
3301_ACAV_IN_NB: PR1019.1 PU1001.24
3301_DC_IN_SS: PR1010.2 PU1001.34
3301_PWRSRC: PR1029.1 PU1001.15
24737_BST_CHG_MODE#: PQ710.2 PR718.1 PR757.2 PU700.11
+ADDR_XEN: R394.1 U29.32
+BL_PWR_SRC: C249.2 C296.1 JLVDS1.1 JLVDS1.2 JLVDS1.3 Q21.1 Q21.2 Q21.5 Q21.6
+CAMERA_VDD: C299.1 C300.1 JLVDS1.8 Q24.1
+CAP_LDO: C714.1 U46.B46
+CHAGER_SRC: PC705.1 PC706.1 PC707.1 PC708.1 PL700.1 PQ704.5
+CHG_VCC: PD701.1 PR775.2
+COINCELL: JRTC1.1 PR1.1
+CRT_VCC: C14.1 JCRT1.9 U6.3
+DC1_PWR_SRC: PC104.1 PC105.1 PC106.1 PC109.1 PC110.1 PC117.1 PL100.1 PQ101.5 PQ102.5 PU101.12
+DC_IN: PC9.2 PC15.1 PL4.2 PQ5.1 PQ5.2 PQ5.3 PQ8.3 PR16.1 PR19.1 PR736.1 PR1011.1
+DC_IN_SS: PC14.1 PD700.2 PD701.3 PQ5.5 PQ701.5 PR18.1 PR1010.1
+DCIN_JACK: PC11.1 PD8.1 PJPDC1.7 PJPDC1.8 PJPDC1.9 PJPDC1.10 PL4.1
+DOCK_PWR_BAR: C702.1 C703.1 D33.2 D33.3 JDOCK1.149 JDOCK1.150 JDOCK1.151 PD701.2 PD1001.2 PD1001.3 PQ1001.5 PQ1008.5 PR1001.1 PR1007.1
+DP_VCC: C313.1 C482.1 F3.1 JDP1.20 U8.3
+LCDVDD: C298.1 C769.1 JEPWR1.5 JEPWR1.6 JLVDS1.5 JLVDS1.6 R161.1 R162.1 U62.1
+LOM_VCT: JDOCK1.116 JDOCK1.118
+MXM_PWR_SRC: C1.1 C2.1 C3.1 C4.1 C776.1 JMXM1.1 JMXM1.2 JMXM1.3 JMXM1.4 JMXM1.5 JMXM1.6 JMXM1.7 JMXM1.8 JMXM1.9 JMXM1.10 JMXM1.11 JMXM1.12 JMXM1.13 JMXM1.14 JMXM1.15 JMXM1.16 JMXM1.17 JMXM1.18 Q186.5 Q186.6 Q186.7 Q186.8 R935.1
+NBDOCK_DC_IN_SS: JDOCK1.41 PQ1070.1 PR1024.2
+PCH_DCPRTC: CH54.1 UH1.P14 UH1.P16
+PCH_USB_DCPSUS1: CH39.1 RH234.2 UH1.Y12
+PCH_USB_DCPSUS2: CH58.1 RH239.2 UH1.Y35
+PCH_USB_DCPSUS3: CH41.1 CH42.1 RH236.1 UH1.AJ26 UH1.AJ28
+PCH_VCC: CH63.1 CH64.1 LH2.2 UH1.AP45
+PCH_VCCCFUSE: CH66.1 RH242.2 UH1.P18 UH1.P20
+PCH_VCCCLK: CH67.1 CH68.1 CH69.1 CH70.1 CH71.1 RH244.2 UH1.AA30 UH1.AA32 UH1.AD34 UH1.AD35 UH1.AD36 UH1.AE30 UH1.AE32 UH1.AG30 UH1.AG32 UH1.Y32
+PCH_VCCCLK3_3: CH72.1 CH73.1 CH74.1 CH75.1 RH245.2 UH1.L26 UH1.L29 UH1.M26 UH1.M29 UH1.U32 UH1.V32
+PCH_VCCDSW: RH232.2 UH1.U14
+PCH_VCCDSW3_3: CH44.1 JAPS1.3 R835.1 RC18.1 RH78.1 RH80.1 RH112.1 RH216.2 RH217.2 RH238.2 UC2.5 UH1.A16
+PCH_VCCDSW_R: CH40.1 RH232.1
+PCH_VCCSST: CH46.1 UH1.AA14
+PECI_VREF: C740.1 R866.1 U51.B51
+PWR_SRC: C297.1 PC7.1 PC1001.1 PC1002.1 PC1003.1 PD1001.1 PD1002.1 PJP200.2 PJP300.1 PL1.2 PL100.2 PL510.2 PL700.2 PQ4.3 PQ1001.1 PQ1001.2 PQ1001.3 PQ1004.1 PQ1004.2 PQ1004.3 PR15.1 PR701.4 PR1029.2 Q21.4 R422.1 R933.1
+PWR_SRC_MXM: PC1.1 PC30.1 PC31.1 PL1.1 Q186.1 Q186.2 Q186.3 R940.1
+PWR_SRC_S: PC8.1 PQ4.1
+RSVD_VCC3P3_2: R554.2 U31.1
+RTC_CELL: C278.1 C287.1 C1353.1 CH55.1 CH56.1 CH57.1 JIO1.58 PC2.1 PD1.1 R395.2 R810.1 R819.1 R870.1 R873.1 RH5.1 RH42.1 RH43.1 RH44.1 RH67.2 U10.5 U29.16 U51.B64 UH1.A6
+SA_DIMM1_VREFDQ: CD1.1 CD2.1 CD23.1 CD26.1 JDIMM1.1 JDIMM2.1 RD41.2 RD43.1 RD44.2
+SA_DIMM_VREFDQ: CD89.1 JCPU1.F16 RD41.1
+SB_DIMM1_VREFDQ: CD45.1 CD46.1 CD71.1 CD72.1 JDIMM3.1 JDIMM4.1 RD48.2 RD49.2 RD50.1
+SB_DIMM_VREFDQ: CD91.1 JCPU1.F13 RD48.1
+SDC_IN: PC700.1 PC701.1 PD700.1 PQ701.1 PQ701.2 PQ701.3 PR701.1 PR762.1 PR1015.1 PU701.3
+SIM_PWR: C119.1 C616.1 C617.1 JMINI2.8 JSIM1.1
+SM_VREF: CD90.1 JCPU1.AM3 RD45.1
+SM_VREF_DIMM: CD19.1 CD20.1 CD41.1 CD42.1 CD63.1 CD64.1 CD85.1 CD86.1 JDIMM1.126 JDIMM2.126 JDIMM3.126 JDIMM4.126 RD45.2 RD46.1 RD47.2
+SW_LX: L62.2 U23.17
+SWR_V12: C109.1 C110.1 C111.1 C112.1 L62.1 U23.11 U23.15 U23.43
+TRM_CT1: C479.1 T156.3
+TRM_CT2: C480.1 T156.4
+TRM_CT3: C484.1 T156.9
+TRM_CT4: C486.1 T156.10
+V_DDR_REF: PC209.1 PU200.4
+VCHGR: PC715.1 PC718.1 PC719.1 PQ1005.1 PQ1005.2 PQ1005.3 PQ1009.5 PQ1083.3 PR723.4
+VCOMP_OUT: JCPU1.F22 RC1.1 RC2.1
+VDISPLAY_VCC: C46.1 C47.1 JHDMI1.18 R460.1 R461.1 U5.3
+VR_CAP: C779.1 U51.B12
A_ON: PR315.2 R429.2 U35.5 U51.B24
AC_DIS: PQ8.5 PR1030.2 U46.B12
AC_PRESENT: R835.2 U51.A54 UH1.E6
ACAV_DOCK_SRC#: JDOCK1.42 PR1013.2 PR1017.1
ACAV_IN: PQ707.2 PQ710.3 PR717.1 PR772.2 PR1021.1 U17.1 U29.21 U51.A64
ACAV_IN_NB: PR742.1 PR1019.2 U51.B20
ACAVDK_SRC: PR1017.2 PU1001.4
ACAVIN: PR1021.2 PU1001.8
ACDET: PC783.1 PR732.2 PR762.2 PU700.6
ACPRN: PQ710.5 PR771.2 PU700.5
ADP_I: PC746.1 PR702.1 PR704.1 PR743.1 R1982.2
ADP_I_R: R1982.1 U51.A12
ALERT#: PR503.1 PR506.2 PU500.32
ALW_PWRGD_3V_5V: PR118.1 U51.A1
ALWON: PR112.1 U51.A60
AUD_HP_NB_SENSE: JIO1.70 U46.A41
AUD_NB_MUTE#: JIO1.72 U46.A39
AUDIO_BACKLITE#: JIO1.102 U46.B68
AUX_EN_WOWL: R844.1 U46.B67
AUX_MODE_EN: RP8.1 U46.A45
BAT1_LED#: JIO1.106 U46.B64
BAT2_LED#: JIO1.104 U46.A9
BBS_BIT1: RH119.1 UH1.C10
BC_CLK_ECE1117: JKB1.17 JKB1.18 U51.A20
BC_CLK_ECE5048: U46.A30 U51.A43
BC_CLK_EMC4021: U29.8 U51.B49
BC_DAT_ECE1117: JKB1.13 JKB1.14 R817.2 U51.B21
BC_DAT_ECE5048: R814.2 U46.B31 U51.B45
BC_DAT_EMC4021: R854.2 U29.7 U51.B48
BC_INT#_ECE1117: JKB1.11 JKB1.12 U51.A19
BC_INT#_ECE5048: U46.A29 U51.A42
BC_INT#_EMC4021: R426.2 U29.9 U51.A34
BCM5882_ALERT#: JUSH1.7 U46.B62
BEEP: JIO1.74 U51.B19
BIA_PWM_EC: D71.2 U51.B25
BIA_PWM_LVDS: D66.1 D68.1 D71.1 JLVDS1.16 R1137.1
BIA_PWM_PCH: R127.2 U23.21 UH1.N36
BIA_PWM_SW: D66.2 U23.19
BLK_MOSFET_GC: PR1006.2 PU1001.30
BLKNG_MOSFET_GC: PR1009.2 PU1001.20
BLUE_CRT: C22.1 L3.1 R55.1 U19.31
BLUE_CRT_L: JCRT1.3 L3.2
BLUE_DOCK: JDOCK1.45 U19.22
BOARD_ID: C744.1 R875.2 U51.B10
BOOT1: PR549.2 PU500.18
BOOT2: PR534.2 PU500.27
BOOT3: PR502.2 PU501.2
BOOT_1.35V: PR200.2 PU200.18
BQ24737_VDD: PC745.1 PD703.2 PR738.1 PR771.1 PR772.1 PU700.16
BREATH_LED#: JDOCK1.98 Q344.1 Q344.4 U46.B39
BREATH_LED#_Q: JIO1.100 R956.2
BREATH_WHITE_LED: JPB1.4 R955.2
BST1_3V: PC112.2 PR108.1
BST1_5V: PC111.1 PR107.2
BST_3V: PR108.2 PU101.9
BST_5V: PR107.1 PU101.17
BST_+1.05VSP: PR301.1 PU300.10
BST_CHG: PD703.1 PR765.1 PU700.17
BST_CHG_IMON: PR705.1 U51.B61
BST_CHG_MODE#: PR716.2 PR718.2 U46.B15
BT_LED: JIO1.94 R941.2
BT_LED#: JMINI4.46 Q89.3 R725.1
BT_LED#_Q: Q89.1 Q318.3 R938.2
BT_RADIO_DIS#: D30.1 U46.A13
BT_RADIO_DIS#_R: D30.2 JMINI4.51 R696.1
CAM_MIC_CBL_DET#: JLVDS1.12 RH86.2 UH1.L15
CARD_SMBCLK: JIO1.12 U51.A49
CARD_SMBDAT: JIO1.14 U51.B52
CARDCLK_REQ#: JIO1.1 RH22.1 RH120.2 UH1.AF3
CCD_OFF: Q24.2 U46.B43
CD3301_DCIN: PC1006.1 PR1011.2 PU1001.1
CD3301_NBDOCK_DC_IN_SS: PR1024.1 PR1070.2 PU1001.19
CD3301_SDC_IN: PR1015.2 PU1001.6
CD_PBATT_OFF: PR1016.1 PU1001.26
CFD_PWRBTN#_XDP: JXDP1.41 RC6.2
CFG0: JCPU1.AT20 JXDP1.9
CFG1: JCPU1.AR20 JXDP1.11
CFG2: JCPU1.AP20 JXDP1.15 RC76.1
CFG3: JCPU1.AP22 JXDP1.17 R566.1 RC64.2
CFG3_R: JXDP1.60 RC64.1
CFG4: JCPU1.AT22 JXDP1.27 RC77.1
CFG5: JCPU1.AN22 JXDP1.29
CFG6: JCPU1.AT25 JXDP1.33
CFG7: JCPU1.AN23 JXDP1.35
CFG8: JCPU1.AR24 JXDP1.10
CFG9: JCPU1.AT23 JXDP1.12
CFG10: JCPU1.AN20 JXDP1.16
CFG11: JCPU1.AP24 JXDP1.18
CFG12: JCPU1.AP26 JXDP1.28
CFG13: JCPU1.AN25 JXDP1.30
CFG14: JCPU1.AN26 JXDP1.34
CFG15: JCPU1.AP25 JXDP1.36
CFG16: JCPU1.AR21 JXDP1.6
CFG17: JCPU1.AP21 JXDP1.4
CFG18: JCPU1.AR23 JXDP1.24
CFG19: JCPU1.AP23 JXDP1.22
CFG_RCOMP: JCPU1.AT31 RC58.1
CHARGER_SMBCLK: PR766.2 RP5.6 U51.B50
CHARGER_SMBDAT: PR763.2 RP5.5 U51.A47
CHG: PL701.2 PR723.1
CLK_80H: RH159.2 UH1.F36
CLK_BUF_BCLK: RPH3.3 UH1.AT24
CLK_BUF_BCLK#: RPH3.4 UH1.AR24
CLK_BUF_CKSSCD: RH150.1 UH1.BC6
CLK_BUF_CKSSCD#: RH149.1 UH1.BE6
CLK_BUF_DMI: RPH3.1 UH1.AW24
CLK_BUF_DMI#: RPH3.2 UH1.AY24
CLK_BUF_DOT96: RH148.1 UH1.G33
CLK_BUF_DOT96#: RH147.1 UH1.H33
CLK_CPU_DMI: JCPU1.E26 UH1.AF40
CLK_CPU_DMI#: JCPU1.D26 UH1.AF39
CLK_CPU_DPLL: JCPU1.H28 UH1.AF36
CLK_CPU_DPLL#: JCPU1.G28 UH1.AF35
CLK_CPU_ITP: RH107.2 UH1.AH45
CLK_CPU_ITP#: RH108.2 UH1.AH43
CLK_CPU_SSC_DPLL: JCPU1.E27 UH1.AJ39
CLK_CPU_SSC_DPLL#: JCPU1.F27 UH1.AJ40
CLK_DDC2_CRT: JCRT1.15 U19.35
CLK_DDC2_DOCK: JDOCK1.48 U19.26
CLK_KBD: JDOCK1.78 RP6.7 U51.A38
CLK_MSE: JDOCK1.71 RP6.6 U51.A39
CLK_PCH_14M: RH146.1 UH1.F45
CLK_PCI_5048: CH15.1 R795.1 RH158.2 U46.A28
CLK_PCI_DOCK: CH76.1 JDOCK1.121 R756.1 RH162.2
CLK_PCI_LOOPBACK: CH77.1 RH164.2 UH1.D17
CLK_PCI_MEC: CH16.1 R885.1 RH160.2 U51.A29
CLK_PCI_TPM: CH78.1 RE5.1 RH155.1 U39.21
CLK_PCIE_CARD: JIO1.7 UH1.AB45
CLK_PCIE_CARD#: JIO1.5 UH1.AB43
CLK_PCIE_EXP: JIO1.25 UH1.AF45
CLK_PCIE_EXP#: JIO1.23 UH1.AF43
CLK_PCIE_LAN: U31.44 UH1.AA42
CLK_PCIE_LAN#: U31.45 UH1.AA44
CLK_PCIE_MINI1: JMINI2.13 UH1.Y45
CLK_PCIE_MINI1#: JMINI2.11 UH1.Y43
CLK_PCIE_MINI2: JMINI4.13 UH1.AB39
CLK_PCIE_MINI2#: JMINI4.11 UH1.AB40
CLK_PCIE_MINI3: JMINI3.13 UH1.AD45
CLK_PCIE_MINI3#: JMINI3.11 UH1.AD43
CLK_PCIE_VGA: JMXM1.185 UH1.AB36
CLK_PCIE_VGA#: JMXM1.183 UH1.AB35
CLK_SIO_14M: CH79.1 R794.1 RH157.1 U46.A32
CLK_TP_SIO: JIO1.112 U51.A37
CLK_XDP: JXDP1.40 RH107.1
CLK_XDP#: JXDP1.42 RH108.1
CLKRUN#: RH90.2 U39.15 U46.B20 U51.A32 UH1.AN7
CMPL_EN: R568.2 U637.13
COMP: PC525.2 PR541.2 PU500.7
CONTACTLESS_DET#: JUSH1.17 RPH8.6 UH1.C16
CPPE#: JMINI4.37 R823.1 UH1.B13
CPU1.5V_S3_GATE: RP7.5 U51.A36
CPU_B+: PC502.1 PC503.1 PC504.1 PC512.1 PC513.1 PC514.1 PC515.1 PC516.1 PC529.1 PC530.1 PC531.1 PC533.1 PC534.1 PC535.1 PL510.1 PQ500.1 PQ502.1 PQ504.1 PR526.2
CPU_DETECT#: JCPU1.AP32 RP2.8 U46.A3
CPU_EDP_HPD: QC6.2 RC75.1 U23.1
CPU_PLTRST#: JCPU1.AT26 RC8.1 UH1.AU4
CPU_PWR_DEBUG: JCPU1.H27 RC7.1 RC69.2 RC71.1
CPU_PWR_DEBUG_R: JXDP1.45 RC7.2
CPU_VTT_ON: RP4.1 U46.B17
CRT_11: JCRT1.11 T61.1(TP-1)
CRT_IREF: RH97.2 UH1.U40
CRT_SWITCH: U19.38 U19.40 U46.B52
CS_1.35V: PR201.2 PU200.13
CSON_1: PC786.1 PC792.2 PR723.3 PR761.2
CSOP_1: PC792.1 PR723.2 PR759.2
CSS_GC: PR703.2 PU1001.10
CSSN_1: PQ702.3 PQ703.2 PR707.1 PR711.1 PR712.1
CSSN_2: PC703.2 PC704.1 PR706.1 PR711.2 PU700.1 PU701.5
CSSP_1: PQ700.3 PQ703.5 PR707.2 PR709.1 PR710.1
CSSP_2: PC702.2 PC703.1 PR708.1 PR710.2 PU700.2
D_CLKRUN#: JDOCK1.111 RP3.8 U46.A19
D_DLDRQ1#: JDOCK1.117 RP3.6 U46.B24
D_LAD0: JDOCK1.97 U46.B29
D_LAD1: JDOCK1.99 U46.B28
D_LAD2: JDOCK1.103 U46.A25
D_LAD3: JDOCK1.105 U46.A24
D_LFRAME#: JDOCK1.109 U46.B23
D_SERIRQ: JDOCK1.115 RP3.7 U46.A20
DAI_12MHZ#: JDOCK1.89 JIO1.48 RE11.1
DAI_BCLK#: JDOCK1.77 JIO1.56 RE12.1
DAI_DI: JDOCK1.83 JIO1.52
DAI_DO#: JDOCK1.85 JIO1.50
DAI_LRCK#: JDOCK1.79 JIO1.54
DAT_DDC2_CRT: JCRT1.12 U19.34
DAT_DDC2_DOCK: JDOCK1.46 U19.25
DAT_KBD: JDOCK1.80 RP6.8 U51.B41
DAT_MSE: JDOCK1.73 RP6.5 U51.B42
DAT_TP_SIO: JIO1.110 U51.B40
DC_BLOCK_GC: PR700.1 PU1001.7
DDR3_DRAMRST#_CPU: JCPU1.AN3 RD5.2 RD12.1
DDR3_DRAMRST#_R: JDIMM1.30 JDIMM2.30 JDIMM3.30 JDIMM4.30 RD12.2
DDR_1.35V_CNTRL0: PR216.2 PR219.1 U46.A49
DDR_1.35V_CNTRL1: PR222.2 PR223.1 U46.A16
DDR_A_BS0: JCPU1.V5 JDIMM1.109 JDIMM2.109
DDR_A_BS1: JCPU1.U5 JDIMM1.108 JDIMM2.108
DDR_A_BS2: JCPU1.AD1 JDIMM1.79 JDIMM2.79
DDR_A_CAS#: JCPU1.U8 JDIMM1.115 JDIMM2.115
DDR_A_D0: JCPU1.AR15 JDIMM1.7 JDIMM2.6
DDR_A_D1: JCPU1.AT14 JDIMM1.4 JDIMM2.5
DDR_A_D2: JCPU1.AM14 JDIMM1.16 JDIMM2.15
DDR_A_D3: JCPU1.AN14 JDIMM1.18 JDIMM2.17
DDR_A_D4: JCPU1.AT15 JDIMM1.5 JDIMM2.4
DDR_A_D5: JCPU1.AR14 JDIMM1.6 JDIMM2.7
DDR_A_D6: JCPU1.AN15 JDIMM1.17 JDIMM2.18
DDR_A_D7: JCPU1.AM15 JDIMM1.15 JDIMM2.16
DDR_A_D8: JCPU1.AM9 JDIMM1.21 JDIMM2.22
DDR_A_D9: JCPU1.AN9 JDIMM1.23 JDIMM2.24
DDR_A_D10: JCPU1.AM8 JDIMM1.36 JDIMM2.35
DDR_A_D11: JCPU1.AN8 JDIMM1.34 JDIMM2.33
DDR_A_D12: JCPU1.AR9 JDIMM1.24 JDIMM2.23
DDR_A_D13: JCPU1.AT9 JDIMM1.22 JDIMM2.21
DDR_A_D14: JCPU1.AR8 JDIMM1.35 JDIMM2.36
DDR_A_D15: JCPU1.AT8 JDIMM1.33 JDIMM2.34
DDR_A_D16: JCPU1.AJ9 JDIMM1.42 JDIMM2.41
DDR_A_D17: JCPU1.AK9 JDIMM1.40 JDIMM2.39
DDR_A_D18: JCPU1.AJ6 JDIMM1.52 JDIMM2.53
DDR_A_D19: JCPU1.AK6 JDIMM1.50 JDIMM2.51
DDR_A_D20: JCPU1.AJ10 JDIMM1.41 JDIMM2.42
DDR_A_D21: JCPU1.AK10 JDIMM1.39 JDIMM2.40
DDR_A_D22: JCPU1.AJ7 JDIMM1.53 JDIMM2.52
DDR_A_D23: JCPU1.AK7 JDIMM1.51 JDIMM2.50
DDR_A_D24: JCPU1.AF4 JDIMM1.58 JDIMM2.59
DDR_A_D25: JCPU1.AF5 JDIMM1.56 JDIMM2.57
DDR_A_D26: JCPU1.AF1 JDIMM1.70 JDIMM2.69
DDR_A_D27: JCPU1.AF2 JDIMM1.68 JDIMM2.67
DDR_A_D28: JCPU1.AG4 JDIMM1.59 JDIMM2.58
DDR_A_D29: JCPU1.AG5 JDIMM1.57 JDIMM2.56
DDR_A_D30: JCPU1.AG1 JDIMM1.69 JDIMM2.70
DDR_A_D31: JCPU1.AG2 JDIMM1.67 JDIMM2.68
DDR_A_D32: JCPU1.J1 JDIMM1.132 JDIMM2.131
DDR_A_D33: JCPU1.J2 JDIMM1.130 JDIMM2.129
DDR_A_D34: JCPU1.J5 JDIMM1.141 JDIMM2.140
DDR_A_D35: JCPU1.H5 JDIMM1.143 JDIMM2.142
DDR_A_D36: JCPU1.H2 JDIMM1.131 JDIMM2.132
DDR_A_D37: JCPU1.H1 JDIMM1.129 JDIMM2.130
DDR_A_D38: JCPU1.J4 JDIMM1.140 JDIMM2.141
DDR_A_D39: JCPU1.H4 JDIMM1.142 JDIMM2.143
DDR_A_D40: JCPU1.F2 JDIMM1.148 JDIMM2.149
DDR_A_D41: JCPU1.F1 JDIMM1.146 JDIMM2.147
DDR_A_D42: JCPU1.D2 JDIMM1.160 JDIMM2.159
DDR_A_D43: JCPU1.D3 JDIMM1.158 JDIMM2.157
DDR_A_D44: JCPU1.D1 JDIMM1.149 JDIMM2.148
DDR_A_D45: JCPU1.F3 JDIMM1.147 JDIMM2.146
DDR_A_D46: JCPU1.C3 JDIMM1.159 JDIMM2.160
DDR_A_D47: JCPU1.B3 JDIMM1.157 JDIMM2.158
DDR_A_D48: JCPU1.B5 JDIMM1.163 JDIMM2.164
DDR_A_D49: JCPU1.E6 JDIMM1.165 JDIMM2.166
DDR_A_D50: JCPU1.A5 JDIMM1.176 JDIMM2.177
DDR_A_D51: JCPU1.D6 JDIMM1.175 JDIMM2.174
DDR_A_D52: JCPU1.D5 JDIMM1.164 JDIMM2.163
DDR_A_D53: JCPU1.E5 JDIMM1.166 JDIMM2.165
DDR_A_D54: JCPU1.B6 JDIMM1.174 JDIMM2.175
DDR_A_D55: JCPU1.A6 JDIMM1.177 JDIMM2.176
DDR_A_D56: JCPU1.E12 JDIMM1.183 JDIMM2.182
DDR_A_D57: JCPU1.D12 JDIMM1.181 JDIMM2.180
DDR_A_D58: JCPU1.B11 JDIMM1.192 JDIMM2.191
DDR_A_D59: JCPU1.A11 JDIMM1.194 JDIMM2.193
DDR_A_D60: JCPU1.E11 JDIMM1.180 JDIMM2.181
DDR_A_D61: JCPU1.D11 JDIMM1.182 JDIMM2.183
DDR_A_D62: JCPU1.B12 JDIMM1.193 JDIMM2.194
DDR_A_D63: JCPU1.A12 JDIMM1.191 JDIMM2.192
DDR_A_DQS0: JCPU1.AP14 JDIMM1.12 JDIMM2.12
DDR_A_DQS1: JCPU1.AP9 JDIMM1.29 JDIMM2.29
DDR_A_DQS2: JCPU1.AK8 JDIMM1.47 JDIMM2.47
DDR_A_DQS3: JCPU1.AG3 JDIMM1.64 JDIMM2.64
DDR_A_DQS4: JCPU1.H3 JDIMM1.137 JDIMM2.137
DDR_A_DQS5: JCPU1.E3 JDIMM1.154 JDIMM2.154
DDR_A_DQS6: JCPU1.C6 JDIMM1.171 JDIMM2.171
DDR_A_DQS7: JCPU1.C12 JDIMM1.188 JDIMM2.188
DDR_A_DQS#0: JCPU1.AP15 JDIMM1.10 JDIMM2.10
DDR_A_DQS#1: JCPU1.AP8 JDIMM1.27 JDIMM2.27
DDR_A_DQS#2: JCPU1.AJ8 JDIMM1.45 JDIMM2.45
DDR_A_DQS#3: JCPU1.AF3 JDIMM1.62 JDIMM2.62
DDR_A_DQS#4: JCPU1.J3 JDIMM1.135 JDIMM2.135
DDR_A_DQS#5: JCPU1.E2 JDIMM1.152 JDIMM2.152
DDR_A_DQS#6: JCPU1.C5 JDIMM1.169 JDIMM2.169
DDR_A_DQS#7: JCPU1.C11 JDIMM1.186 JDIMM2.186
DDR_A_MA0: JCPU1.V8 JDIMM1.98 JDIMM2.98
DDR_A_MA1: JCPU1.AC6 JDIMM1.97 JDIMM2.97
DDR_A_MA2: JCPU1.V9 JDIMM1.96 JDIMM2.96
DDR_A_MA3: JCPU1.U9 JDIMM1.95 JDIMM2.95
DDR_A_MA4: JCPU1.AC5 JDIMM1.92 JDIMM2.92
DDR_A_MA5: JCPU1.AC4 JDIMM1.91 JDIMM2.91
DDR_A_MA6: JCPU1.AD6 JDIMM1.90 JDIMM2.90
DDR_A_MA7: JCPU1.AC3 JDIMM1.86 JDIMM2.86
DDR_A_MA8: JCPU1.AD5 JDIMM1.89 JDIMM2.89
DDR_A_MA9: JCPU1.AC2 JDIMM1.85 JDIMM2.85
DDR_A_MA10: JCPU1.V6 JDIMM1.107 JDIMM2.107
DDR_A_MA11: JCPU1.AC1 JDIMM1.84 JDIMM2.84
DDR_A_MA12: JCPU1.AD4 JDIMM1.83 JDIMM2.83
DDR_A_MA13: JCPU1.V7 JDIMM1.119 JDIMM2.119
DDR_A_MA14: JCPU1.AD3 JDIMM1.80 JDIMM2.80
DDR_A_MA15: JCPU1.AD2 JDIMM1.78 JDIMM2.78
DDR_A_RAS#: JCPU1.U6 JDIMM1.110 JDIMM2.110
DDR_A_WE#: JCPU1.U7 JDIMM1.113 JDIMM2.113
DDR_B_BS0: JCPU1.R7 JDIMM3.109 JDIMM4.109
DDR_B_BS1: JCPU1.P8 JDIMM3.108 JDIMM4.108
DDR_B_BS2: JCPU1.AA9 JDIMM3.79 JDIMM4.79
DDR_B_CAS#: JCPU1.P7 JDIMM3.115 JDIMM4.115
DDR_B_D0: JCPU1.AR18 JDIMM3.5 JDIMM4.4
DDR_B_D1: JCPU1.AT18 JDIMM3.7 JDIMM4.6
DDR_B_D2: JCPU1.AM17 JDIMM3.16 JDIMM4.15
DDR_B_D3: JCPU1.AM18 JDIMM3.18 JDIMM4.17
DDR_B_D4: JCPU1.AR17 JDIMM3.4 JDIMM4.5
DDR_B_D5: JCPU1.AT17 JDIMM3.6 JDIMM4.7
DDR_B_D6: JCPU1.AN17 JDIMM3.17 JDIMM4.18
DDR_B_D7: JCPU1.AN18 JDIMM3.15 JDIMM4.16
DDR_B_D8: JCPU1.AT12 JDIMM3.21 JDIMM4.22
DDR_B_D9: JCPU1.AR12 JDIMM3.23 JDIMM4.24
DDR_B_D10: JCPU1.AN12 JDIMM3.33 JDIMM4.34
DDR_B_D11: JCPU1.AM11 JDIMM3.36 JDIMM4.35
DDR_B_D12: JCPU1.AT11 JDIMM3.24 JDIMM4.23
DDR_B_D13: JCPU1.AR11 JDIMM3.22 JDIMM4.21
DDR_B_D14: JCPU1.AM12 JDIMM3.34 JDIMM4.33
DDR_B_D15: JCPU1.AN11 JDIMM3.35 JDIMM4.36
DDR_B_D16: JCPU1.AR5 JDIMM3.42 JDIMM4.41
DDR_B_D17: JCPU1.AR6 JDIMM3.40 JDIMM4.39
DDR_B_D18: JCPU1.AM5 JDIMM3.52 JDIMM4.53
DDR_B_D19: JCPU1.AM6 JDIMM3.50 JDIMM4.51
DDR_B_D20: JCPU1.AT5 JDIMM3.41 JDIMM4.42
DDR_B_D21: JCPU1.AT6 JDIMM3.39 JDIMM4.40
DDR_B_D22: JCPU1.AN5 JDIMM3.53 JDIMM4.52
DDR_B_D23: JCPU1.AN6 JDIMM3.51 JDIMM4.50
DDR_B_D24: JCPU1.AJ4 JDIMM3.58 JDIMM4.59
DDR_B_D25: JCPU1.AK4 JDIMM3.56 JDIMM4.57
DDR_B_D26: JCPU1.AJ1 JDIMM3.70 JDIMM4.69
DDR_B_D27: JCPU1.AJ2 JDIMM3.68 JDIMM4.67
DDR_B_D28: JCPU1.AM1 JDIMM3.59 JDIMM4.58
DDR_B_D29: JCPU1.AN1 JDIMM3.57 JDIMM4.56
DDR_B_D30: JCPU1.AK2 JDIMM3.69 JDIMM4.70
DDR_B_D31: JCPU1.AK1 JDIMM3.67 JDIMM4.68
DDR_B_D32: JCPU1.L2 JDIMM3.129 JDIMM4.130
DDR_B_D33: JCPU1.M2 JDIMM3.130 JDIMM4.129
DDR_B_D34: JCPU1.L4 JDIMM3.142 JDIMM4.143
DDR_B_D35: JCPU1.M4 JDIMM3.140 JDIMM4.141
DDR_B_D36: JCPU1.L1 JDIMM3.131 JDIMM4.132
DDR_B_D37: JCPU1.M1 JDIMM3.132 JDIMM4.131
DDR_B_D38: JCPU1.L5 JDIMM3.143 JDIMM4.142
DDR_B_D39: JCPU1.M5 JDIMM3.141 JDIMM4.140
DDR_B_D40: JCPU1.G7 JDIMM3.149 JDIMM4.148
DDR_B_D41: JCPU1.J8 JDIMM3.146 JDIMM4.147
DDR_B_D42: JCPU1.G8 JDIMM3.160 JDIMM4.159
DDR_B_D43: JCPU1.G9 JDIMM3.158 JDIMM4.157
DDR_B_D44: JCPU1.J7 JDIMM3.148 JDIMM4.149
DDR_B_D45: JCPU1.J9 JDIMM3.147 JDIMM4.146
DDR_B_D46: JCPU1.G10 JDIMM3.157 JDIMM4.158
DDR_B_D47: JCPU1.J10 JDIMM3.159 JDIMM4.160
DDR_B_D48: JCPU1.A8 JDIMM3.163 JDIMM4.164
DDR_B_D49: JCPU1.B8 JDIMM3.165 JDIMM4.166
DDR_B_D50: JCPU1.A9 JDIMM3.176 JDIMM4.177
DDR_B_D51: JCPU1.B9 JDIMM3.174 JDIMM4.175
DDR_B_D52: JCPU1.D8 JDIMM3.164 JDIMM4.163
DDR_B_D53: JCPU1.E8 JDIMM3.166 JDIMM4.165
DDR_B_D54: JCPU1.D9 JDIMM3.177 JDIMM4.176
DDR_B_D55: JCPU1.E9 JDIMM3.175 JDIMM4.174
