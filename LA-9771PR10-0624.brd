# Allegro board LA-9771PR10-0624.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_BS2: length 63.3
  TOP w0.089: v1(107.12,63.75) 106.65,63.28 JCPU1.AD1
  TOP w0.102: v1(141.95,67.08) 141.89,67.02 141.89,66.38 141.77,66.25 141.53,66.25 141.4,66.38 141.4,66.46 141.3,66.56 141.09,66.56 140.99,66.46 140.99,66.08 140.89,65.97 140.69,65.97 140.59,66.08 140.59,66.31 140.47,66.43 140.3,66.43 140.18,66.31 140.18,66.08 140.08,65.97 139.56,65.97 138.34,64.75 JDIMM1.79
  IN1 w0.089: v1(107.12,63.75) 107.12,63.59 107.01,63.48 106.62,63.48 106.51,63.59 106.51,63.69 106.63,63.8 106.63,63.89 106.51,64.01 106.51,64.09 106.73,64.31 106.85,64.31 107.03,64.13 107.13,64.13 107.26,64.26 107.26,64.48 107.39,64.6 107.52,64.6 108.21,65.29 108.21,65.71 108.64,66.14 108.64,66.62 108.83,66.8 108.97,66.8 109.1,66.68 109.1,66.47 109.22,66.36 109.38,66.36 109.5,66.47 109.5,66.68 109.62,66.8 109.89,66.8
  IN1 w0.208: 109.89,66.8 111.43,66.8 113.25,68.63 113.66,68.63 113.87,68.83 113.87,69.25 114.08,69.45 114.49,69.45 114.7,69.25 114.7,68.75 114.83,68.63 115.41,68.63 115.54,68.75 115.54,69.34 115.66,69.47 116.24,69.47 116.37,69.34 116.37,68.7 116.45,68.63 116.69,68.63 117.1,69.04 117.33,69.04 117.46,69.16 117.46,69.34 117.59,69.47 118.12,69.47 118.25,69.34 118.25,69.16 118.37,69.04 118.66,69.04 119.69,70.06 119.87,70.06 120,69.93 120,69.86 120.12,69.73 120.61,69.73 120.73,69.86 120.73,69.93 120.86,70.06 130.62,70.06 130.74,69.93 130.74,69.75 130.96,69.53 131.8,69.53 132.29,69.04 136.49,69.04 137.87,67.66 141.28,67.66 141.77,68.15 143.18,68.15 143.3,68.02 143.3,67.71 143.18,67.58 141.97,67.58 141.84,67.46 141.84,67.19 v1(141.95,67.08)
  BOTTOM w0.102: JDIMM2.79 144.79,64.75 144.05,65.49 144.05,67.17 143.67,67.55 142.07,67.55 141.95,67.43 v1(141.95,67.08)
DDR_A_CAS#: length 58.6
  TOP w0.102: JDIMM1.115 138.47,53.95 138.78,53.64 139.01,53.64 139.14,53.52 139.14,53.11 139.23,53.02 141.35,53.02 141.47,53.15 141.47,53.35 141.35,53.48 v1(141.18,53.48) ; v1(100.12,55.75) 100.21,55.83 100.21,56.13 99.88,56.45 99.76,56.45 JCPU1.U8
  IN1 w0.089: v1(100.12,55.75) 100.12,55.53 100.37,55.28 101.42,55.28 101.52,55.18 101.52,54.26 101.61,54.17 102.23,54.17 102.54,53.86 102.54,53.32 102.71,53.15 104.36,53.15 104.37,53.16 107.47,53.16 108.26,52.36 109.89,52.36
  IN1 w0.208: 109.89,52.36 112.26,52.36 114.55,50.06 123.94,50.06 124.78,50.9 127.14,50.9 127.74,51.5 128.95,51.5 129.39,51.94 131.73,51.94 132.1,52.3 136.03,52.3 136.32,52.59 139.57,52.59 139.96,52.98 140.28,52.98 140.4,52.86 140.4,52.76 140.57,52.59 141.52,52.59 141.72,52.79 141.72,53.06 141.29,53.48 v1(141.18,53.48)
  BOTTOM w0.102: JDIMM2.115 145.79,53.95 141.66,53.95 141.18,53.48 v1(141.18,53.48)
DDR_A_D0: length 70.3
  TOP w0.102: JCPU1.AR15 v1(93.12,74.75)
  TOP w0.14: v1(141.09,90.26) 139.58,88.75 JDIMM1.7
  IN1 w0.089: v1(93.12,74.75) 92.73,75.14 92.73,77.25
  IN1 w0.147: 92.73,77.25 92.73,78.7 95.67,81.63 95.67,85.78 99.4,89.5 118.72,89.5 119.98,90.76 123.32,90.76 123.71,91.15 141.31,91.15 141.43,91.02 141.43,90.39 141.31,90.26 v1(141.09,90.26)
  BOTTOM w0.14: v1(141.09,90.26) 139.88,89.05 JDIMM2.6
DDR_A_D1: length 67.3
  TOP w0.102: JCPU1.AT14 v1(94.12,75.75)
  TOP w0.14: v1(144.29,90.26) 144.29,90.2 144.83,89.65 JDIMM1.4
  IN1 w0.089: v1(94.12,75.75) 94.01,75.86 94.01,77.25
  IN1 w0.147: 94.01,77.25 94.01,78.33 96.84,81.15 96.84,85.29 99.88,88.33 119.2,88.33 119.97,89.1 128.63,89.1 128.97,89.44 139.24,89.44 139.24,89.44 140.53,89.44 140.88,89.09 144.94,89.09 145.07,89.22 145.07,90.14 144.94,90.26 v1(144.29,90.26)
  BOTTOM w0.14: v1(144.29,90.26) 144.29,89.87 144.8,89.35 JDIMM2.5
DDR_A_D2: length 72.7
  TOP w0.102: JCPU1.AM14 v1(94.12,71.75)
  TOP w0.14: v1(143.98,87) 143.98,86.7 144.25,86.43 144.45,86.43 144.83,86.05 JDIMM1.16
  IN1 w0.089: 97.83,77.25 96.72,76.15 96.72,71.72 96.3,71.3 94.57,71.3 v1(94.12,71.75)
  IN1 w0.147: 97.83,77.25 100.15,79.58 103.05,79.58 105.61,82.13 105.61,83.41 107.71,85.52 108.89,85.52 109.04,85.67 109.04,85.86 109.18,86 109.48,86 109.63,85.86 109.63,85.67 109.77,85.52 110.15,85.52 110.3,85.67 110.3,85.86 110.45,86.01 110.74,86.01 110.89,85.86 110.89,85.67 111.03,85.52 111.33,85.52 111.48,85.67 111.48,85.86 111.62,86.01 120.17,86.01 120.18,86.03 124.59,86.03 125.34,86.78 125.91,86.78 126.05,86.63 126.05,86.18 126.2,86.03 126.5,86.03 126.64,86.18 126.64,86.63 126.79,86.78 133.2,86.78 133.27,86.71 136.28,86.71 137.13,85.86 145.59,85.86 145.72,85.98 145.72,86.88 145.59,87 v1(143.98,87)
  BOTTOM w0.14: v1(143.98,87) 143.98,86.48 144.11,86.35 JDIMM2.15
DDR_A_D3: length 73.3
  TOP w0.102: JCPU1.AN14 v1(94.12,72.75)
  TOP w0.14: JDIMM1.18 144.84,85.45 144.31,85.99 143.44,85.99 142.46,86.98 v1(142.46,87)
  IN1 w0.089: 97.28,77.25 96.53,76.5 96.53,72.58 96.25,72.3 94.57,72.3 v1(94.12,72.75)
  IN1 w0.147: v1(142.46,87) 142.68,87 142.81,86.88 142.81,86.37 142.68,86.25 139.02,86.25 138.9,86.37 138.9,86.97 138.77,87.09 138.35,87.09 138.2,86.95 138.2,86.4 138.05,86.26 137.76,86.26 137.61,86.4 137.61,86.95 137.46,87.09 133.43,87.09 133.36,87.17 124.26,87.17 124.11,87.02 124.11,86.57 123.96,86.42 123.67,86.42 123.52,86.57 123.52,87.02 123.37,87.17 123.07,87.17 122.9,87 122.9,86.56 122.75,86.41 122.46,86.41 122.31,86.56 122.31,87 122.17,87.15 121.87,87.15 121.72,87 121.72,86.56 121.58,86.41 121.28,86.41 121.13,86.56 121.13,86.94 121.01,87.06 120.67,87.06 120.54,86.94 120.54,86.56 120.4,86.41 120.02,86.41 120,86.4 108.04,86.4 105.22,83.57 105.22,82.29 102.89,79.96 99.99,79.96 97.28,77.25
  BOTTOM w0.14: JDIMM2.17 143.43,85.75 142.46,86.72 v1(142.46,87)
DDR_A_D4: length 67.4
  TOP w0.102: JCPU1.AT15 v1(93.12,75.75)
  TOP w0.14: v1(139.57,90.26) 138.66,89.35 JDIMM1.5
  IN1 w0.089: 93.12,77.25 v1(93.12,75.75)
  IN1 w0.147: 93.12,77.25 93.12,78.53 96.06,81.47 96.06,85.61 99.56,89.11 118.88,89.11 119.65,89.88 122.99,89.88 123.87,90.76 127.54,90.76 127.69,90.62 127.69,90.01 127.82,89.88 128.15,89.88 128.28,90.01 128.28,90.62 128.43,90.76 128.72,90.76 128.87,90.62 128.87,90.36 129.02,90.22 129.31,90.22 129.46,90.36 129.46,90.62 129.61,90.76 129.9,90.76 130.05,90.62 130.05,90.36 130.2,90.22 130.49,90.22 130.64,90.36 130.64,90.62 130.79,90.76 131.08,90.76 131.23,90.62 131.23,90.36 131.38,90.22 131.67,90.22 131.82,90.36 131.82,90.62 131.96,90.76 132.26,90.76 132.41,90.62 132.41,90.36 132.55,90.22 132.85,90.22 133,90.36 133,90.62 133.14,90.76 133.44,90.76 133.58,90.62 133.58,90.36 133.73,90.22 134.03,90.22 134.17,90.36 134.17,90.62 134.32,90.76 139.06,90.76 v1(139.57,90.26)
  BOTTOM w0.14: JDIMM2.4 138.96,89.65 v1(139.57,90.26)
DDR_A_D5: length 70
  TOP w0.102: JCPU1.AR14 v1(94.12,74.75)
  TOP w0.14: JDIMM1.6 144.85,89.05 144.1,89.8 143.23,89.8 v1(142.77,90.26)
  IN1 w0.089: 93.58,77.25 93.58,75.29 v1(94.12,74.75)
  IN1 w0.147: v1(142.77,90.26) 142.98,90.26 143.11,90.14 143.11,89.61 142.98,89.48 142.48,89.48 142.33,89.63 142.33,89.7 142.2,89.83 141.87,89.83 141.74,89.7 141.74,89.61 141.61,89.48 141.17,89.48 141.04,89.61 141.04,89.7 140.92,89.83 128.81,89.83 128.47,89.49 119.81,89.49 119.04,88.72 99.72,88.72 96.45,85.45 96.45,81.31 93.58,78.45 93.58,77.25
  BOTTOM w0.14: JDIMM2.7 144.28,88.75 v1(142.77,90.26)
DDR_A_D6: length 73.3
  TOP w0.102: JCPU1.AN15 v1(93.12,72.75)
  TOP w0.14: v1(140.93,87) 140.93,86.98 140.35,86.4 139.4,86.4 138.76,85.75 JDIMM1.17
  IN1 w0.089: 96.11,77.25 95.53,76.67 95.53,74.59 95.29,74.35 94.83,74.35 94.52,74.04 94.52,73.58 94.29,73.35 93.72,73.35 v1(93.12,72.75)
  IN1 w0.147: v1(140.93,87) 140.93,87.31 140.37,87.87 139.84,87.87 139.7,88.02 139.7,88.15 139.57,88.28 139.24,88.28 139.11,88.15 139.11,88.02 138.96,87.87 138.67,87.87 138.52,88.02 138.52,88.15 138.39,88.28 138.06,88.28 137.93,88.15 137.93,88.02 137.78,87.87 137.49,87.87 137.34,88.02 137.34,88.15 137.21,88.28 136.88,88.28 136.75,88.15 136.75,88.02 136.6,87.87 133.93,87.87 133.83,87.97 133.83,88.15 133.7,88.28 133.37,88.28 133.24,88.15 133.24,88.09 133.09,87.94 132.8,87.94 132.65,88.09 132.65,88.15 132.53,88.28 132.19,88.28 132.06,88.15 132.06,88.09 131.92,87.94 131.62,87.94 131.47,88.09 131.47,88.15 131.35,88.28 131.01,88.28 130.88,88.15 130.88,88.09 130.74,87.94 130.44,87.94 130.3,88.09 130.3,88.15 130.17,88.28 129.83,88.28 129.71,88.15 129.71,88.09 129.56,87.94 120.45,87.94 119.68,87.17 100.36,87.17 98.05,84.87 98.05,80.68 96.87,79.5 96.87,79.29 97.45,78.71 97.45,78.53 97.16,78.23 96.98,78.23 96.38,78.83 96.2,78.83 95.97,78.59 95.97,78.41 96.51,77.86 96.51,77.66 96.11,77.25
  BOTTOM w0.14: JDIMM2.18 138.54,85.45 139.56,86.47 140.43,86.47 140.93,86.98 v1(140.93,87)
DDR_A_D7: length 72.5
  TOP w0.102: JCPU1.AM15 v1(93.12,71.75)
  TOP w0.14: JDIMM1.15 138.79,86.35 139.41,86.98 v1(139.41,87)
  IN1 w0.089: 96.73,77.25 95.72,76.24 95.72,74.3 95.58,74.16 94.91,74.16 94.71,73.96 94.71,73.5 94.37,73.16 93.86,73.16 93.68,72.98 93.68,71.78 93.55,71.65 93.22,71.65 v1(93.12,71.75)
  IN1 w0.147: v1(139.41,87) 139.63,87 139.76,87.13 139.76,87.36 139.63,87.48 133.6,87.48 133.52,87.55 120.61,87.55 119.84,86.78 107.88,86.78 107.56,86.46 107.35,86.46 107.03,86.78 106.85,86.78 106.61,86.55 106.61,86.37 106.93,86.05 106.93,85.84 106.72,85.63 106.51,85.63 105.36,86.78 105.18,86.78 104.94,86.55 104.94,86.37 106.1,85.21 106.1,85.01 105.89,84.8 105.68,84.8 104.98,85.49 104.81,85.49 104.57,85.26 104.57,85.08 105.26,84.38 105.26,84.17 104.83,83.74 104.83,82.45 102.73,80.35 99.83,80.35 99.66,80.18 99.45,80.18 98.84,80.79 98.66,80.79 98.42,80.55 98.42,80.37 99.03,79.76 99.03,79.55 98.82,79.35 98.61,79.35 98.06,79.9 97.85,79.9 97.65,79.69 97.65,79.48 98.2,78.93 98.2,78.72 96.73,77.25
  BOTTOM w0.14: JDIMM2.16 137.6,86.05 138.49,86.05 139.41,86.98 v1(139.41,87)
DDR_A_D8: length 62.9
  TOP w0.102: JCPU1.AM9 v1(99.12,71.75)
  TOP w0.14: v1(140.92,84.97) 140.92,84.94 140.39,85.48 139.3,85.48 138.9,85.08 138.9,84.87 138.58,84.55 JDIMM1.21
  IN1 w0.089: 98.47,77.25 97.75,76.53 97.75,73.59 97.99,73.35 98.05,73.35 98.58,72.82 98.58,72.29 v1(99.12,71.75)
  IN1 w0.147: v1(140.92,84.97) 140.49,85.41 136.94,85.41 136.09,86.25 133.07,86.25 133,86.32 127.71,86.32 126.95,85.57 120.37,85.57 120.35,85.56 113.69,85.56 113.2,85.06 107.98,85.06 106.06,83.13 106.06,81.89 103.29,79.12 100.34,79.12 98.47,77.25
  BOTTOM w0.14: JDIMM2.22 138.54,84.25 138.87,84.58 138.87,85.04 139.22,85.4 140.5,85.4 v1(140.92,84.97)
DDR_A_D9: length 60.7
  TOP w0.102: JCPU1.AN9 v1(99.12,72.75)
  TOP w0.14: v1(139.4,84.97) 139.4,84.69 138.66,83.95 JDIMM1.23
  IN1 w0.089: 99.02,77.25 98.53,76.77 98.53,73.7 98.72,73.51 98.72,73.15 v1(99.12,72.75)
  IN1 w0.147: v1(139.4,84.97) 139.35,85.02 138.88,85.02 138.73,84.87 138.73,84.57 138.59,84.43 138.29,84.43 138.14,84.57 138.14,84.87 138,85.02 137.7,85.02 137.55,84.87 137.55,84.55 137.43,84.43 137.09,84.43 136.97,84.55 136.97,84.87 136.82,85.02 136.52,85.02 136.38,84.87 136.38,84.55 136.25,84.43 135.91,84.43 135.79,84.55 135.79,84.83 135.66,84.96 135.32,84.96 135.2,84.83 135.2,84.55 135.07,84.43 134.74,84.43 134.61,84.55 134.61,84.87 134.46,85.02 134.1,85.02 133.97,84.89 133.97,84.73 133.84,84.61 133.56,84.61 133.43,84.73 133.43,85.58 133.31,85.71 132.74,85.71 132.61,85.58 132.61,85.42 132.48,85.29 132.24,85.29 132.11,85.42 132.11,85.75 131.93,85.94 127.87,85.94 127.12,85.18 120.53,85.18 120.51,85.17 113.86,85.17 113.36,84.67 108.14,84.67 106.45,82.97 106.45,81.73 103.45,78.74 100.5,78.74 99.02,77.25
  BOTTOM w0.14: v1(139.4,84.97) 139.4,84.42 138.63,83.65 JDIMM2.24
DDR_A_D10: length 63.3
  TOP w0.102: JCPU1.AM8 v1(100.12,71.75)
  TOP w0.14: JDIMM1.36 144.98,80.05 144.29,80.74 143.7,80.74 143.56,80.88 143.56,81.13 143.43,81.25 143.13,81.25 143,81.13 143,80.88 142.86,80.74 142.44,80.74 142.31,80.87 142.31,81.79 142.44,81.91 v1(142.5,81.91)
  IN1 w0.089: v1(100.12,71.75) 99.7,72.17 99.7,73.11 99.94,73.35 101.29,73.35 101.52,73.58 101.52,73.98 101.89,74.35 102.29,74.35 102.52,74.58 102.52,75.14 102.7,75.32 103.31,75.32 103.55,75.56 103.55,76.05 103.84,76.34 105.07,76.34 105.98,77.25
  IN1 w0.147: v1(142.5,81.91) 142.72,81.91 142.85,81.79 142.85,81.61 142.72,81.48 137.85,81.48 137.67,81.3 133.03,81.3 132.51,81.82 112.82,81.82 112.67,81.67 112.67,81.27 112.52,81.13 112.23,81.13 112.08,81.27 112.08,81.67 111.93,81.82 110.83,81.82 110.19,81.18 109.91,81.18 105.98,77.25
  BOTTOM w0.14: JDIMM2.35 144.74,80.35 144.17,80.92 141.85,80.92 141.73,81.05 141.73,81.38 141.85,81.5 142.37,81.5 142.5,81.63 v1(142.5,81.91)
DDR_A_D11: length 59.4
  TOP w0.102: JCPU1.AN8 v1(100.12,72.75)
  TOP w0.14: JDIMM1.34 144.92,80.65 144.02,81.55 v1(144.02,81.91)
  IN1 w0.089: v1(100.12,72.75) 100.56,72.75 100.97,73.16 101.37,73.16 101.71,73.5 101.71,73.9 101.96,74.15 102.36,74.15 102.71,74.5 102.71,75.03 102.81,75.12 103.39,75.12 103.75,75.48 103.75,75.91 103.97,76.13 105.41,76.13 106.53,77.25
  IN1 w0.147: v1(144.02,81.91) 144.75,81.91 144.88,81.79 144.88,81.22 144.75,81.09 144.56,81.09 144.41,80.94 144.41,80.41 144.26,80.26 143.97,80.26 143.82,80.41 143.82,80.94 143.67,81.09 143.38,81.09 143.23,80.94 143.23,80.41 143.08,80.26 142.79,80.26 142.64,80.41 142.64,80.94 142.49,81.09 138.01,81.09 137.83,80.91 132.87,80.91 132.35,81.43 113.51,81.43 112.81,80.73 111.54,80.73 111.1,81.17 110.73,81.17 110.35,80.79 110.07,80.79 106.53,77.25
  BOTTOM w0.14: v1(144.02,81.91) 144.02,81.85 144.92,80.95 JDIMM2.33
DDR_A_D12: length 60.5
  TOP w0.102: JCPU1.AR9 v1(99.12,74.75)
  TOP w0.14: v1(142.45,84.97) 142.45,84.94 143.1,84.29 144.18,84.29 144.81,83.65 JDIMM1.24
  IN1 w0.089: v1(99.12,74.75) 99.12,75.18 98.72,75.58 98.72,76.41 99.57,77.25
  IN1 w0.147: 99.57,77.25 100.66,78.35 103.61,78.35 106.83,81.57 106.83,82.81 108.31,84.28 113.52,84.28 114.02,84.78 120.67,84.78 120.69,84.8 132.82,84.8 133.58,84.04 139.25,84.04 139.4,84.19 139.4,84.38 139.54,84.53 139.84,84.53 139.99,84.38 139.99,84.19 140.13,84.04 140.49,84.04 140.73,84.29 142.68,84.29 142.8,84.42 142.8,84.84 142.68,84.97 v1(142.45,84.97)
  BOTTOM w0.14: v1(142.45,84.97) 142.45,84.94 143,84.39 143.92,84.39 144.36,83.95 JDIMM2.23
DDR_A_D13: length 57.4
  TOP w0.102: JCPU1.AT9 v1(99.12,75.75)
  TOP w0.14: v1(143.97,84.97) 144.13,84.97 144.85,84.25 JDIMM1.22
  IN1 w0.089: 100.12,77.25 99.12,76.26 v1(99.12,75.75)
  IN1 w0.147: 100.12,77.25 100.82,77.96 103.77,77.96 107.22,81.41 107.22,82.65 108.47,83.89 113.68,83.89 114.18,84.39 120.84,84.39 120.85,84.41 132.66,84.41 133.42,83.65 140.65,83.65 140.9,83.9 144.74,83.9 144.86,84.03 144.86,84.84 144.74,84.97 v1(143.97,84.97)
  BOTTOM w0.14: JDIMM2.21 144.36,84.55 143.97,84.94 v1(143.97,84.97)
DDR_A_D14: length 58.9
  TOP w0.089: JCPU1.AR8 99.59,74.23 99.72,74.1 99.99,74.1 100.12,74.23 v1(100.12,74.75)
  TOP w0.14: JDIMM1.35 138.39,80.35 138.77,80.73 138.89,80.73 139.02,80.86 139.02,81.03 139.36,81.37 139.6,81.37 139.73,81.49 139.73,81.79 139.6,81.91 v1(139.45,81.91)
  IN1 w0.089: 105.43,77.25 104.77,76.59 101.02,76.59 100.75,76.32 100.75,74.23 100.62,74.1 100.25,74.1 99.98,74.37 99.98,74.61 v1(100.12,74.75)
  IN1 w0.147: 105.43,77.25 109.75,81.56 110.03,81.56 110.67,82.21 114.36,82.21 114.51,82.35 114.51,82.53 114.63,82.66 114.97,82.66 115.09,82.53 115.09,82.33 115.22,82.21 117.18,82.21 117.33,82.35 117.33,82.72 117.46,82.84 117.79,82.84 117.92,82.72 117.92,82.35 118.07,82.21 118.36,82.21 118.51,82.35 118.51,82.72 118.64,82.84 118.97,82.84 119.1,82.72 119.1,82.35 119.25,82.21 119.54,82.21 119.69,82.35 119.69,82.72 119.82,82.84 120.15,82.84 120.28,82.72 120.28,82.35 120.42,82.21 124.27,82.21 124.42,82.35 124.42,82.71 124.57,82.85 124.86,82.85 125.01,82.71 125.01,82.35 125.16,82.21 129.84,82.21 129.99,82.35 129.99,82.73 130.12,82.86 130.45,82.86 130.58,82.73 130.58,82.35 130.73,82.21 131.02,82.21 131.17,82.35 131.17,82.73 131.3,82.86 131.63,82.86 131.76,82.73 131.76,82.35 131.91,82.21 132.67,82.21 133.19,81.69 137.45,81.69 137.63,81.87 139.4,81.87 v1(139.45,81.91)
  BOTTOM w0.14: JDIMM2.36 138.37,80.05 139.45,81.13 v1(139.45,81.91)
DDR_A_D15: length 60
  TOP w0.102: JCPU1.AT8 v1(100.12,75.75)
  TOP w0.14: v1(140.97,81.91) 140.97,82.35 140.86,82.46 139.38,82.46 138.86,81.94 138.86,81.4 138.41,80.95 JDIMM1.33
  IN1 w0.089: v1(100.12,75.75) 100.12,76.05 100.87,76.79 104.43,76.79 104.88,77.25
  IN1 w0.147: 104.88,77.25 109.58,81.95 109.86,81.95 110.64,82.73 114.16,82.73 114.66,83.23 120.65,83.23 120.78,83.1 120.78,82.72 120.9,82.6 122.24,82.6 122.37,82.72 122.37,83.12 122.5,83.25 122.83,83.25 122.96,83.12 122.96,82.72 123.09,82.6 123.69,82.6 123.82,82.72 123.82,83.12 123.95,83.25 125.15,83.25 125.47,82.93 125.47,82.72 125.6,82.6 126.01,82.6 126.13,82.72 126.13,83 126.26,83.13 126.55,83.13 126.68,83 126.68,82.72 126.81,82.6 127.42,82.6 127.55,82.72 127.55,83.12 127.68,83.25 128.01,83.25 128.14,83.12 128.14,82.72 128.27,82.6 129.33,82.6 129.45,82.72 129.45,83.12 129.58,83.25 132.18,83.25 133.35,82.08 137.29,82.08 137.57,82.36 140.39,82.36 140.84,81.91 v1(140.97,81.91)
  BOTTOM w0.14: v1(140.97,81.91) 140.97,81.85 140.44,82.38 139.28,82.38 139.01,82.12 139.01,81.28 138.38,80.65 JDIMM2.34
DDR_A_D16: length 60.8
  TOP w0.102: JCPU1.AJ9 v1(99.12,68.75)
  TOP w0.14: JDIMM1.42 144.83,78.25 143.99,79.09 v1(143.99,79.8)
  IN1 w0.089: v1(99.12,68.75) 99.75,69.37 99.75,69.9 99.99,70.15 100.3,70.15 100.72,70.57 100.72,70.88 100.99,71.15 101.3,71.15 101.72,71.57 101.72,71.88 101.99,72.15 102.3,72.15 102.72,72.57 102.72,72.88 102.99,73.15 103.3,73.15 103.72,73.57 103.72,73.88 104,74.16 105.31,74.16 105.7,74.54 105.7,74.86 106.97,76.13 107.7,76.13 108.62,77.05
  IN1 w0.147: v1(143.99,79.8) 145.22,79.8 145.35,79.67 145.35,79.17 145.22,79.04 143.24,79.04 142.95,79.33 138.54,79.33 138.5,79.29 132.2,79.29 131.68,79.81 114.76,79.81 113.64,78.7 112.56,78.7 112.14,79.11 110.68,79.11 108.62,77.05
  BOTTOM w0.14: JDIMM2.41 144.81,78.55 143.99,79.37 v1(143.99,79.8)
DDR_A_D17: length 62.2
  TOP w0.102: JCPU1.AK9 v1(99.12,69.75)
  TOP w0.14: v1(142.46,79.8) 142.96,80.3 144.09,80.3 144.26,80.12 144.28,80.12 144.43,79.97 144.43,79.31 144.89,78.85 JDIMM1.40
  IN1 w0.089: v1(99.12,69.75) 98.8,69.75 98.43,69.37 98.02,69.37 97.8,69.59 97.8,69.9 98.24,70.34 99.25,70.34 99.53,70.63 99.53,70.94 99.93,71.34 100.24,71.34 100.53,71.63 100.53,71.94 100.93,72.34 101.24,72.34 101.53,72.63 101.53,72.94 101.93,73.34 102.24,73.34 102.53,73.63 102.53,73.94 102.94,74.35 103.25,74.35 103.38,74.48 103.53,74.63 103.53,74.94 103.94,75.35 105.27,75.35 107.17,77.25
  IN1 w0.147: 107.17,77.25 110.2,80.28 113.57,80.28 114.27,80.98 132.16,80.98 132.68,80.46 138.02,80.46 138.2,80.64 141.62,80.64 v1(142.46,79.8)
  BOTTOM w0.14: v1(142.46,79.8) 142.89,80.22 144.2,80.22 144.51,79.92 144.51,79.44 144.79,79.15 JDIMM2.39
DDR_A_D18: length 58.6
  TOP w0.102: JCPU1.AJ6 v1(102.12,68.75)
  TOP w0.14: JDIMM1.52 146.99,75.25 v1(147.94,74.31)
  IN1 w0.089: v1(102.12,68.75) 102.74,69.36 102.74,69.89 102.99,70.15 103.36,70.15 103.72,70.51 103.72,70.88 104,71.16 105.31,71.16 105.71,71.56 105.71,71.9 105.96,72.15 106.31,72.15 106.71,72.56 106.71,72.87 107,73.16 107.67,73.16 108.62,74.1
  IN1 w0.147: v1(147.94,74.31) 148.12,74.31 148.24,74.43 148.24,75.66 148.12,75.79 139.89,75.79 139.31,76.37 134.73,76.37 134.13,76.97 131.24,76.97 130.72,77.49 116.34,77.49 115.23,76.37 111.23,76.37 108.96,74.1 108.62,74.1
  BOTTOM w0.14: v1(147.94,74.31) 147.29,74.95 JDIMM2.53
DDR_A_D19: length 62.5
  TOP w0.089: JCPU1.AK6 101.65,69.28 v1(102.12,69.75)
  TOP w0.14: v1(141.75,76.61) 141.6,76.61 141.47,76.49 141.47,75.25 141.6,75.12 141.91,75.12 142.03,75.25 142.03,75.89 142.16,76.02 142.55,76.02 142.72,75.85 143.32,75.85 143.46,75.99 144.14,75.99 144.28,75.85 JDIMM1.50
  IN1 w0.089: 108.62,74.51 108.55,74.51 108.35,74.31 107.9,74.31 107.72,74.13 107.72,73.45 107.61,73.35 106.81,73.35 106.52,73.06 106.52,72.62 106.25,72.35 105.82,72.35 105.52,72.05 105.52,71.62 105.25,71.35 103.82,71.35 103.53,71.06 103.53,70.59 103.28,70.34 102.81,70.34 102.56,70.09 102.56,69.44 102.42,69.3 102.14,69.3 101.93,69.09 101.81,69.09 101.71,69.19 101.71,69.64 101.88,69.81 102.06,69.81 v1(102.12,69.75)
  IN1 w0.147: v1(141.75,76.61) 141.99,76.61 142.12,76.49 142.12,76.3 141.99,76.18 140.05,76.18 139.47,76.76 134.89,76.76 134.29,77.36 131.4,77.36 130.88,77.88 116.18,77.88 115.07,76.76 111.07,76.76 108.81,74.51 108.62,74.51
  BOTTOM w0.14: JDIMM2.51 143.95,75.55 143.81,75.69 143.81,75.93 143.68,76.06 143.38,76.06 143.25,75.93 143.25,75.69 143.11,75.55 142.83,75.55 142.69,75.69 142.69,76.02 142.55,76.16 142.27,76.16 142.13,76.02 142.13,75.69 141.99,75.55 141.72,75.55 141.59,75.68 141.59,76.49 141.72,76.61 v1(141.75,76.61)
DDR_A_D20: length 66.2
  TOP w0.089: JCPU1.AJ10 97.65,68.28 v1(98.12,68.75)
  TOP w0.14: v1(139.42,79.8) 139.42,79.43 139.54,79.3 141.32,79.3 141.45,79.17 141.45,78.76 141.32,78.63 140.01,78.63 139.93,78.55 JDIMM1.41
  IN1 w0.089: v1(98.12,68.75) 98.35,68.75 98.47,68.87 98.47,69.04 98.35,69.16 97.66,69.16 97.53,69.04 97.53,68.26 97.66,68.13 98.62,68.13 98.75,68.26 98.75,69.19 98.87,69.31 99.37,69.31 99.5,69.44 99.5,69.91 99.93,70.34 100.24,70.34 100.53,70.63 100.53,70.94 100.93,71.34 101.24,71.34 101.53,71.63 101.53,71.94 101.93,72.34 102.24,72.34 102.53,72.63 102.53,72.99 102.88,73.34 103.24,73.34 103.53,73.63 103.53,73.94 103.94,74.35 105.25,74.35 105.52,74.62 105.52,74.99 107.05,76.52 107.54,76.52 108.27,77.25
  IN1 w0.147: 108.27,77.25 110.52,79.5 112.3,79.5 112.72,79.09 113.48,79.09 114.6,80.2 131.84,80.2 132.36,79.68 138.34,79.68 138.46,79.8 v1(139.42,79.8)
  BOTTOM w0.14: v1(139.42,79.8) 139.42,79.44 139.54,79.31 141.26,79.31 141.39,79.18 141.39,78.73 141.26,78.6 139.2,78.6 138.85,78.25 JDIMM2.42
DDR_A_D21: length 65.2
  TOP w0.102: JCPU1.AK10 97.7,69.28 v1(98.17,69.75)
  TOP w0.14: v1(140.94,79.8) 141,79.8 141.13,79.93 141.13,80.71 141,80.83 140.67,80.83 140.55,80.71 140.55,80.43 140.42,80.3 140.15,80.3 140.01,80.44 140.01,80.76 139.87,80.9 139.59,80.9 139.45,80.76 139.45,80.44 139.31,80.3 139,80.3 138.87,80.17 138.87,79.33 138.69,79.15 JDIMM1.39
  IN1 w0.089: 107.72,77.25 107.38,76.91 107.14,76.91 105.35,75.12 104.93,75.12 104.78,74.97 104.49,74.97 104.33,75.12 103.97,75.12 103.72,74.88 103.72,74.38 103.49,74.15 102.99,74.15 102.72,73.88 102.72,73.43 102.44,73.15 101.99,73.15 101.72,72.88 101.72,72.38 101.49,72.15 100.99,72.15 100.72,71.88 100.72,71.38 100.49,71.15 99.99,71.15 99.72,70.88 99.72,70.38 99.51,70.17 98.32,70.17 98.17,70.02 v1(98.17,69.75)
  IN1 w0.147: 107.72,77.25 110.36,79.89 112.67,79.89 112.82,79.74 112.82,79.6 112.94,79.47 113.28,79.47 113.41,79.6 113.41,79.74 113.55,79.89 113.73,79.89 114.43,80.59 132,80.59 132.52,80.07 138.18,80.07 138.36,80.25 141.16,80.25 141.29,80.12 141.29,79.93 141.16,79.8 v1(140.94,79.8)
  BOTTOM w0.14: JDIMM2.40 138.49,78.85 138.95,79.31 138.95,79.97 139.32,80.35 140.62,80.35 140.75,80.47 140.75,80.97 140.88,81.1 141.16,81.1 141.28,80.97 141.28,79.93 141.16,79.8 v1(140.94,79.8)
DDR_A_D22: length 62.4
  TOP w0.089: JCPU1.AJ7 100.59,68.26 100.72,68.13 101.06,68.13 101.19,68.26 101.19,68.68 v1(101.12,68.75)
  TOP w0.14: v1(140.23,76.61) 140.15,76.53 140.15,76.29 140.28,76.16 140.78,76.16 140.91,76.03 140.91,75.66 140.78,75.54 140.18,75.54 140.05,75.66 140.05,75.8 139.92,75.93 139.68,75.93 139.56,75.8 139.56,75.66 139.43,75.54 139.24,75.54 138.65,74.95 JDIMM1.53
  IN1 w0.089: v1(101.12,68.75) 101.12,69.14 101.01,69.26 100.85,69.26 100.73,69.14 100.73,68.63 100.61,68.5 100.42,68.5 100.31,68.39 100.31,68.26 100.44,68.13 101.58,68.13 101.71,68.26 101.71,68.79 101.53,68.98 101.53,69.72 101.96,70.15 102.36,70.15 102.72,70.51 102.72,70.91 102.96,71.15 103.36,71.15 103.72,71.51 103.72,71.91 103.97,72.16 105.38,72.16 105.72,72.5 105.72,72.91 105.97,73.16 106.37,73.16 106.71,73.5 106.71,73.92 106.92,74.13 107.44,74.13 108.21,74.9 108.62,74.9
  IN1 w0.147: 108.62,74.9 108.63,74.9 108.65,74.9 110.91,77.15 114.91,77.15 116.02,78.27 131.04,78.27 131.56,77.75 134.45,77.75 135.05,77.15 140.45,77.15 140.58,77.02 140.58,76.73 140.45,76.61 v1(140.23,76.61)
  BOTTOM w0.14: v1(140.23,76.61) 140.19,76.57 140.19,76.31 140.26,76.24 140.8,76.24 140.92,76.11 140.92,75.87 140.8,75.74 139.91,75.74 139.78,75.87 139.78,76.11 139.66,76.24 139.47,76.24 139.34,76.11 139.34,75.87 139.21,75.74 139.1,75.74 138.6,75.25 JDIMM2.52
DDR_A_D23: length 62.5
  TOP w0.102: JCPU1.AK7 v1(101.12,69.75)
  TOP w0.14: JDIMM1.51 138.56,75.55 140.06,77.05 142.85,77.05 v1(143.29,76.61)
  IN1 w0.089: 108.62,75.41 108.62,75.45 108.5,75.33 108.29,75.33 107.29,74.33 106.84,74.33 106.52,74.01 106.52,73.58 106.29,73.35 105.89,73.35 105.53,72.99 105.53,72.58 105.3,72.35 103.89,72.35 103.53,71.99 103.53,71.59 103.28,71.34 102.88,71.34 102.53,70.99 102.53,70.59 102.28,70.34 101.88,70.34 101.34,69.8 101.33,69.8 101.28,69.75 v1(101.12,69.75)
  IN1 w0.147: 108.62,75.41 110.75,77.54 114.75,77.54 115.86,78.65 131.2,78.65 131.72,78.13 134.61,78.13 135.21,77.53 141.83,77.53 141.97,77.39 141.97,77.23 142.12,77.09 142.42,77.09 142.56,77.23 142.56,77.39 142.71,77.53 143.32,77.53 143.44,77.41 143.44,76.74 143.32,76.61 v1(143.29,76.61)
  BOTTOM w0.14: v1(143.29,76.61) 142.85,77.05 139.56,77.05 138.36,75.85 JDIMM2.50
DDR_A_D24: length 55.9
  TOP w0.102: JCPU1.AF4 v1(104.12,65.75)
  TOP w0.14: JDIMM1.58 144.4,73.45 144.15,73.7 v1(144.15,74.58)
  IN1 w0.089: v1(104.12,65.75) 104.41,66.03 104.41,66.03 104.72,66.34 104.72,67 104.94,67.22 105.24,67.22 105.55,67.52 105.55,67.88 105.8,68.13 106.53,68.13 106.74,68.34 106.74,70 107.02,70.28 107.29,70.28 107.5,70.49 107.5,70.97 108.14,71.61 108.34,71.61 108.62,71.89
  IN1 w0.147: 108.62,71.89 108.82,72.09 109.24,72.09 111.9,74.76 115.9,74.76 117.02,75.87 130.05,75.87 130.57,75.35 133.46,75.35 134.06,74.75 138.26,74.75 139.49,73.52 144.92,73.52 145.04,73.65 145.04,74.46 144.92,74.58 v1(144.15,74.58)
  BOTTOM w0.14: JDIMM2.59 144.62,73.15 144.15,73.62 v1(144.15,74.58)
DDR_A_D25: length 59.3
  TOP w0.102: JCPU1.AF5 v1(103.12,65.75)
  TOP w0.14: v1(142.63,74.58) 142.52,74.7 142.52,75.28 142.64,75.41 144.46,75.41 144.59,75.28 144.59,74.25 144.79,74.05 JDIMM1.56
  IN1 w0.089: v1(103.12,65.75) 103.54,65.75 104.14,66.35 104.29,66.35 104.52,66.58 104.52,67.82 105.01,68.31 106.46,68.31 106.56,68.41 106.56,70.72 107.03,71.18 107.38,71.18 108.62,72.42
  IN1 w0.147: 108.62,72.42 108.68,72.48 109.08,72.48 111.74,75.14 115.74,75.14 116.85,76.26 130.21,76.26 130.73,75.74 133.62,75.74 134.22,75.14 138.42,75.14 139.65,73.91 142.85,73.91 142.98,74.03 142.98,74.46 142.85,74.58 v1(142.63,74.58)
  BOTTOM w0.14: JDIMM2.57 144.78,73.75 144.59,73.95 144.59,74.94 144.43,75.09 142.48,75.09 142.35,74.97 142.35,74.71 142.48,74.58 v1(142.63,74.58)
DDR_A_D26: length 53.3
  TOP w0.102: JCPU1.AF1 v1(107.12,65.75)
  TOP w0.14: v1(147.91,71.84) 147.91,71.23 146.53,69.85 JDIMM1.70
  IN1 w0.089: v1(107.12,65.75) 107.12,66.13 107.53,66.54 107.53,67.16 109.36,68.98 109.36,69.25 109.87,69.77 109.89,69.77
  IN1 w0.147: 109.89,69.77 110.2,69.77 112.86,72.43 117.86,72.43 118.46,73.03 132.5,73.03 133.2,72.32 137.4,72.32 139.1,70.62 146.69,70.62 v1(147.91,71.84)
  BOTTOM w0.14: v1(147.91,71.84) 147.91,71.05 147.01,70.15 JDIMM2.69
DDR_A_D27: length 54.1
  TOP w0.102: JCPU1.AF2 v1(106.12,65.75)
  TOP w0.14: v1(142.97,71.45) 142.97,71.07 143.59,70.45 JDIMM1.68
  IN1 w0.089: 109.43,69.89 109.13,69.58 109.13,69.01 107.36,67.24 107.36,66.62 107,66.26 106.64,66.26 v1(106.12,65.75)
  IN1 w0.147: v1(142.97,71.45) 143.52,72.01 144.86,72.01 144.99,71.88 144.99,71.14 144.86,71.01 139.26,71.01 137.56,72.71 133.36,72.71 132.66,73.41 118.3,73.41 117.7,72.82 112.7,72.82 110.04,70.16 109.7,70.16 109.43,69.89
  BOTTOM w0.14: JDIMM2.67 143.68,70.75 v1(142.97,71.45)
DDR_A_D28: length 56.9
  TOP w0.102: JCPU1.AG4 v1(104.12,66.75)
  TOP w0.14: JDIMM1.59 139.38,73.15 139.57,73.34 140.31,73.34 140.44,73.47 140.44,73.89 140.31,74.01 139.71,74.01 139.58,74.14 v1(139.58,74.58)
  IN1 w0.089: v1(104.12,66.75) 104.33,66.95 104.33,67.19 104.26,67.26 102.86,67.26 102.67,67.45 102.67,68.2 102.76,68.29 104.5,68.29 104.61,68.39 104.61,69.14 104.67,69.2 105.56,69.2 105.71,69.35 105.71,70.96 105.91,71.16 106.65,71.16 106.72,71.23 106.72,72.01 106.87,72.16 107.84,72.16 108.55,72.87 108.62,72.87
  IN1 w0.147: 108.62,72.87 108.91,72.87 111.58,75.53 115.58,75.53 116.69,76.65 130.37,76.65 130.89,76.13 133.78,76.13 134.38,75.53 138.96,75.53 139.58,74.91 v1(139.58,74.58)
  BOTTOM w0.14: JDIMM2.58 138.61,73.45 138.96,73.1 139.18,73.1 139.33,73.25 139.33,73.42 139,73.74 139,73.92 139.22,74.14 139.4,74.14 139.72,73.81 139.89,73.81 140.15,74.07 140.15,74.17 139.74,74.58 v1(139.58,74.58)
DDR_A_D29: length 58
  TOP w0.102: JCPU1.AG5 v1(103.12,66.75)
  TOP w0.14: v1(141.11,74.58) 140.6,75.09 139.48,75.09 138.96,74.57 138.96,74.24 138.47,73.75 JDIMM1.57
  IN1 w0.089: v1(103.12,66.75) 102.7,66.75 102.5,66.95 102.5,68.87 102.93,69.3 103.55,69.3 103.75,69.5 103.75,70.03 104.06,70.35 105.29,70.35 105.52,70.58 105.52,71.04 105.83,71.35 106.29,71.35 106.52,71.58 106.52,72.06 106.81,72.35 107.5,72.35 108.41,73.26 108.62,73.26
  IN1 w0.147: 108.62,73.26 108.75,73.26 111.42,75.92 115.42,75.92 116.53,77.04 130.53,77.04 131.05,76.52 133.94,76.52 134.54,75.92 139.12,75.92 139.7,75.34 139.97,75.34 140.12,75.19 140.12,75.14 140.24,75.01 140.58,75.01 140.71,75.14 140.71,75.19 140.85,75.34 141.53,75.34 141.66,75.21 141.66,74.98 141.53,74.85 141.23,74.85 141.11,74.72 v1(141.11,74.58)
  BOTTOM w0.14: v1(141.11,74.58) 141.11,75 140.81,75.3 139.58,75.3 139.14,74.86 139.14,74.6 138.59,74.05 JDIMM2.56
DDR_A_D30: length 53.7
  TOP w0.089: JCPU1.AG1 106.59,66.47 106.89,66.77 v1(106.98,66.77)
  TOP w0.14: v1(139.9,71.45) 139.9,71.07 140.03,70.94 140.52,70.94 140.65,70.81 140.65,70.42 140.52,70.29 139.67,70.29 139.53,70.15 JDIMM1.69
  IN1 w0.089: v1(106.98,66.77) 106.98,67.14 108.82,68.98 108.82,69.83 108.88,69.89
  IN1 w0.147: v1(139.9,71.45) 139.88,71.44 139.38,71.44 137.72,73.1 133.52,73.1 132.82,73.8 125.34,73.8 125.19,73.95 125.19,74.2 125.07,74.32 124.73,74.32 124.61,74.2 124.61,73.95 124.46,73.8 124.16,73.8 124.02,73.95 124.02,74.2 123.89,74.32 123.55,74.32 123.43,74.2 123.43,73.95 123.28,73.8 122.99,73.8 122.84,73.95 122.84,74.2 122.71,74.32 122.38,74.32 122.25,74.2 122.25,73.95 122.1,73.8 121.81,73.8 121.66,73.95 121.66,74.2 121.53,74.32 121.2,74.32 121.07,74.2 121.07,73.95 120.92,73.8 120.63,73.8 120.48,73.95 120.48,74.2 120.35,74.32 120.02,74.32 119.89,74.2 119.89,73.95 119.74,73.8 119.45,73.8 119.3,73.95 119.3,74.2 119.18,74.32 118.84,74.32 118.71,74.2 118.71,73.95 118.57,73.8 118.27,73.8 118.12,73.95 118.12,74.17 117.98,74.32 117.66,74.32 117.37,74.03 117.37,73.71 117.53,73.54 117.53,73.34 117.41,73.21 112.54,73.21 109.88,70.55 109.54,70.55 108.88,69.89
  BOTTOM w0.14: JDIMM2.70 139.75,69.85 139.87,69.98 139.87,70.08 140,70.2 140.57,70.2 140.7,70.33 140.7,70.76 140.57,70.89 140.03,70.89 139.9,71.02 v1(139.9,71.45)
DDR_A_D31: length 55.9
  TOP w0.089: JCPU1.AG2 105.65,66.28 v1(106.12,66.75)
  TOP w0.14: v1(141.44,71.45) 140.87,72.02 140.87,72.42 140.74,72.55 139.28,72.55 139.15,72.42 139.15,70.88 139.02,70.75 JDIMM1.67
  IN1 w0.089: 108.62,70.17 108.52,70.07 108.52,69.02 106.56,67.07 106.56,66.72 106.43,66.6 106.27,66.6 v1(106.12,66.75)
  IN1 w0.147: v1(141.44,71.45) 141.66,71.45 141.78,71.58 141.78,71.77 141.66,71.9 139.47,71.9 137.88,73.49 133.68,73.49 132.98,74.19 127.12,74.19 126.97,74.34 126.97,74.59 126.84,74.71 126.51,74.71 126.38,74.59 126.38,74.34 126.23,74.19 125.94,74.19 125.79,74.34 125.79,74.59 125.66,74.71 117.5,74.71 116.38,73.6 112.38,73.6 109.72,70.93 109.38,70.93 108.62,70.17
  BOTTOM w0.14: JDIMM2.68 138.92,70.45 139.31,70.84 139.31,71.49 140.12,72.3 141.66,72.3 141.79,72.17 141.79,71.58 141.66,71.45 v1(141.44,71.45)
DDR_A_D32: length 50.9
  TOP w0.102: JCPU1.J1 v1(107.12,47.75)
  TOP w0.14: v1(143.95,47.38) 143.47,47.86 143.47,48.23 143.58,48.35 144.38,48.35 144.89,48.85 JDIMM1.132
  IN1 w0.089: 108.62,46.68 108.45,46.85 108.45,47.34 108.04,47.75 v1(107.12,47.75)
  IN1 w0.147: v1(143.95,47.38) 143.95,47.37 144.08,47.24 145.08,47.24 145.21,47.37 145.21,47.69 145.08,47.82 138.07,47.82 136.13,45.87 133.97,45.87 132.48,44.38 131.57,44.38 130.93,43.73 112.85,43.73 109.9,46.68 108.62,46.68
  BOTTOM w0.14: v1(143.95,47.38) 143.95,48.19 144.91,49.15 JDIMM2.131
DDR_A_D33: length 53.7
  TOP w0.102: JCPU1.J2 v1(106.12,47.75)
  TOP w0.14: JDIMM1.130 144.95,49.45 144.22,48.73 143.21,48.73 142.42,47.94 v1(142.42,47.39)
  IN1 w0.089: v1(106.12,47.75) 106.12,47.44 106.66,46.9 106.66,46.54 106.82,46.39 107.76,46.39 108.62,45.53 108.59,45.53 108.61,45.51 108.62,45.51
  IN1 w0.147: 108.62,45.51 109.42,45.51 112.37,42.57 131.41,42.57 132.06,43.22 132.96,43.22 134.45,44.71 136.61,44.71 137.77,45.87 138.23,45.87 138.93,46.57 139.96,46.57 140.19,46.34 143.58,46.34 143.71,46.47 143.71,46.8 143.58,46.92 142.55,46.92 142.42,47.05 v1(142.42,47.39)
  BOTTOM w0.14: JDIMM2.129 144.97,49.75 144.02,48.8 143.84,48.8 v1(142.42,47.39)
DDR_A_D34: length 55.6
  TOP w0.102: v1(103.12,47.75) 102.53,47.75 102.4,47.88 102.4,48.08 102.59,48.28 JCPU1.J5
  TOP w0.14: JDIMM1.141 138.79,46.15 140.06,44.88 140.06,44.71 139.84,44.49 139.84,44.39 139.72,44.27 v1(139.57,44.27)
  IN1 w0.089: 108.62,43.97 108.44,43.97 108.32,44.09 108.32,44.28 108.2,44.4 108.07,44.4 107.86,44.19 107.71,44.19 107.61,44.3 107.61,44.44 107.82,44.65 107.82,44.78 107.69,44.91 107.56,44.91 107.34,44.69 107.22,44.69 106.17,45.73 105.75,45.73 105.68,45.81 105.62,45.81 105.29,46.14 104.94,46.14 104.57,46.51 104.57,47.1 104.44,47.23 103.67,47.23 103.56,47.33 102.84,47.33 102.54,47.03 102.54,46.15 102.41,46.03 101.72,46.03 101.6,46.15 101.6,46.77 102.57,47.75 v1(103.12,47.75)
  IN1 w0.147: 108.62,43.97 108.78,43.97 111.72,41.02 132.05,41.02 132.7,41.67 133.6,41.67 135.1,43.16 137.26,43.16 138.37,44.27 v1(139.57,44.27)
  BOTTOM w0.14: v1(139.57,44.27) 139.57,45.24 138.35,46.45 JDIMM2.140
DDR_A_D35: length 56.8
  TOP w0.102: JCPU1.H5 102.64,47.28 v1(103.17,46.75)
  TOP w0.14: JDIMM1.143 138.79,45.55 139.07,45.27 139.07,44.13 139.65,43.56 141.19,43.56 141.32,43.69 141.32,44.14 141.19,44.27 v1(141.09,44.27)
  IN1 w0.089: v1(103.17,46.75) 103.17,46.48 103.39,46.26 104.52,46.26 104.58,46.2 104.58,45.51 104.72,45.37 105.39,45.37 105.57,45.55 106.1,45.55 108.07,43.58 108.62,43.58 108.62,43.58
  IN1 w0.147: 108.62,43.58 110.1,42.09 111.56,40.63 132.21,40.63 132.86,41.28 134.06,41.28 134.55,41.78 135.28,41.78 135.4,41.9 135.4,42.27 135.53,42.4 135.86,42.4 135.99,42.27 135.99,41.9 136.11,41.78 136.24,41.78 136.58,42.11 136.58,42.64 136.71,42.77 137.43,42.77 138.49,43.84 141.31,43.84 141.44,43.96 141.44,44.14 141.31,44.27 v1(141.09,44.27)
  BOTTOM w0.14: JDIMM2.142 138.38,45.85 139.12,45.1 139.12,44.08 139.45,43.75 140.71,43.75 141.09,44.13 v1(141.09,44.27)
DDR_A_D36: length 54.9
  TOP w0.102: v1(106.12,46.75) 106.12,47.26 105.99,47.39 105.7,47.39 JCPU1.H2
  TOP w0.14: JDIMM1.131 138.86,49.15 139.1,48.92 139.1,48.51 139.21,48.4 140.91,48.4 141.04,48.28 141.04,48.01 140.91,47.89 139.49,47.89 139.37,47.77 v1(139.37,47.39)
  IN1 w0.089: v1(106.12,46.75) 106,46.75 105.88,46.87 105.88,47.22 105.5,47.6 105.5,47.93 105.69,48.12 106.6,48.12 106.75,47.97 106.75,47.81 106.45,47.51 106.45,47.37 106.74,47.08 106.9,47.08 107,47.18 107,47.25 107.13,47.37 107.32,47.37 107.51,47.56 107.97,47.56 108.23,47.3 108.23,47.16 108.01,46.94 108.01,46.77 108.49,46.29 108.62,46.29
  IN1 w0.147: v1(139.37,47.39) 138.19,47.39 136.29,45.48 134.13,45.48 132.64,43.99 131.73,43.99 131.09,43.35 112.69,43.35 109.74,46.29 108.62,46.29
  BOTTOM w0.14: JDIMM2.132 138.62,48.85 138.95,48.52 140.75,48.52 140.87,48.39 140.87,48.04 140.75,47.92 139.23,47.92 139.1,47.79 139.1,47.52 139.23,47.39 v1(139.37,47.39)
DDR_A_D37: length 53.7
  TOP w0.089: v1(107.12,46.77) 107.02,46.67 106.6,46.67 106.5,46.77 106.5,47.19 JCPU1.H1
  TOP w0.14: JDIMM1.129 138.8,49.75 139.77,48.78 141.61,48.78 141.74,48.66 141.74,48.01 141.61,47.89 141.45,47.89 140.95,47.39 v1(140.9,47.39)
  IN1 w0.089: v1(107.12,46.77) 107.12,46.9 107.6,47.38 107.76,47.38 107.87,47.26 107.87,47.1 107.51,46.75 107.51,46.63 107.58,46.57 107.95,46.57 108.08,46.45 108.08,46.33 108.5,45.9 108.62,45.9
  IN1 w0.147: 108.62,45.9 109.58,45.9 112.53,42.96 131.25,42.96 131.89,43.6 132.8,43.6 134.29,45.1 136.45,45.1 137.77,46.42 138.17,46.42 138.3,46.55 138.3,46.83 138.43,46.96 140.13,46.96 140.36,46.73 141.24,46.73 141.37,46.86 141.37,47.06 141.05,47.39 v1(140.9,47.39)
  BOTTOM w0.14: JDIMM2.130 138.84,49.45 139.29,48.99 139.97,48.99 140.21,49.24 141.13,49.24 141.25,49.11 141.25,47.52 141.13,47.39 v1(140.9,47.39)
DDR_A_D38: length 55.6
  TOP w0.102: JCPU1.J4 v1(104.12,47.75)
  TOP w0.14: v1(142.61,44.27) 142.61,44.57 144.5,46.45 JDIMM1.140
  IN1 w0.089: 108.62,44.36 108.51,44.36 107.62,45.25 106.91,45.25 106.24,45.91 105.83,45.91 105.75,45.98 105.7,45.98 105.37,46.31 105.01,46.31 104.75,46.58 104.75,47.65 104.65,47.75 v1(104.12,47.75)
  IN1 w0.147: v1(142.61,44.27) 142.71,44.27 143.17,44.72 143.72,44.72 143.85,44.85 143.85,45.29 143.72,45.42 142.79,45.42 142.09,44.71 138.27,44.71 137.1,43.55 134.93,43.55 133.44,42.06 132.54,42.06 131.89,41.41 111.88,41.41 108.94,44.36 108.62,44.36
  BOTTOM w0.14: JDIMM2.141 144.45,46.15 142.61,44.32 142.61,44.32 v1(142.61,44.27)
DDR_A_D39: length 53.8
  TOP w0.102: v1(103.96,46.75) 103.59,47.11 JCPU1.H4
  TOP w0.14: JDIMM1.142 144.48,45.85 144.14,45.51 v1(144.14,44.27)
  IN1 w0.089: v1(103.96,46.75) 103.82,46.75 103.44,47.12 103.02,47.12 102.8,46.9 102.8,46.54 103.13,46.21 103.19,46.21 103.59,45.81 103.59,45.75 104.15,45.18 106.21,45.18 108.21,43.19 108.46,43.19 108.62,43.03
  IN1 w0.147: v1(144.14,44.27) 143.32,43.45 138.65,43.45 137.59,42.38 137.4,42.38 136.4,41.39 134.71,41.39 134.2,40.87 133.01,40.87 132.38,40.24 111.4,40.24 108.62,43.03
  BOTTOM w0.14: v1(144.14,44.27) 144.14,45.1 144.59,45.55 145.79,45.55 JDIMM2.143
DDR_A_D40: length 55.1
  TOP w0.102: v1(105.12,44.75) JCPU1.F2
  TOP w0.14: v1(142.89,42.03) 142.74,42.03 142.61,42.16 142.61,43.64 142.74,43.77 143.09,43.77 143.23,43.63 143.23,43.29 143.36,43.17 143.66,43.17 143.79,43.29 143.79,43.63 143.93,43.77 144.5,43.77 144.79,44.05 JDIMM1.148
  IN1 w0.089: v1(105.12,44.75) 105.5,44.75 106.07,44.18 106.22,44.18 108.56,41.84 108.62,41.84
  IN1 w0.147: v1(142.89,42.03) 143.12,42.03 143.24,42.16 143.24,42.48 143.12,42.61 139,42.61 137.93,41.54 137.75,41.54 136.75,40.55 135.06,40.55 134.54,40.03 133.36,40.03 132.73,39.4 111.05,39.4 109.59,40.86 108.62,41.84
  BOTTOM w0.14: v1(142.89,42.03) 142.66,42.03 142.54,42.16 142.54,43.62 142.66,43.75 143.07,43.75 143.21,43.61 143.21,43.36 143.33,43.23 143.64,43.23 143.77,43.36 143.77,43.61 143.9,43.75 JDIMM2.149
DDR_A_D41: length 49.5
  TOP w0.102: v1(106.12,44.75) JCPU1.F1
  TOP w0.14: v1(147.15,44.51) 147.01,44.65 JDIMM1.146
  IN1 w0.089: 108.62,42.39 108.62,42.42 108.39,42.65 108.2,42.65 106.12,44.72 v1(106.12,44.75)
  IN1 w0.147: 108.62,42.39 109.75,41.25 111.21,39.79 132.57,39.79 133.2,40.42 134.38,40.42 134.9,40.94 136.59,40.94 137.59,41.93 137.77,41.93 138.84,43 147.09,43 147.21,43.12 147.21,44.45 v1(147.15,44.51)
  BOTTOM w0.14: v1(147.15,44.51) 146.99,44.35 JDIMM2.147
DDR_A_D42: length 51.9
  TOP w0.102: v1(105.12,42.75) JCPU1.D2
  TOP w0.14: v1(143.97,38.92) 143.97,38.99 144.59,39.61 144.59,40.24 144.79,40.45 JDIMM1.160
  IN1 w0.089: 108.62,39.07 106.34,41.35 105.96,41.35 105.52,41.78 105.52,41.91 105.12,42.31 v1(105.12,42.75)
  IN1 w0.147: 108.62,39.07 108.76,38.93 110.25,37.44 133.51,37.44 134.16,38.1 137.04,38.1 138.53,39.59 138.77,39.59 139.18,40 144.75,40 144.88,39.87 144.88,39.05 144.75,38.92 v1(143.97,38.92)
  BOTTOM w0.14: v1(143.97,38.92) 143.97,39.9 144.81,40.75 JDIMM2.159
DDR_A_D43: length 53.9
  TOP w0.089: JCPU1.D3 104.71,43.16 104.71,42.87 104.58,42.75 v1(104.12,42.75)
  TOP w0.14: v1(142.44,38.92) 142.87,39.36 143.67,39.36 144.23,39.91 144.23,40.52 144.76,41.05 JDIMM1.158
  IN1 w0.089: v1(104.12,42.75) 104.61,42.75 104.68,42.67 104.68,41.62 104.96,41.35 105.42,41.35 105.61,41.16 106.24,41.16 106.57,40.83 106.57,40.57 108.37,38.77
  IN1 w0.147: 108.37,38.77 108.6,38.54 108.6,38.54 110.09,37.05 133.67,37.05 134.32,37.71 137.2,37.71 138.69,39.2 138.93,39.2 139.34,39.61 142.66,39.61 142.78,39.48 142.78,39.05 142.66,38.92 v1(142.44,38.92)
  BOTTOM w0.14: JDIMM2.157 144.84,41.35 143.94,40.45 143.74,40.45 142.44,39.14 v1(142.44,38.92)
DDR_A_D44: length 53.9
  TOP w0.089: v1(106.12,42.75) 106.59,43.22 JCPU1.D1
  TOP w0.14: v1(141.37,42.03) 141.78,41.62 141.78,41.36 141.58,41.17 141.3,41.17 140.98,41.49 139.52,41.49 139.2,41.81 139.2,42.96 138.41,43.75 JDIMM1.149
  IN1 w0.089: 108.62,40.74 107.75,41.6 107.4,41.6 107.04,41.97 107.04,42.49 106.78,42.75 v1(106.12,42.75)
  IN1 w0.147: v1(141.37,42.03) 141.59,42.03 141.72,41.9 141.72,41.72 141.58,41.59 139.08,41.59 138.26,40.76 138.07,40.76 136.56,39.25 133.68,39.25 133.05,38.63 110.73,38.63 109.27,40.09 108.62,40.74
  BOTTOM w0.14: v1(141.37,42.03) 141.56,42.03 141.69,41.9 141.69,41.72 141.56,41.59 139.56,41.59 139.4,41.74 139.4,42.26 139.59,42.45 139.59,42.82 139.43,42.99 139.02,42.99 138.82,43.19 138.82,43.6 138.36,44.05 JDIMM2.148
DDR_A_D45: length 57.8
  TOP w0.089: JCPU1.F3 104.59,45.22 v1(104.12,44.75)
  TOP w0.14: v1(139.84,42.03) 139.84,42.4 139.96,42.53 141.32,42.53 141.45,42.66 141.45,42.99 141.32,43.11 139.61,43.11 138.37,44.35 JDIMM1.147
  IN1 w0.089: v1(104.12,44.75) 103.72,45.15 102.87,45.15 102.74,45.02 102.74,44.36 102.87,44.23 105.53,44.23 105.7,44.07 105.7,43.29 105.85,43.14 106.77,43.14 108.62,41.29
  IN1 w0.147: 108.62,41.29 109.43,40.48 110.89,39.01 132.89,39.01 133.52,39.64 136.4,39.64 137.91,41.15 138.1,41.15 139.14,42.2 139.66,42.2 v1(139.84,42.03)
  BOTTOM w0.14: v1(139.84,42.03) 140.42,42.61 141.28,42.61 141.41,42.74 141.41,43.18 141.28,43.3 139.52,43.3 138.82,44 138.82,44.23 138.4,44.65 JDIMM2.146
DDR_A_D46: length 53.9
  TOP w0.089: v1(104.12,41.75) 104.2,41.67 104.59,41.67 104.73,41.81 104.73,42.14 JCPU1.C3
  TOP w0.14: v1(139.44,38.92) 140.08,39.56 140.08,39.75 139.84,39.99 139.64,39.99 139.24,39.59 139.06,39.59 138.85,39.81 138.85,39.99 139.25,40.38 139.25,40.58 139.07,40.75 JDIMM1.159
  IN1 w0.089: 107.82,38.77 106.24,40.35 105.99,40.35 105.72,40.62 105.72,40.77 105.34,41.16 104.71,41.16 v1(104.12,41.75)
  IN1 w0.147: v1(139.44,38.92) 139.33,38.81 138.85,38.81 137.36,37.32 134.48,37.32 133.83,36.66 116.74,36.66 116.59,36.52 116.59,36.02 116.47,35.9 116.13,35.9 116,36.02 116,36.52 115.86,36.66 115.56,36.66 115.41,36.52 115.41,36.02 115.29,35.9 114.95,35.9 114.82,36.02 114.82,36.52 114.68,36.66 114.38,36.66 114.23,36.52 114.23,36.02 114.11,35.9 113.77,35.9 113.65,36.02 113.65,36.52 113.5,36.66 109.93,36.66 108.44,38.15 107.82,38.77
  BOTTOM w0.14: v1(139.44,38.92) 139.44,39.17 139.64,39.37 140.31,39.37 140.42,39.48 140.42,39.69 139.96,40.15 139.66,40.15 139.53,40.02 139.53,39.84 139.4,39.71 139.16,39.71 139.04,39.84 139.04,40.02 138.91,40.15 138.66,40.15 138.36,40.45 JDIMM2.160
DDR_A_D47: length 53.3
  TOP w0.089: v1(104.12,40.75) 104.56,40.75 104.68,40.87 104.68,41.19 JCPU1.B3
  TOP w0.14: v1(140.92,38.92) 141.14,39.15 141.14,39.32 140.16,40.3 140.16,40.5 140.34,40.68 140.34,40.88 140.14,41.08 139.95,41.08 139.77,40.9 139.57,40.9 139.11,41.35 JDIMM1.157
  IN1 w0.089: 107.27,38.77 105.67,40.37 104.93,40.37 104.56,40.75 v1(104.12,40.75)
  IN1 w0.147: 107.27,38.77 109.76,36.27 112.84,36.27 113.61,35.51 116.97,35.51 117.74,36.27 133.99,36.27 134.64,36.93 137.52,36.93 139.01,38.42 141.14,38.42 141.27,38.55 141.27,38.8 141.14,38.92 v1(140.92,38.92)
  BOTTOM w0.14: JDIMM2.158 138.39,41.05 138.91,40.53 140.12,40.53 140.73,39.91 141.2,39.91 141.42,39.69 141.42,39.3 141.04,38.92 v1(140.92,38.92)
DDR_A_D48: length 59.4
  TOP w0.102: v1(102.12,40.75) JCPU1.B5
  TOP w0.14: JDIMM1.163 138.46,39.55 138.94,39.07 138.94,38.8 139.45,38.29 140.92,38.29 141.05,38.16 v1(141.05,36.89)
  IN1 w0.089: 104.63,38.77 104.22,39.18 103.91,39.18 103.53,39.56 103.53,39.96 103.34,40.16 102.88,40.16 102.29,40.75 v1(102.12,40.75)
  IN1 w0.147: v1(141.05,36.89) 140.62,36.46 139.34,36.46 137.54,34.66 134.48,34.66 134.48,34.65 132.35,34.65 132.21,34.5 132.21,34.02 132.08,33.89 131.74,33.89 131.62,34.02 131.62,34.5 131.47,34.65 131.18,34.65 131.03,34.5 131.03,34.02 130.9,33.89 130.57,33.89 130.44,34.02 130.44,34.53 130.31,34.66 129.11,34.66 128.97,34.51 128.97,34.02 128.84,33.89 128.5,33.89 128.38,34.02 128.38,34.51 128.23,34.66 127.94,34.66 127.79,34.51 127.79,34.02 127.66,33.89 112.94,33.89 112.17,34.66 109.08,34.66 107.64,36.1 107.31,36.1 104.63,38.77
  BOTTOM w0.14: v1(141.05,36.89) 141.16,36.89 141.64,37.37 141.64,38.11 141.27,38.48 139.19,38.48 138.42,39.25 JDIMM2.164
DDR_A_D49: length 60.4
  TOP w0.102: v1(101.12,43.75) JCPU1.E6
  TOP w0.14: v1(139.7,36.89) 139.7,37.23 139.82,37.36 140.19,37.36 140.31,37.49 140.31,37.78 140.19,37.91 139.14,37.91 138.9,38.15 138.9,38.41 138.36,38.95 JDIMM1.165
  IN1 w0.089: v1(101.12,43.75) 101.72,43.15 101.72,42.58 101.96,42.35 102.09,42.35 102.52,41.91 102.52,40.78 102.96,40.35 103.42,40.35 103.72,40.04 103.72,39.62 103.98,39.36 104.62,39.36 105.22,38.77
  IN1 w0.147: v1(139.7,36.89) 139.22,36.89 138.02,35.68 137.38,35.68 137.23,35.54 137.23,35.21 137.09,35.06 136.79,35.06 136.64,35.21 136.64,35.54 136.5,35.68 136.19,35.68 136.06,35.56 136.06,35.17 135.93,35.05 127.31,35.05 127.17,34.9 127.17,34.4 127.04,34.28 126.7,34.28 126.58,34.4 126.58,34.9 126.43,35.05 126.14,35.05 125.99,34.9 125.99,34.4 125.86,34.28 125.53,34.28 125.4,34.4 125.4,34.9 125.25,35.05 124.96,35.05 124.81,34.9 124.81,34.4 124.68,34.28 124.35,34.28 124.22,34.4 124.22,34.82 124.09,34.95 123.76,34.95 123.63,34.82 123.63,34.4 123.5,34.28 113.1,34.28 112.33,35.05 109.25,35.05 107.81,36.49 107.5,36.49 105.22,38.77
  BOTTOM w0.14: v1(139.7,36.89) 139.7,37.19 139.82,37.32 140.56,37.32 140.69,37.44 140.69,37.97 140.56,38.1 139.01,38.1 138.46,38.65 JDIMM2.166
DDR_A_D50: length 55.9
  TOP w0.102: v1(102.12,39.75) JCPU1.A5
  TOP w0.14: JDIMM1.176 144.86,35.65 144.06,34.86 v1(144.06,33.81)
  IN1 w0.147: v1(144.06,33.81) 144.73,33.81 144.85,33.94 144.85,34.73 144.73,34.86 139.38,34.86 138.01,33.49 134.23,33.49 132.83,32.09 121.56,32.09 120.92,32.73 112.46,32.73 111.69,33.5 108.45,33.5 107.09,34.86 106.87,34.86 102.12,39.61 v1(102.12,39.75)
  BOTTOM w0.14: v1(144.06,33.81) 144.19,33.68 144.39,33.68 144.52,33.81 144.52,35.21 144.66,35.35 JDIMM2.177
DDR_A_D51: length 59.2
  TOP w0.102: v1(101.12,42.75) JCPU1.D6
  TOP w0.14: JDIMM1.175 138.87,35.95 141.01,33.81 v1(141.01,33.81)
  IN1 w0.089: v1(101.12,42.75) 100.73,42.36 100.73,41.92 100.72,41.91 100.72,39.36 101.31,38.77
  IN1 w0.147: 101.31,38.77 106.38,33.7 106.61,33.7 107.97,32.33 108.4,32.33 108.54,32.19 108.54,31.94 108.67,31.81 109.01,31.81 109.13,31.94 109.13,32.19 109.28,32.33 109.67,32.33 109.8,32.21 109.8,31.91 109.93,31.78 111.24,31.78 111.36,31.65 111.36,31.05 111.49,30.93 133.31,30.93 134.17,31.79 138.02,31.79 139.54,33.31 140.51,33.31 v1(141.01,33.81)
  BOTTOM w0.14: v1(141.01,33.81) 141.01,33.84 138.6,36.25 JDIMM2.174
DDR_A_D52: length 59.5
  TOP w0.102: v1(102.12,42.75) JCPU1.D5
  TOP w0.14: v1(142.45,36.89) 142.45,37.83 142.81,38.19 143.94,38.19 144.51,38.75 144.51,38.9 144.86,39.25 JDIMM1.164
  IN1 w0.089: v1(102.12,42.75) 102.71,42.16 102.71,41.63 103.06,41.28 103.24,41.28 103.53,40.99 103.53,40.5 103.88,40.16 104.28,40.16 104.66,39.78 104.66,39.63 104.94,39.36 105.19,39.36 105.77,38.77
  IN1 w0.147: v1(142.45,36.89) 141.75,37.58 139.36,37.58 137.87,36.09 134.99,36.09 134.34,35.43 123.03,35.43 122.88,35.29 122.88,34.82 122.73,34.67 122.44,34.67 122.29,34.82 122.29,35.29 122.14,35.43 121.85,35.43 121.7,35.29 121.7,34.82 121.56,34.67 121.26,34.67 121.11,34.82 121.11,35.29 120.97,35.43 120.67,35.43 120.52,35.29 120.52,34.82 120.37,34.67 113.26,34.67 112.5,35.43 109.41,35.43 107.92,36.92 107.63,36.92 105.77,38.77
  BOTTOM w0.14: JDIMM2.163 144.79,39.55 144.48,39.24 144.48,38.8 143.74,38.05 142.57,38.05 142.45,37.93 v1(142.45,36.89)
DDR_A_D53: length 57.6
  TOP w0.102: v1(102.12,43.75) JCPU1.E5
  TOP w0.14: JDIMM1.166 144.95,38.65 143.72,37.42 v1(143.72,36.88)
  IN1 w0.089: 106.63,38.77 105.23,40.17 104.54,40.17 104.36,40.35 103.96,40.35 103.72,40.58 103.72,41.22 103.56,41.38 103.56,41.89 103.15,42.3 102.95,42.3 102.63,42.62 102.63,43.24 v1(102.12,43.75)
  IN1 w0.147: 106.63,38.77 109.58,35.82 112.66,35.82 113.42,35.06 117.6,35.06 117.78,35.24 117.78,35.68 117.93,35.82 118.22,35.82 118.37,35.68 118.37,35.24 118.51,35.09 118.81,35.09 118.96,35.24 118.96,35.68 119.1,35.82 119.4,35.82 119.55,35.68 119.55,35.24 119.69,35.09 119.99,35.09 120.14,35.24 120.14,35.68 120.28,35.82 134.18,35.82 134.83,36.48 137.71,36.48 139.2,37.97 142.63,37.97 v1(143.72,36.88)
  BOTTOM w0.14: JDIMM2.165 145.03,38.95 144.48,38.41 144.48,38.24 143.72,37.47 v1(143.72,36.88)
DDR_A_D54: length 58.7
  TOP w0.102: v1(101.12,40.75) JCPU1.B6
  TOP w0.14: JDIMM1.174 144.91,36.25 142.54,33.88 v1(142.54,33.81)
  IN1 w0.089: 102.41,38.77 101.63,39.54 101.63,39.96 101.12,40.48 v1(101.12,40.75)
  IN1 w0.147: v1(142.54,33.81) 142.54,34.34 142.41,34.47 139.54,34.47 138.16,33.09 136.99,33.09 136.85,32.94 136.85,32.71 136.7,32.56 136.41,32.56 136.26,32.71 136.26,32.94 136.11,33.09 134.37,33.09 132.99,31.7 120.93,31.7 120.78,31.85 120.78,32.22 120.66,32.34 120.32,32.34 120.19,32.22 120.19,31.85 120.05,31.7 119.75,31.7 119.6,31.85 119.6,32.22 119.48,32.34 112.3,32.34 111.53,33.11 108.29,33.11 106.93,34.47 106.71,34.47 102.41,38.77
  BOTTOM w0.14: v1(142.54,33.81) 142.69,33.81 143.12,34.25 143.67,34.25 144.2,34.78 144.2,35.47 144.69,35.95 JDIMM2.175
DDR_A_D55: length 56.8
  TOP w0.102: v1(101.12,39.75) JCPU1.A6
  TOP w0.14: JDIMM1.177 138.58,35.35 139.49,34.44 v1(139.49,33.81)
  IN1 w0.147: v1(101.12,39.75) 101.12,39.51 106.54,34.08 106.77,34.08 108.13,32.72 110.14,32.72 110.28,32.57 110.28,32.29 110.41,32.17 110.75,32.17 110.87,32.29 110.87,32.57 111.02,32.72 111.37,32.72 111.77,32.32 111.77,31.46 111.92,31.32 112.21,31.32 112.36,31.46 112.36,31.81 112.51,31.95 112.8,31.95 112.95,31.81 112.95,31.46 113.1,31.32 113.39,31.32 113.54,31.46 113.54,31.81 113.69,31.95 113.98,31.95 114.13,31.81 114.13,31.46 114.27,31.32 114.57,31.32 114.72,31.46 114.72,31.81 114.86,31.95 115.16,31.95 115.31,31.81 115.31,31.46 115.45,31.32 115.75,31.32 115.9,31.46 115.9,31.81 116.04,31.95 116.34,31.95 116.48,31.81 116.48,31.46 116.63,31.32 116.93,31.32 117.07,31.46 117.07,31.81 117.22,31.95 117.52,31.95 117.66,31.81 117.66,31.46 117.81,31.32 118.11,31.32 118.25,31.46 118.25,31.81 118.4,31.95 118.69,31.95 118.84,31.81 118.84,31.46 118.99,31.32 133.15,31.32 134.01,32.17 137.85,32.17 v1(139.49,33.81)
  BOTTOM w0.14: v1(139.49,33.81) 139.49,34.83 138.66,35.65 JDIMM2.176
