# Allegro board LA-9771PR10-0624.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TMDSE_RP_CLK: length 5.8
  TOP w0.102: R451.1 19.29,163.22 L19.4 19.29,162.59 19.44,162.44 19.44,162.22 19.38,162.15 19.22,162.15 19.2,162.13 19.18,162.13 18.77,161.71 18.77,161.69 17.64,160.57 17.64,159.6 17.9,159.33 U9.16
TMDSE_RP_CLK#: length 5.8
  TOP w0.102: R452.1 20.14,163.22 L19.1 20.14,162.56 20,162.42 19.74,162.42 19.66,162.33 19.66,162.13 19.47,161.94 19.31,161.94 v3(19.13,161.76) 17.85,160.48 17.85,159.69 17.99,159.55 18.1,159.55 18.11,159.56 18.29,159.74 U9.15
TMDSE_RP_N0: length 5.5
  TOP w0.102: U9.18 18.3,158.54 18.12,158.35 17.74,158.35 v3(17.34,158.75) 16.91,159.18 16.91,160.21 16.93,160.22 16.93,160.75 16.91,160.77 16.91,161.14 17,161.22 17.28,161.22 17.4,161.34 L23.1 17.36,161.68 R454.1
TMDSE_RP_N1: length 7.2
  TOP w0.102: U9.21 18.25,157.33 18.06,157.15 17.47,157.15 v3(15.76,158.86) 14.96,159.67 14.96,159.93 14.97,159.94 14.97,160.47 14.96,160.49 14.96,161.06 15.07,161.17 15.3,161.17 15.44,161.32 L24.1
TMDSE_RP_N2: length 21.8
  TOP w0.102: U9.24 18.29,156.14 18.1,155.95 17.59,155.95 17.22,156.32 14.74,156.32 13.14,154.72 13.13,154.72 13.11,154.73 12.58,154.73 12.57,154.72 10.88,154.72 8.86,156.74 v3(8.86,158.47) 8.86,161.33 8.07,162.11 8.07,163.92 8.38,164.23 8.8,164.23 8.95,164.08 8.95,163.56 9.07,163.44 L25.1 9.94,163.44 R458.1
TMDSE_RP_P0: length 5.5
  TOP w0.102: U9.19 17.65,158.14 17.39,158.39 17.38,158.39 16.99,158.78 16.99,158.8 16.7,159.09 v3(16.7,160.49) 16.7,161.22 16.55,161.36 L23.4 16.55,161.92 R453.1
TMDSE_RP_P1: length 7.2
  TOP w0.102: L24.4 14.6,161.29 14.74,161.15 v3(14.74,160.21) 14.74,159.58 15.4,158.92 15.4,158.9 15.79,158.51 15.81,158.51 17.38,156.93 U9.22
TMDSE_RP_P2: length 21.9
  TOP w0.102: R459.1 9.94,164.29 L25.4 9.05,164.29 8.89,164.45 8.3,164.45 7.86,164.01 7.86,162.02 8.64,161.24 8.64,158.75 8.63,158.74 8.63,158.2 8.64,158.19 8.64,156.65 10.79,154.51 v3(12.85,154.51) 13.23,154.51 14.83,156.11 17.13,156.11 17.5,155.74 U9.25
TOUCH_SCREEN_PD#: length 8.5
  IN4 w0.109: v1(221.83,83.7) 221.95,83.58 224.49,83.58 225.05,84.14 226.02,84.14 226.25,84.36 228.23,84.36 v1(228.48,84.11)
  BOTTOM w0.102: v1(221.83,83.7) 221.9,83.77 U46.B55 ; T155.1 228.2,83.83 v1(228.48,84.11)
TP_LAN_JTAG_TCK: length 2.5
  BOTTOM w0.102: U31.35 120.54,147.23 119.45,146.15 T172.1
TP_LAN_JTAG_TDI: length 3.8
  BOTTOM w0.102: T142.1 120.75,145.6 121.5,146.35 121.5,147.41 121.74,147.65 U31.32
TP_LAN_JTAG_TDO: length 1.5
  BOTTOM w0.102: T143.1 120.94,147.11 U31.34
TP_LAN_JTAG_TMS: length 4.1
  BOTTOM w0.102: U31.33 121.34,147.63 121.19,147.48 121.19,146.78 119.44,145.03 T171.1
TP_VSS_NCTF: length 5.9
  TOP w0.102: RH219.2 46.72,88.4 44.99,88.4 43.87,89.52 43.87,90.76 43.26,91.38 UH1.BE5
TPM_ID0: length 10.7
  TOP w0.102: UH1.AT7 39.3,92.31 39.54,92.56 39.59,92.56 39.59,92.56 v1(39.6,92.56)
  BOTTOM w0.102: v1(39.6,92.56) 39.49,92.56 39.19,92.26 v2(39.19,92.21) 39.19,90.88 38.97,90.66 38.97,88.85 39.6,88.22 40.45,88.22 42.43,86.24 42.99,86.24 43.47,85.76 RPH10.6
TPM_ID1: length 7
  TOP w0.102: UH1.AM3 37.5,90.59 37.5,90.13 37.48,90.1 37.29,89.92 37.29,89.66 37.58,89.37 37.58,88.56 38.38,87.76 38.38,86.6 38.72,86.25 39.07,86.25 v2(39.29,86.03) 39.79,85.53 RH200.2
TRIP_+1.05VSP: length 2.5
  TOP w0.254: PR302.2 21.37,147.36 20.86,147.86 v1(20.86,147.99)
  BOTTOM w0.102: v1(20.86,147.99) 20.43,147.99 v2(20.24,148.18)
  BOTTOM w0.254: v1(20.86,147.99) 20.98,147.87 PU300.2
UG_3V: length 10.8
  IN4 w0.762: v3(253.15,48.19) v3(253.15,49.11) 250.22,52.03 250.22,56.68 249.44,57.47
  vias: v3(248.46,58.16) v3(249.09,58.16)
UG_5V: length 10.2
  IN4 w0.762: 242.65,49.72 241.72,50.66 241.72,57.31 242.65,58.25 243.49,58.25
  vias: v3(243.39,49.44) v3(243.39,48.73) v3(244.26,58.16) v3(244.89,58.16)
UG_+1.05VSP: length 8.7
  TOP w0.102: v3(20.1,143.42) 20.1,142.99 v2(20.75,142.34)
  IN1 w0.762: 19.26,135.48 19.27,135.49 19.27,142.59 19.47,142.78
  vias: v3(19.27,134.72) v3(19.26,134.08) v3(20.74,143.42)
UGATE1: length 33
  TOP w0.762: 41.94,55.54 42.45,56.04 PQ504.2
  TOP w1.016: v3(43.93,49.57) v3(43.93,50.71) 41.69,52.94 v2(41.69,54.07) 41.69,55.28 41.94,55.54
  IN1 w1.016: 54.52,30.39 54.52,31.66 50.15,36.03 50.15,43.34 v3(43.93,49.57) v3(43.93,50.71)
  vias: v3(53.78,29.88) v3(53.78,29.25)
UGATE2: length 17.3
  TOP w0.762: PQ502.2 v3(43.62,41.29)
  IN4 w0.762: v3(43.62,41.29) v3(43.62,40.42) 43.62,37.98 44.1,37.5 46.39,37.5 47.41,36.49 47.41,29.5 48.55,28.36
  vias: v2(43.1,40.8) v3(49.44,27.98) v3(49.95,27.47)
UGATE3: length 5.3
  TOP w0.635: PQ500.2 42.71,70.95 v3(42.25,71.41)
  IN4 w0.762: v3(42.25,71.41) 42.25,72.15 41.21,73.19 39.91,73.19
  BOTTOM w0.102: v2(42.36,70.69) 42.25,70.8 v3(42.25,71.41)
  vias: v3(38.9,73.19) v3(38.9,72.53)
UIM_CLK: length 82.5
  TOP w0.102: v1(254.26,84.97) 253.25,83.96 253.25,82.43 254.85,80.84 254.85,73.79 260.36,68.27 260.36,67 269.45,57.9 269.45,45.58 263.15,39.28 259.62,39.28 258.43,38.09 252.65,38.09 251.63,37.07 244.51,37.07 v1(244.1,37.48)
  BOTTOM w0.102: JMINI2.12 253.49,84.2 v1(254.26,84.97) ; v1(244.1,37.48) 244.1,36.43 C628.1 244.19,35.45 v2(244.19,34.77) 244.19,34.67 JSIM1.3
UIM_DATA: length 79.4
  TOP w0.102: v1(246.13,37.48) 249.33,37.48 251.36,39.51 263.03,39.51 269.22,45.71 269.22,57.81 260.13,66.9 260.13,68.18 254.62,73.69 254.62,80.74 253.02,82.34 253.02,84.35 v1(253.68,85)
  BOTTOM w0.102: v1(253.68,85) JMINI2.10 ; JSIM1.7 244.89,34.05 244.89,35.26 C631.1 246.13,36.51 v1(246.13,37.48) v2(246.68,37.48)
UIM_RESET: length 83.7
  TOP w0.102: v1(254.32,82.6) 255.47,81.45 255.47,73.81 260.82,68.46 260.82,67.19 269.91,58.09 269.91,44.21 264.5,38.8 262.41,38.8 261.24,37.63 252.84,37.63 251.82,36.61 242.48,36.61 v1(241.61,37.48)
  BOTTOM w0.102: JSIM1.2 242.79,34.24 v2(242.79,34.67) 242.79,35.34 C629.1 241.61,36.51 v1(241.61,37.48) ; v1(254.32,82.6) 253.52,83.4 JMINI2.14
UIM_VPP: length 80.9
  TOP w0.102: v1(242.88,37.48) 243.52,36.84 251.73,36.84 252.75,37.86 261.15,37.86 262.31,39.03 263.23,39.03 269.68,45.48 269.68,58 260.59,67.09 260.59,68.37 255.08,73.88 255.08,81.21 v1(253.68,82.6)
  BOTTOM w0.102: v2(242.88,38.14) v1(242.88,37.48) 242.88,36.51 C630.1 243.49,35.89 243.49,34.8 JSIM1.6 ; JMINI2.16 v1(253.68,82.6)
USB3_A_DE0: length 2.4
  BOTTOM w0.102: U638.29 227.42,86.01 226.85,86.58 226.85,86.78 R23.2
USB3_A_DE1: length 2.1
  BOTTOM w0.102: U638.28 227.31,85.61 226.46,86.46 R25.2
USB3_A_EQ0: length 3.8
  BOTTOM w0.102: U638.32 227.67,87.21 227.54,87.34 227.54,88.76 v2(227.26,89.04) R24.2
USB3_A_EQ1: length 3.3
  BOTTOM w0.102: U638.31 227.59,86.81 227.31,87.09 227.31,88.1 R22.2
USB3_B_DE0: length 14.9
  IN3 w0.127: v1(234.36,84.92) 234.48,84.81 234.48,77.57 233.71,76.81 233.71,76.31 v1(233.27,75.86)
  BOTTOM w0.102: U638.15 234.54,86.01 234.84,85.71 234.84,85.4 v1(234.36,84.92) ; v2(233.68,75.28) 233.27,75.69 v1(233.27,75.86) 232.85,76.28 232.85,77.61 R28.2
USB3_B_DE1: length 14.8
  IN3 w0.127: v1(233.64,84.93) 233.64,80.99 231.94,79.28 231.94,76.31 v1(232.39,75.86)
  BOTTOM w0.102: v1(233.64,84.93) 234.05,85.34 U638.16 ; v1(232.39,75.86) 231.86,76.39 231.86,77.59 232.34,78.07 R30.2 232.38,78.55 v2(231.77,79.16)
USB3_B_EQ0: length 19.3
  IN3 w0.127: v1(234.86,87.74) 235.31,87.29 236.25,87.29 237.09,86.45 237.09,82.76 236.13,81.8 236.13,76.71 v1(235.28,75.86)
  BOTTOM w0.102: R18.2 235.7,77.63 235.7,76.28 v1(235.28,75.86) v2(236.28,75.86) ; U638.13 234.53,86.81 234.86,87.13 v1(234.86,87.74)
USB3_B_EQ1: length 18.1
  IN3 w0.127: v1(234.91,86.45) 235.14,86.68 236.33,86.68 236.77,86.24 236.77,83.03 235.77,82.03 235.77,78.22 234.78,77.23 234.78,76.32 v1(234.34,75.88)
  BOTTOM w0.102: v2(234.59,79.08) 234.35,78.84 R27.2 233.87,77.61 233.87,76.35 v1(234.34,75.88) ; v1(234.91,86.45) 234.87,86.41 U638.14
USB3_RX1_N_D-: length 8.6
  TOP w0.102: JUSB1.5 262.9,116.6 262.66,116.36 262.41,116.36 261.6,115.55 261.6,114.77 260.85,114.02 259.81,114.02 259.7,114.13 D14.5 D14.6 258.17,114.13 258.03,113.99 257.82,113.99 257.67,114.14 257.38,114.14 257.04,114.48 L40.1
USB3_RX1_P_D+: length 8.6
  TOP w0.102: L40.4 257.09,113.63 257.38,113.92 257.58,113.92 257.73,113.77 258.05,113.77 258.19,113.63 D14.7 D14.4 259.64,113.63 259.81,113.8 260.94,113.8 261.82,114.68 261.82,115.46 262.5,116.14 262.67,116.14 262.9,115.91 JUSB1.6
USB3_RX2_N_D-: length 15.2
  TOP w0.102: L43.1 257.82,126.84 258.14,127.16 258.14,127.41 258.32,127.59 258.32,127.77 258.18,127.91 D16.6 D16.5 258.18,129.81 258.32,129.95 v3(258.32,130.86) 258.32,133.16 258.31,133.17 258.31,133.7 258.32,133.72 258.32,134.37 262.31,138.36 262.8,138.36 262.9,138.47 JUSB2.5
USB3_RX2_P_D+: length 15.2
  TOP w0.102: JUSB2.6 262.9,138.01 262.76,138.15 262.4,138.15 258.54,134.28 v3(258.54,133.44) 258.54,131.15 258.56,131.13 258.56,130.57 258.54,130.55 258.54,129.98 258.68,129.83 D16.4 D16.7 258.68,127.87 258.54,127.73 258.54,127.5 258.36,127.32 258.36,127.16 258.67,126.84 L43.4
USB3_TEST: length 13.1
  IN3 w0.127: v1(231.44,75.84) 230.95,76.33 230.95,83.79 231.05,83.89 v1(231.05,83.93)
  BOTTOM w0.102: R26.2 230.84,77.63 230.84,76.82 230.95,76.72 230.95,76.33 v1(231.44,75.84) 231.44,75.52 231.22,75.31 v2(231.22,74.86) ; 231.05,84.9 v1(231.05,83.93)
USB3_TX1_N_D-: length 8.9
  TOP w0.102: L42.1 257.04,112.7 257.36,112.39 257.52,112.39 257.63,112.49 258.01,112.49 258.14,112.63 D14.8 D14.2 259.68,112.63 259.81,112.49 261.1,112.49 261.49,112.1 261.49,110.67 261.8,110.36 262.63,110.36 262.9,110.63 JUSB1.8
USB3_TX1_P_D+: length 8.9
  TOP w0.102: JUSB1.9 262.9,109.86 262.62,110.14 261.71,110.14 261.27,110.58 261.27,112.01 261.01,112.28 259.81,112.28 259.66,112.13 D14.1 D14.9 258.15,112.13 258,112.28 257.72,112.28 257.61,112.17 257.35,112.17 257.03,111.85 L42.4
USB3_TX2_N_D-: length 9
  TOP w0.102: JUSB2.8 262.9,132.5 262.75,132.34 261.55,132.34 259.83,130.62 259.83,129.96 259.68,129.81 D16.2 D16.8 259.68,127.87 259.81,127.73 259.81,127.48 260.01,127.27 260.01,127.11 259.73,126.83 L44.1
USB3_TX2_P_D+: length 9
  TOP w0.102: L44.4 260.58,126.83 260.23,127.18 260.23,127.36 260.03,127.57 260.03,127.71 260.18,127.86 D16.9 D16.1 260.18,129.81 260.04,129.94 260.04,130.53 261.64,132.13 262.71,132.13 262.9,131.94 JUSB2.9
USB3RN1: length 229.4
  TOP w0.102: UH1.AR26 38.93,100.56 v1(39.2,100.83)
  IN4 w0.089: v1(39.2,100.83) 38.76,100.39 38.39,100.39 38.31,100.31 38.31,99.47 38.44,99.35 38.68,99.35 38.71,99.38 38.73,99.38
  IN4 w0.117: 38.73,99.38 41.33,99.38 43.77,96.94 47.11,96.94 47.46,97.29 48.78,97.29 51.9,100.42 51.9,101.21 52.36,101.67 56.19,101.67 56.85,101.01 59.89,101.01 60.25,101.36 67.22,101.36 67.91,102.05 71.84,102.05 72.85,103.06 83.45,103.06 84.31,102.19 109.97,102.19 110.19,101.98 117.27,101.98 118.9,100.35 133.13,100.35 134.55,98.93 150.07,98.93 151.92,100.77 159.44,100.77 161.6,98.62 175.77,98.62 182.21,92.18 182.21,88.37 183.35,87.23 184.59,87.23 188.34,83.48 194.65,83.48 199.99,78.14 199.99,76.96 209.12,67.83 212.61,67.83 212.97,67.47 213.43,67.47 214.11,66.79 220.61,66.79 221.8,67.98 225.68,67.98 228.04,70.34 228.04,71.2 229.75,72.91 229.75,73.4 230.07,73.72 230.07,74.05 229.95,74.16 229.95,74.56 230.07,74.67 230.07,75.02 229.95,75.13 229.95,75.53 230.07,75.64 230.07,75.92 229.67,76.32 v1(229.67,76.32)
  BOTTOM w0.102: v1(229.67,76.32) 229.88,76.53 v3(229.88,78.01) 229.88,78.75 230.56,79.44 230.56,79.91 C487.2
USB3RN1_C: length 4
  BOTTOM w0.102: U638.24 230.25,84.41 230.34,84.31 230.34,83.75 230.33,83.74 230.33,83.21 230.34,83.2 230.34,82.95 230.58,82.71 v3(230.58,82.13) 230.58,81.51 C487.1
USB3RN1_RP: length 48.8
  TOP w0.102: L40.2 253.81,114.48 253.49,114.16 v3(253.49,113.78) 253.49,113.2 252.47,112.19 252.47,111.67 252.46,111.66 252.46,111.12 252.47,111.11 252.47,109.19 253.16,108.5 253.16,107.34 253.74,106.75 254.14,106.75 v1(254.32,106.58)
  IN3 w0.127: v1(254.32,106.58) 254.32,106.62 254.52,106.82 254.88,106.82 255,106.69 255,106.18 254.6,105.78 254.45,105.78 254.15,105.49 254.15,105.33 253.79,104.96 253.79,104.67 253.68,104.57 253.68,104.14 253.79,104.03 253.79,99.33 248.23,93.77 236.8,93.77 233.64,90.61 232.95,90.61 232.65,90.3 231.38,90.3 230.51,89.44 230.51,89.11 230.15,88.75 v1(230.12,88.75)
  BOTTOM w0.102: v1(230.12,88.75) 230.33,88.54 230.33,88.41 230.25,88.32 U638.4
USB3RN2: length 225.5
  TOP w0.102: v1(41.14,100.85) 40.72,100.44 UH1.AW26
  IN4 w0.089: v1(41.14,100.85) 41.09,100.85 40.88,100.65 40.88,100.52 40.95,100.44 41.48,100.44 42.04,99.89 42.08,99.89 42.09,99.88
  IN4 w0.117: v1(232.77,79.44) 232.77,79.39 232.53,79.14 232.02,79.14 231.5,78.62 231.35,78.62 231.08,78.35 231.08,78.19 230.83,77.95 230.67,77.95 230.4,77.67 230.4,77.52 230.09,77.21 229.51,77.21 228.93,76.63 228.93,73.16 226.83,71.06 226.33,71.06 224.03,68.77 220.94,68.77 219.69,67.52 214.52,67.52 213.47,68.57 209.42,68.57 201.18,76.81 201.18,78.25 195.2,84.22 189.05,84.22 185.36,87.91 185.36,90.33 175.44,100.25 162.21,100.25 160.94,101.51 150.14,101.51 149.56,100.93 138.56,100.93 138.01,101.48 132.25,101.48 131.91,101.82 127.98,101.82 127.32,101.16 121.67,101.16 121.01,101.82 118.53,101.82 117.64,102.71 110.64,102.71 109.91,103.44 89.18,103.44 88.86,103.12 85.04,103.12 83.92,104.23 77.34,104.23 77.04,104.54 76.49,104.54 76.11,104.16 72.22,104.16 71.11,103.04 67.02,103.04 66.18,102.2 62.16,102.2 61.94,102.42 52.07,102.42 51.03,101.38 51.03,100.59 48.48,98.04 43.93,98.04 42.09,99.88
  BOTTOM w0.102: C490.2 233.24,80.24 233.42,80.06 233.42,79.4 233.18,79.16 232.98,79.16 232.77,79.36 v1(232.77,79.44)
USB3RN2_C: length 4.2
  BOTTOM w0.102: U638.18 232.65,84.43 232.74,84.34 232.74,84.04 232.94,83.84 232.94,83.83 233.36,83.4 v3(233.36,82.43) 233.36,81.5 C490.1
USB3RN2_RP: length 56.1
  TOP w0.102: v1(257.93,121.8) 258.14,122.01 258.14,122.64 258.13,122.66 258.13,123.19 258.14,123.2 258.14,124.13 257.82,124.45 L43.2
  IN3 w0.127: v1(257.93,121.8) 257.97,121.8 258.15,121.62 258.15,119.44 255.77,117.06 255.77,104.69 254.95,103.87 254.95,97.32 250.01,92.38 236.75,92.38 234.22,89.85 233.28,89.85 232.96,89.53 232.96,89.24 v1(232.81,89.08)
  BOTTOM w0.102: U638.10 232.65,88.28 232.75,88.39 232.75,88.53 232.99,88.76 232.99,88.9 v1(232.81,89.08)
USB3RN3: length 124.1
  TOP w0.102: UH1.AW31 40.72,102.62 v1(40.48,102.86)
  IN3 w0.089: v1(40.48,102.86) 40.6,102.86 40.78,103.03 40.78,103.24 40.95,103.41 42.06,103.41 42.1,103.45 42.12,103.45
  IN3 w0.127: 42.12,103.45 43.44,103.45 43.96,102.93 49.23,102.93 51.24,104.94 64.35,104.94 65.57,106.16 65.57,112.36 64.81,113.12 64.81,132.78 58.53,139.06 58.53,143.2 60.52,145.19 64.98,145.19 65.77,145.98 70.37,145.98 72.5,148.12 78.72,148.12 81.87,144.97 83.09,144.97 87.65,140.41 87.65,137.97 88.66,136.96 88.66,128.68 92.99,124.34 94.69,124.34 94.84,124.5 94.84,124.68 v1(94.65,124.88)
  BOTTOM w0.102: v1(94.65,124.88) 94.84,125.07 94.84,125.27 94.7,125.41 JDOCK1.84
USB3RN5: length 43.7
  TOP w0.102: JIO1.45 8.72,97.8 8.9,97.62 11.13,97.62 v1(11.34,97.83) ; v1(40.54,101.85) 40.47,101.78 40.47,101.61 UH1.AW29
  IN3 w0.089: v1(40.54,101.85) 40.35,101.85 40.16,101.66 40.16,101.51 40.24,101.43 41.23,101.43 41.26,101.47 41.28,101.47
  IN3 w0.127: v1(11.34,97.83) 11.13,97.62 10.98,97.62 10.83,97.77 10.83,98.26 10.98,98.42 12.15,98.42 13.17,99.43 17.18,99.43 17.36,99.25 23.2,99.25 23.45,99 23.45,98.77 24.09,98.13 24.54,98.13 24.8,97.87 26.54,97.87 26.68,97.73 30.01,97.73 30.59,98.31 32.75,98.31 33.79,99.35 36.59,99.35 36.81,99.13 41.41,99.13 42.64,100.35 42.64,100.89 42.06,101.47 41.28,101.47
USB3RN6: length 41.6
  TOP w0.102: v1(38.58,101.85) 38.93,101.5 UH1.AR29 ; JIO1.57 8.74,94.2 8.93,94.01 9.12,94.01 v1(9.31,94.19)
  IN3 w0.089: v1(38.58,101.85) 38.52,101.85 38.16,101.48 38.16,101.31 38,101.14 37.7,101.14 37.66,101.11 37.65,101.11
  IN3 w0.127: 37.65,101.11 37.35,101.11 37.22,100.98 36.84,100.98 36.71,101.11 36.33,101.11 36.2,100.98 35.82,100.98 35.68,101.11 32.42,101.11 32.06,100.75 32.06,100.57 31.43,99.94 30.64,99.94 29.85,99.15 26.63,99.15 26.28,99.5 25.41,99.5 24.39,100.52 24.39,100.75 23.89,101.26 21.83,101.26 21.78,101.2 18.5,101.2 18.43,101.28 12.15,101.28 10.83,99.96 10.83,99.35 10.07,98.59 10.07,97.44 10.57,96.94 10.57,95.67 10.14,95.24 9.15,95.24 8.75,94.83 8.75,94.06 8.85,93.96 9.07,93.96 v1(9.31,94.19)
USB3RP1: length 229.4
  TOP w0.102: v1(38.58,100.83) 38.57,100.83 38.34,100.59 UH1.AP26
  IN4 w0.089: 38.73,99.14 38.71,99.14 38.68,99.17 38.36,99.17 38.13,99.4 38.13,100.39 38.32,100.57 38.49,100.57 38.58,100.66 v1(38.58,100.83)
  IN4 w0.117: 38.73,99.14 41.24,99.14 43.67,96.71 47.21,96.71 47.55,97.06 48.87,97.06 52.14,100.32 52.14,101.11 52.46,101.43 56.09,101.43 56.75,100.77 59.99,100.77 60.35,101.13 67.32,101.13 68.01,101.81 71.94,101.81 72.95,102.82 83.35,102.82 84.21,101.96 109.87,101.96 110.09,101.74 117.17,101.74 118.8,100.11 133.03,100.11 134.45,98.69 150.17,98.69 152.02,100.54 159.35,100.54 161.5,98.38 175.68,98.38 181.97,92.09 181.97,88.28 183.25,87 184.49,87 188.24,83.25 194.55,83.25 199.75,78.04 199.75,76.86 209.02,67.59 212.51,67.59 212.87,67.23 213.33,67.23 214.01,66.55 220.71,66.55 221.9,67.74 225.78,67.74 228.28,70.24 228.28,71.11 229.99,72.81 229.99,73.31 230.3,73.62 v5(230.3,76.32)
  BOTTOM w0.102: v5(230.3,76.32) 230.09,76.53 230.09,77.74 230.1,77.75 230.1,78.28 230.09,78.29 230.09,78.66 230.77,79.35 230.77,79.91 C465.2
USB3RP1_C: length 4
  BOTTOM w0.102: U638.23 230.65,84.41 230.55,84.31 v3(230.55,83.48) 230.55,83.04 230.79,82.8 230.79,82.41 230.81,82.39 230.81,81.86 230.79,81.85 230.79,81.47 C465.1
USB3RP1_RP: length 48.8
  TOP w0.102: v1(254.32,107.25) 254.32,107.08 254.21,106.97 253.83,106.97 253.37,107.43 253.37,108.59 252.69,109.28 v3(252.69,111.39) 252.69,112.1 253.69,113.1 253.69,113.3 253.71,113.32 253.71,114.04 253.7,114.06 253.7,114.07 253.9,114.27 254.33,114.27 254.39,114.21 254.39,113.7 254.46,113.63 L40.3
  IN3 w0.127: v1(230.76,88.75) 230.76,89.33 231.48,90.05 232.75,90.05 233.05,90.36 233.74,90.36 236.91,93.53 248.34,93.53 254.03,99.22 254.03,104.86 255.25,106.08 255.25,106.8 254.98,107.07 254.51,107.07 v1(254.32,107.25)
  BOTTOM w0.102: v1(230.76,88.75) 230.55,88.54 230.55,88.41 230.65,88.32 U638.5
USB3RP2: length 225.5
  TOP w0.102: v1(40.48,100.85) 40.13,100.5 UH1.AV26
  IN4 w0.089: v1(40.48,100.85) 40.7,100.64 40.7,100.44 40.88,100.26 41.41,100.26 41.92,99.76 41.92,99.72 41.92,99.71
  IN4 w0.117: v1(232.77,78.8) 232.67,78.9 232.12,78.9 230.19,76.97 229.6,76.97 229.17,76.54 229.17,73.06 226.93,70.83 226.42,70.83 224.13,68.53 221.04,68.53 219.79,67.29 214.42,67.29 213.38,68.33 209.32,68.33 200.94,76.71 200.94,78.15 195.11,83.98 188.96,83.98 185.12,87.81 185.12,90.23 175.34,100.01 162.11,100.01 160.84,101.27 150.24,101.27 149.66,100.7 138.46,100.7 137.91,101.25 132.15,101.25 131.81,101.59 128.08,101.59 127.42,100.92 121.57,100.92 120.91,101.59 118.44,101.59 117.55,102.47 110.54,102.47 109.81,103.2 89.28,103.2 88.96,102.88 84.94,102.88 83.82,104 77.25,104 76.94,104.3 76.59,104.3 76.21,103.92 72.32,103.92 71.2,102.8 67.12,102.8 66.28,101.97 62.06,101.97 61.84,102.19 52.17,102.19 51.27,101.28 51.27,100.49 48.57,97.8 43.83,97.8 41.92,99.71
  BOTTOM w0.102: C491.2 233.64,79.98 233.64,79.31 233.27,78.94 232.91,78.94 v1(232.77,78.8)
USB3RP2_C: length 4.2
  BOTTOM w0.102: U638.17 233.05,84.41 232.96,84.32 232.96,84.13 v3(233.38,83.71) 233.58,83.51 233.58,82.72 233.59,82.71 233.59,82.16 233.58,82.14 233.58,81.48 C491.1
USB3RP2_RP: length 56.1
  TOP w0.102: L43.3 258.67,124.44 258.36,124.12 258.36,122.01 v1(258.57,121.8)
  IN3 w0.127: v1(258.57,121.8) 258.4,121.64 258.4,119.34 256.02,116.95 256.02,104.58 255.2,103.77 255.2,97.21 250.11,92.13 236.86,92.13 234.32,89.6 233.38,89.6 233.21,89.42 233.21,89.32 v1(233.44,89.08)
  BOTTOM w0.102: v1(233.44,89.08) 233.21,88.85 233.21,88.67 232.97,88.44 232.97,88.38 233.05,88.3 U638.11
USB3RP3: length 124.1
  TOP w0.102: v1(41.13,102.86) 41.32,102.67 UH1.AY31
  IN3 w0.089: 42.12,103.2 42.11,103.2 42.08,103.24 41.03,103.24 40.95,103.16 40.95,103.04 v1(41.13,102.86)
  IN3 w0.127: v1(95.28,124.88) 95.09,124.68 95.09,124.39 94.79,124.09 92.89,124.09 88.41,128.57 88.41,136.86 87.4,137.87 87.4,140.31 82.99,144.72 81.77,144.72 78.62,147.87 72.61,147.87 70.47,145.74 65.87,145.74 65.08,144.94 60.63,144.94 58.78,143.1 58.78,139.16 65.06,132.88 65.06,113.22 65.81,112.46 65.81,106.05 64.45,104.69 51.34,104.69 49.34,102.68 43.86,102.68 43.34,103.2 42.12,103.2
  BOTTOM w0.102: JDOCK1.86 95.2,125.4 95.06,125.26 95.06,125.1 v1(95.28,124.88)
USB3RP5: length 43.8
  TOP w0.102: v1(39.83,101.85) 40.13,101.55 UH1.AV29 ; JIO1.47 8.68,97.2 8.89,97.41 11.12,97.41 v1(11.34,97.19)
  IN3 w0.089: 41.28,101.22 41.26,101.22 41.23,101.26 40.17,101.26 39.98,101.44 39.98,101.7 v1(39.83,101.85)
  IN3 w0.127: 41.28,101.22 41.95,101.22 42.39,100.79 42.39,100.45 41.31,99.38 36.91,99.38 36.69,99.6 33.68,99.6 32.65,98.56 30.49,98.56 29.9,97.98 26.78,97.98 26.64,98.12 24.91,98.12 24.64,98.38 24.19,98.38 23.7,98.87 23.7,99.1 23.31,99.5 17.46,99.5 17.28,99.68 13.06,99.68 12.05,98.66 10.88,98.66 10.58,98.36 10.58,97.67 10.87,97.37 11.15,97.37 v1(11.34,97.19)
USB3RP6: length 41.6
  TOP w0.102: v1(37.98,101.84) 38.34,101.48 UH1.AP29 ; JIO1.59 8.73,93.6 8.92,93.79 9.12,93.79 v1(9.31,93.61)
  IN3 w0.089: 37.65,101.36 37.66,101.36 37.7,101.32 37.92,101.32 37.98,101.38 v1(37.98,101.84)
  IN3 w0.127: 37.65,101.36 32.32,101.36 31.81,100.85 31.81,100.67 31.33,100.19 30.54,100.19 29.75,99.4 26.73,99.4 26.38,99.75 25.51,99.75 24.64,100.62 24.64,100.86 23.99,101.5 21.72,101.5 21.67,101.45 18.61,101.45 18.53,101.53 12.05,101.53 10.58,100.06 10.58,99.45 9.82,98.69 9.82,97.34 10.32,96.84 10.32,95.77 10.04,95.48 9.05,95.48 8.5,94.93 8.5,93.96 8.75,93.71 9.2,93.71 v1(9.31,93.61)
USB3TN1: length 218.1
  TOP w0.076: v1(44.4,99.3) 44.01,99.68 43.67,99.68 43.49,99.5 UH1.BE24
  IN4 w0.117: v1(44.4,99.3) 44.2,99.49 44.2,99.71 44.33,99.83 48.07,99.83 49.69,101.46 49.69,101.79 52.3,104.4 53.84,104.4 54.25,104 65.51,104 66.93,105.42 75.52,105.42 75.88,105.78 77.7,105.78 77.98,105.5 85.4,105.5 86.19,104.71 114.36,104.71 115.12,103.95 138.74,103.95 140.18,102.5 142.61,102.5 143.26,103.16 146.65,103.16 147.22,103.74 162.32,103.74 164.07,101.99 175.49,101.99 186.93,90.56 186.93,88.53 190,85.46 196.43,85.46 203.11,78.78 203.11,77.5 207.42,73.19 207.42,72.96 210.55,69.83 218.9,69.83 220.65,71.58 222.99,71.58 227.68,76.27 227.68,77.15 230.03,79.51 230.03,80.3 229.62,80.71 228.89,80.71 v1(228.79,80.81)
  BOTTOM w0.102: v1(228.79,80.81) 228.79,80.61 228.91,80.49 229.09,80.49 229.4,80.8 229.4,81.11 229.12,81.39 229.12,81.8 228.9,82.02 C452.2
USB3TN1_C: length 2.2
  BOTTOM w0.102: C452.1 229.02,83.25 229.02,83.78 229.13,83.89 229.13,84.31 229.05,84.4 U638.27
USB3TN1_RP: length 43.8
  TOP w0.102: v1(254.01,112.55) 254.19,112.36 254.31,112.36 254.65,112.7 L42.2
  IN3 w0.127: v1(228.11,92.01) 228.25,92.16 228.25,92.74 228.63,93.12 232.93,93.12 235.33,95.51 247.54,95.51 252.03,100.01 252.03,111.24 253.16,112.37 253.83,112.37 v1(254.01,112.55)
  BOTTOM w0.102: C488.1 228.33,91.33 228.33,91.79 v1(228.11,92.01)
USB3TN1_RP_C: length 2.7
  BOTTOM w0.102: C488.2 228.35,89.73 228.35,89.49 228.65,89.19 228.65,89.18 229.05,88.78 229.06,88.78 229.14,88.7 229.14,88.5 229.05,88.4 U638.1
USB3TN2: length 221.8
  TOP w0.076: UH1.BD25 42.84,99.85 42.95,99.85 43.08,99.97 43.35,99.97 43.42,100.05 43.65,100.05 43.68,100.07 43.7,100.07
  TOP w0.102: v1(46.25,99.3) 46.11,99.3 45.96,99.45 45.96,99.86 45.74,100.07 43.7,100.07
  IN4 w0.117: v1(231.76,80.81) 231.76,80.63 231.58,80.45 231.33,80.45 230.99,80.11 230.99,79.76 228.18,76.95 228.18,74.53 224.9,71.26 223.76,71.26 222.26,69.76 219.79,69.76 219.35,69.31 209.81,69.31 202.52,76.59 202.52,78.25 195.81,84.96 189.41,84.96 186.22,88.15 186.22,90.5 175.52,101.21 162.87,101.21 160.84,103.24 149.18,103.24 147.63,101.69 139.91,101.69 138.34,103.26 124.7,103.26 124.15,102.71 118.68,102.71 117.95,103.45 111.46,103.45 110.7,104.21 85.85,104.21 85.07,105 77.75,105 77.48,105.28 76.17,105.28 75.78,104.89 67.12,104.89 65.73,103.5 52.11,103.5 50.27,101.66 50.27,100.87 49.75,100.36 49.67,100.36 49.61,100.36 49.33,100.08 49.33,100.02 49.33,99.94 49.09,99.69 49,99.69 49,99.69 48.94,99.69 48.66,99.42 48.66,99.35 48.66,99.27 48.19,98.79 46.14,98.79 46.02,98.91 46.02,99.06 v1(46.25,99.3)
  BOTTOM w0.102: v1(231.76,80.81) 231.76,80.59 231.91,80.44 232.08,80.44 232.22,80.58 232.22,81.24 231.96,81.49 231.96,81.82 231.7,82.08 C456.2
USB3TN2_C: length 2.2
  BOTTOM w0.102: U638.21 231.45,84.4 231.54,84.3 231.54,83.75 231.87,83.42 231.87,83.31 C456.1
USB3TN2_RP: length 60.4
  TOP w0.102: L44.2 259.73,124.26 259.9,124.09 259.9,123.58 260.09,123.39 v3(260.33,123.39) 260.88,123.39 261.17,123.68 261.46,123.68 v1(261.55,123.59)
  IN3 w0.127: v1(231.41,91.87) 231.48,91.79 231.48,91.27 231.86,90.9 232.47,90.9 232.7,91.13 233.21,91.13 234.16,92.08 234.16,92.78 235.79,94.4 248,94.4 253.06,99.46 253.06,109.59 254.81,111.35 254.81,116.83 257.23,119.25 257.23,123.05 257.84,123.66 261.49,123.66 v1(261.55,123.59)
  BOTTOM w0.102: v1(231.41,91.87) 231.63,91.65 231.63,91.33 C492.1
USB3TN2_RP_C: length 2.4
  BOTTOM w0.102: C492.2 231.68,89.7 231.68,88.97 231.54,88.83 231.54,88.54 231.45,88.45 U638.7
USB3TN3: length 122.8
  TOP w0.102: v1(46.48,103.45) 46.48,103.9 46.35,104.02 45.93,104.02 45.8,103.9 45.8,103.74 46.01,103.54 46.01,103.29 46.14,103.16 46.14,103.03 46.06,102.95 43.74,102.95 43.45,102.66 43.34,102.66 UH1.BE32
  IN3 w0.127: v1(96.45,128.26) 96.63,128.08 96.63,127.82 96.51,127.7 95.46,127.7 90.19,132.97 90.19,136.55 88.5,138.24 88.5,141.97 83.7,146.77 82.76,146.77 82.61,146.61 81.65,146.61 79.11,149.15 77.91,149.15 77.5,149.57 72,149.57 69.18,146.75 65.26,146.75 64.47,145.95 60.12,145.95 57.77,143.61 57.77,138.74 64.05,132.47 64.05,112.53 64.81,111.77 64.81,106.49 64.02,105.69 50.3,105.69 49.15,104.55 47.06,104.55 46.69,104.18 46.69,103.66 v1(46.48,103.45)
  BOTTOM w0.102: v1(96.45,128.26) 96.62,128.09 96.62,127.89 96.34,127.61 96.34,127.33 96.2,127.19 JDOCK1.90
USB3TN5: length 60.3
  TOP w0.102: v1(46.99,101.34) 46.99,101.04 46.9,100.95 46.24,100.95 45.7,100.41 43.35,100.41 UH1.BE26 ; JIO1.51 8.72,96 8.91,95.81 9.04,95.81 9.13,95.9 9.13,96.18 9.37,96.42 9.62,96.42 v1(9.81,96.61)
  IN3 w0.127: v1(46.99,101.34) 47.18,101.15 47.33,101.15 48.95,99.53 48.95,99.05 48.53,98.62 44.28,98.62 42.34,96.67 36.52,96.67 34.81,94.96 30.08,94.96 29.88,94.76 25.82,94.76 23.83,92.77 22.92,92.77 22.84,92.85 15.13,92.85 14.89,92.62 12.76,92.62 11.09,90.95 10.01,90.95 7.74,93.23 7.74,95.26 8.9,96.42 9.63,96.42 v1(9.81,96.61)
USB3TN6: length 48.1
  TOP w0.076: UH1.BD27 42.87,100.8 44.6,100.8 45.03,101.24 v1(45.03,101.34)
  TOP w0.102: JIO1.63 8.73,92.4 8.92,92.21 9.89,92.21 9.93,92.17 10.33,92.17 v1(10.58,92.42)
  IN3 w0.127: v1(45.03,101.34) 44.9,101.34 44.73,101.17 44.73,100.8 41.65,97.71 37.41,97.71 37.38,97.75 33.66,97.75 33.18,97.27 33.18,97.11 32.72,96.66 26.5,96.66 26.35,96.82 24.37,96.82 23.83,97.35 22.81,97.35 21.67,98.49 16.69,98.49 16.37,98.16 14.2,98.16 10.8,94.77 10.8,93.91 10.28,93.39 10.15,93.39 9.89,93.13 9.89,92.51 10.27,92.14 10.47,92.14 10.58,92.24 v1(10.58,92.42)
USB3TP1: length 218.3
  TOP w0.076: v1(43.81,99.3) 43.73,99.21 43.21,99.21 43.09,99.08 43.09,98.96 42.91,98.78 42.77,98.78 42.68,98.87 42.68,99.01 42.76,99.1 UH1.BD23
  IN4 w0.117: v1(43.81,99.3) 43.97,99.45 43.97,99.8 44.23,100.07 47.97,100.07 49.45,101.56 49.45,101.89 52.21,104.64 53.94,104.64 54.34,104.23 65.41,104.23 66.84,105.66 75.42,105.66 75.78,106.01 77.8,106.01 78.08,105.73 85.5,105.73 86.28,104.95 114.45,104.95 115.22,104.18 138.84,104.18 140.28,102.74 142.51,102.74 143.17,103.4 146.55,103.4 147.13,103.97 162.42,103.97 164.17,102.23 175.59,102.23 187.16,90.66 187.16,88.63 190.1,85.69 196.52,85.69 203.34,78.87 203.34,77.6 207.65,73.29 207.65,73.05 210.64,70.06 218.8,70.06 220.56,71.82 222.89,71.82 227.44,76.36 227.44,77.25 229.79,79.61 229.79,80.2 229.53,80.47 229.03,80.47 228.79,80.22 v1(228.79,80.1)
  BOTTOM w0.102: v1(228.79,80.1) 228.96,80.27 229.18,80.27 229.61,80.71 229.61,81.2 229.33,81.48 229.33,81.76 229.59,82.01 C454.2
USB3TP1_C: length 2.2
  BOTTOM w0.102: C454.1 229.23,83.29 229.23,83.69 229.35,83.81 229.35,84.29 229.45,84.39 U638.26
USB3TP1_RP: length 43.4
  TOP w0.102: v1(254.01,111.96) 254.19,112.15 254.41,112.15 254.7,111.85 L42.3
  IN3 w0.127: v1(254.01,111.96) 253.85,112.12 253.26,112.12 252.28,111.14 252.28,99.91 247.64,95.26 235.43,95.26 233.04,92.87 228.73,92.87 228.5,92.64 228.5,92.19 228.68,92.01 v5(228.74,92.01)
  BOTTOM w0.102: v5(228.74,92.01) 228.55,91.81 228.55,91.34 C489.1
USB3TP1_RP_C: length 2.7
  BOTTOM w0.102: U638.2 229.45,88.38 229.36,88.47 229.36,88.79 v3(229.02,89.13) 228.57,89.58 228.57,89.77 C489.2
USB3TP2: length 221.9
  TOP w0.076: 43.7,99.86 43.68,99.86 43.65,99.88 43.49,99.88 43.42,99.81 43.14,99.81 42.89,99.55 42.4,99.55 UH1.BC24
  TOP w0.102: 43.7,99.86 45.65,99.86 45.74,99.77 45.74,99.45 v1(45.59,99.3)
  IN4 w0.117: v1(45.59,99.3) 45.78,99.11 45.78,98.82 46.04,98.56 48.29,98.56 50.5,100.77 50.5,101.56 52.21,103.26 65.82,103.26 67.22,104.66 75.88,104.66 76.26,105.04 77.38,105.04 77.66,104.76 84.97,104.76 85.76,103.98 110.6,103.98 111.36,103.21 117.85,103.21 118.58,102.47 124.24,102.47 124.8,103.03 138.24,103.03 139.81,101.46 147.73,101.46 149.27,103 160.74,103 162.77,100.98 175.42,100.98 185.99,90.41 185.99,88.05 189.31,84.72 195.72,84.72 202.29,78.15 202.29,76.49 209.71,69.07 219.44,69.07 219.89,69.52 222.36,69.52 223.86,71.02 225,71.02 228.41,74.44 228.41,76.85 231.22,79.66 231.22,80.02 231.42,80.22 231.59,80.22 v1(231.76,80.05)
  BOTTOM w0.102: C457.2 232.18,81.82 232.18,81.58 232.43,81.33 232.43,80.49 232.17,80.22 231.94,80.22 v1(231.76,80.05)
USB3TP2_C: length 2.2
  BOTTOM w0.102: U638.20 231.85,84.38 231.75,84.29 231.75,83.84 232.09,83.51 232.09,83.35 C457.1
USB3TP2_RP: length 60.3
  TOP w0.102: L44.3 260.58,124.36 260.43,124.22 260.23,124.22 260.12,124.1 260.12,123.67 260.17,123.62 260.69,123.62 260.7,123.61 260.79,123.61 261.08,123.9 261.26,123.9 261.55,124.19 v1(261.55,124.22)
  IN3 w0.127: v1(232.05,91.87) 232.02,91.87 231.73,91.58 231.73,91.37 231.96,91.15 232.37,91.15 232.6,91.37 233.1,91.37 233.91,92.18 233.91,92.88 235.68,94.65 247.89,94.65 252.81,99.57 252.81,109.7 254.56,111.45 254.56,116.93 256.99,119.36 256.99,123.15 257.74,123.91 258.7,123.91 258.81,124.01 259.24,124.01 259.35,123.91 259.73,123.91 259.83,124.01 260.26,124.01 260.37,123.91 261.27,123.91 261.55,124.19 v1(261.55,124.22)
  BOTTOM w0.102: C493.1 231.85,91.34 231.85,91.67 v1(232.05,91.87)
USB3TP2_RP_C: length 2.4
  BOTTOM w0.102: C493.2 231.9,89.79 231.9,88.88 231.75,88.74 231.75,88.56 231.85,88.47 U638.8
USB3TP3: length 122.8
  TOP w0.102: UH1.BC32 42.45,102.65 42.92,102.65 43.13,102.45 43.54,102.45 43.83,102.74 46.43,102.74 v1(47.14,103.45)
  IN3 w0.127: v1(97.04,128.26) 96.88,128.1 96.88,127.72 96.61,127.45 95.36,127.45 89.94,132.87 89.94,136.45 88.25,138.14 88.25,141.87 83.6,146.52 82.86,146.52 82.71,146.37 81.55,146.37 79.01,148.91 77.81,148.91 77.4,149.32 72.1,149.32 69.28,146.5 65.36,146.5 64.57,145.71 60.22,145.71 58.02,143.51 58.02,138.85 64.3,132.57 64.3,112.63 65.06,111.87 65.06,106.39 64.12,105.45 50.4,105.45 49.26,104.3 47.16,104.3 46.93,104.07 46.93,103.66 v1(47.14,103.45)
  BOTTOM w0.102: JDOCK1.92 96.7,127.19 96.56,127.34 96.56,127.52 96.83,127.8 96.83,128.05 v1(97.04,128.26)
USB3TP5: length 60.3
  TOP w0.102: v1(46.33,101.34) 45.61,100.62 43.13,100.62 42.82,100.32 UH1.BC26 ; JIO1.53 8.68,95.4 8.87,95.59 9.13,95.59 9.34,95.81 9.34,96.09 9.46,96.2 9.61,96.2 v1(9.81,96)
  IN3 w0.127: v1(46.33,101.34) 46.19,101.34 46.06,101.21 46.06,101.03 46.19,100.9 47.23,100.9 47.34,100.78 47.34,100.63 47.64,100.34 47.79,100.34 48.06,100.07 48.06,99.91 48.36,99.62 48.51,99.62 48.71,99.42 48.71,99.15 48.42,98.87 44.18,98.87 42.23,96.92 36.42,96.92 34.71,95.21 29.98,95.21 29.78,95.01 25.71,95.01 23.73,93.02 23.02,93.02 22.94,93.1 15.03,93.1 14.79,92.87 12.66,92.87 10.98,91.2 10.12,91.2 7.98,93.33 7.98,95.16 9,96.18 9.64,96.18 v1(9.81,96)
USB3TP6: length 48.1
  TOP w0.076: UH1.BE28 43.26,101.25 43.32,101.31 43.52,101.31 43.57,101.26 43.57,101.03 43.63,100.97 44.53,100.97 44.64,101.07 44.64,101.33 44.52,101.45 44.45,101.45 v1(44.35,101.34)
  TOP w0.102: JIO1.65 8.73,91.8 8.92,91.99 9.8,91.99 9.84,91.96 10.35,91.96 v1(10.58,91.73)
  IN3 w0.127: v1(10.58,91.73) 10.42,91.89 10.16,91.89 9.64,92.41 9.64,93.23 10.05,93.64 10.17,93.64 10.55,94.02 10.55,94.87 14.1,98.41 16.26,98.41 16.59,98.74 21.78,98.74 22.92,97.6 23.94,97.6 24.47,97.06 26.45,97.06 26.61,96.91 32.62,96.91 32.93,97.22 32.93,97.37 33.56,98 37.48,98 37.52,97.96 41.54,97.96 44.48,100.9 44.48,101.2 v1(44.35,101.34)
USB_MCARD1_DET#: length 201.2
  TOP w0.102: v1(23.4,93.44) 23.62,93.66 24.29,93.66 24.44,93.81 UH1.A10
  IN2 w0.127: v1(23.4,93.44) 23.39,93.44 23.04,93.09 20.74,93.09 19.59,94.24 19.59,95.02 19.26,95.35 19.26,96.61 18.83,97.04 18.83,100.88 17.33,102.37 17.33,106.58 17.47,106.72 17.47,108.93 20.18,111.64 20.18,113.98 20.77,114.57 20.77,114.86 22.67,116.76 23.06,116.76 25.57,119.28 25.57,123.38 26.6,124.41 26.6,128.08 29.32,130.8 35.94,130.8 41.64,136.5 41.64,138.11 42.58,139.05 43.34,139.05 44.82,140.52 46.62,140.52 48.24,142.14 48.24,145.23 50.54,147.53 50.54,150.66 51.37,151.48 53.04,151.48 57.87,156.31 65.71,156.31 69.14,159.73 70.44,159.73 74.25,163.55 74.25,164.92 74.7,165.36 78.16,165.36 78.88,164.64 81.43,164.64 82.15,163.92 86.83,163.92 87.94,162.8 93.72,162.8 96.37,165.45 98.56,165.45 99.54,166.43 100.41,166.43 100.8,166.81 100.8,167.3 101.41,167.9 102.76,167.9 103.39,168.54 105.9,168.54 106.28,168.92 106.76,168.92 106.92,168.77 107.68,168.77 108.03,169.12 113.02,169.12 116,166.14 117.5,166.14 117.93,166.57 121.41,166.57 128.04,159.94 131.01,159.94 133.87,157.08 145.2,157.08 v1(146.74,155.53)
  BOTTOM w0.102: v2(23.99,93.33) 23.87,93.44 v1(23.4,93.44) ; JMINI4.40 145.55,157.34 147.35,155.53 R824.1 147.05,155.23 v1(146.74,155.53)
USB_OC0#: length 375.1
  TOP w0.102: v1(258.42,101.84) 257.63,101.05 v1(254.49,101.05) ; UH1.P3 30.36,90.61 30.36,90.14 30.59,89.91 30.59,89.65 30.41,89.47 30.41,89.06 v1(30.77,88.71)
  IN2 w0.127: v1(30.13,80.81) 30.15,80.82 30.15,81.38 30.59,81.82 33.9,81.82 35.35,80.38 46.41,80.38 47.6,81.57 52.18,81.57 53.79,83.18 67.1,83.18 69.06,85.14 79.5,85.14 84.63,90.27 84.63,92.24 86.13,93.74 87.63,93.74 89.8,95.91 113.46,95.91 114.09,95.27 114.89,95.27 115.49,95.87 117.27,95.87 118.49,94.65 130.89,94.65 132.99,96.75 132.99,98.8 135.42,101.23 136.89,101.23 140.04,98.08 154.42,98.08 155.1,97.39 161.08,97.39 164.51,93.97 179.34,93.97 179.97,93.33 194.39,93.33 198.74,88.99 198.74,82.96 202.98,78.71 202.98,74.63 207.86,69.75 216.17,69.75 218.04,71.61 218.4,71.61 218.83,72.04 218.83,72.12 219.47,72.76 221.11,72.76 221.21,72.65 223.91,72.65 226.48,75.22 235.26,75.22 239.96,79.92 245.55,79.92 247,81.37 247,86.37 248.57,87.95 248.57,90.03 256.57,98.03 256.57,98.37 255.98,98.97 255.32,98.97 254.96,99.32 254.96,100.58 v1(254.49,101.05)
  IN3 w0.127: v1(30.77,88.71) 30.77,88.1 29.37,86.7 26.39,86.7 25.52,85.84 21.97,85.84 20.95,86.85 19.2,86.85 18.59,87.46 13.69,87.46 11.94,89.22 9.4,89.22 6.46,92.16 6.46,95.81 8.21,97.56 8.21,110.59 9.2,111.57 9.2,112.88 9.79,113.47 10.87,113.47 12.32,114.92 13.6,114.92 14.34,115.66 15.28,115.66 16.34,116.72 16.34,117.31 18.04,119.01 18.83,119.01 19.77,119.95 24.37,119.95 26.15,121.73 28.53,121.73 29.78,120.48 v1(29.8,120.48)
  BOTTOM w0.102: v1(254.49,101.05) 255.28,101.84 U45.6 ; v1(29.8,120.48) 30.21,120.89 v2(30.21,121.64) 30.21,122.34 RH3.1 ; v1(30.77,88.71) 30.77,88.01 29.98,87.23 29.98,85.3 RH246.2 30.26,84.57 30.26,80.94 v1(30.13,80.81) ; v1(258.42,101.84) U45.10
USB_OC1#: length 120.6
  TOP w0.102: JIO1.69 6.6,90.6 5.99,89.99 5.99,89.86 4.86,88.73 v1(4.48,88.73) ; v1(27.36,80.81) 27.36,81.02 28.02,81.68 28.02,84.62 RH247.2 28.48,85.51 29.71,86.74 30.36,86.74 31.91,88.29 UH1.V1
  IN3 w0.127: v1(27.36,80.81) 26.94,80.38 23.48,80.38 22.96,80.91 22.96,81.33 22.46,81.82 15.97,81.82 15.16,81.01 13.12,81.01 8.44,85.68 5.93,85.68 5.01,86.6 5.01,88.2 v1(4.48,88.73)
  IN4 w0.109: v1(27.36,80.81) 27.36,81.49 27.14,81.72 26.58,81.72 25.87,82.43 24.21,82.43 23.99,82.65 19.67,82.65 17.97,84.35 17.41,84.35 14.86,86.9 14.23,86.9 11.92,89.22 9.79,89.22 8.26,90.75 8.26,109.63 9.69,111.06 9.69,112.95 13.33,116.59 13.33,117.97 17.9,122.54 17.9,125.55 v1(18.68,126.32)
  BOTTOM w0.102: v1(18.68,126.32) 19.08,126.73 v2(19.22,126.73) 26.73,126.73 27.62,125.84 28.94,125.84 29.75,125.03 RH4.1
USB_OC2#: length 70.7
  TOP w0.102: RPH7.1 27.33,85.52 27.82,86.02 v1(27.87,86.02) 27.9,86.02 29.38,87.49 30.46,87.49 31.4,88.43 31.4,90.16 UH1.U2
  IN4 w0.109: v1(27.87,86.02) 27.44,85.58 26.14,85.58 25.72,86 25.11,86 24.85,86.26 21.95,86.26 19.85,88.37 19.85,89.39 19.34,89.9 19.34,91.66 16.58,94.42 16.58,96.06 16.4,96.24 15.38,96.24 15.22,96.09 15.22,95.26 14.93,94.97 14.5,94.97 13.32,96.14 13.32,100.77 12.59,101.49 12.59,107.74 13.15,108.29 13.15,110.68 14.11,111.64 14.11,113.9 14.93,114.72 14.93,115.11 16.82,117 16.82,118.4 v1(17.43,119.01)
  BOTTOM w0.102: v1(17.43,119.01) 17.43,118.78 18.35,117.87 21.85,117.87 22.51,118.53 24.72,118.53 26.12,119.92 27.59,119.92 v2(27.82,120.15) 28.86,121.19 RH6.1
USB_OC3#: length 74.7
  TOP w0.102: v1(30.18,88.71) 30.18,89.68 UH1.P1
  IN3 w0.127: v1(26.28,120.69) 25.46,120.69 24.47,119.7 20.02,119.7 15.44,115.12 14.16,115.12 13.71,114.67 12.42,114.67 11.24,113.48 11.24,112.3 10.75,111.82 9.81,111.82 8.47,110.48 8.47,97.45 6.71,95.7 6.71,92.26 9.51,89.47 12.04,89.47 13.8,87.72 18.69,87.72 19.3,87.11 21.06,87.11 22.07,86.09 25.42,86.09 26.28,86.95 28.38,86.95 30.13,88.71 v1(30.18,88.71)
  BOTTOM w0.102: v1(26.28,120.69) 26.32,120.69 26.73,121.09 26.73,121.64 v2(26.58,121.79) 26.58,123.18 RH248.2 27.97,122.79 RH7.1
USB_OC4#: length 256.9
  TOP w0.102: UH1.M3 29.47,90.23 29.17,89.92 29.17,89.52 29.04,89.39 29.04,88.44 27.71,87.11 26.84,87.11 24.81,85.08 RH249.2 25.13,84.62 25.13,81.37 v1(25.13,81.37) 25.13,81.03 v1(24.9,80.81) ; v1(6.59,90) JIO1.71 ; v1(69.6,165.98) U48.6 ; U48.10 v1(66.47,165.98)
  IN1 w0.109: v1(66.47,165.98) v1(69.6,165.98)
  IN2 w0.127: v1(66.47,165.98) 65.46,165.98 62.7,163.22 62.7,161.47 62.15,160.92 60.41,160.92 59.54,160.06 54.51,160.06 51.69,157.24 48.4,157.24 46.47,155.3 43.49,155.3 40.6,152.41 40.6,148.85 38.5,146.75 24.63,146.75 20.38,150.99 15.71,150.99 13.12,153.58 10.02,153.58 7.55,151.12 7.55,145.02 8.32,144.25 8.68,144.25 12.1,140.83 12.1,135.67 9.1,132.67 9.1,125.69 12.89,121.91 12.89,117.31 10.32,114.74 8.83,114.74 7.28,113.2 7.28,91.86 6.59,91.17 v1(6.59,90)
  IN4 w0.109: v1(24.9,80.81) 24.75,80.66 21.25,80.66 20.2,81.7 19.28,81.7 17.88,83.11 13.48,83.11 6.59,90 v1(6.59,90) ; v1(19.85,126.32) 19.42,126.75 17.91,126.75 15.91,124.75 15.91,121.22 12.86,118.17 12.86,116.78 9.22,113.15 9.22,111.26 7.78,109.82 7.78,89.51 13.71,83.58 18.07,83.58 19.48,82.17 23.79,82.17 24.01,81.95 24.54,81.95 25.13,81.37 v1(25.13,81.37)
  BOTTOM w0.102: v1(19.85,126.32) 19.9,126.38 24.7,126.38 26.07,125 RH8.1 ; v1(69.6,165.98) v2(69.6,166.6)
USB_OC5#: length 61.9
  TOP w0.102: UH1.T1 31.12,89.76 31.12,89.52 31.17,89.47 31.17,88.53 30.37,87.72 29.28,87.72 27.99,86.43 27.69,86.43 27.28,86.02 v1(27.24,86.02) 26.83,85.6 RPH7.2
  IN4 w0.109: v1(27.24,86.02) 26.78,86.47 25.31,86.47 25.04,86.73 24.26,86.73 24.04,86.95 24.04,87.73 23.73,88.05 20.84,88.05 20.34,88.54 20.34,89.57 19.81,90.1 19.81,93.01 18.75,94.07 18.2,94.07 17.05,95.21 17.05,96.43 16.39,97.09 15.53,97.09 13.8,98.82 13.8,100.96 13.07,101.69 13.07,107.54 13.62,108.09 13.62,110.49 14.58,111.45 14.58,113.7 15.41,114.53 15.41,114.91 17.62,117.13 17.62,117.98 v1(18.22,118.58)
  BOTTOM w0.102: RH9.1 25.18,120.58 v2(24.11,119.51) 23.35,118.76 22.41,118.76 21.75,118.1 18.7,118.1 v1(18.22,118.58)
USB_OC6#: length 58.5
  TOP w0.102: RPH7.3 26.33,85.64 26.65,85.96 v1(26.65,86.02) 27.29,86.66 27.9,86.66 29.5,88.26 29.5,89.29 29.78,89.57 29.78,90.16 UH1.N2
  IN4 w0.109: v1(18.83,119.79) 18.83,119.77 17.28,118.22 17.28,117.12 15.17,115.01 15.17,114.63 14.34,113.8 14.34,111.55 13.38,110.58 13.38,108.19 12.83,107.64 12.83,101.59 13.56,100.86 13.56,98.72 15.43,96.85 16.29,96.85 16.82,96.33 16.82,94.51 19.57,91.75 19.57,90 20.08,89.49 20.08,88.46 22.05,86.5 24.95,86.5 25.21,86.24 25.82,86.24 26.04,86.02 v1(26.65,86.02)
  BOTTOM w0.102: RH17.1 24.29,122.41 22.42,120.55 v2(21.18,120.55) 19.58,120.55 v1(18.83,119.79)
USB_PWR_SHR_EN#: length 77.6
  TOP w0.102: v1(216.92,78) 216.91,78 216.37,77.46 216.37,76.34 216.01,75.98 216.01,74.56 218.79,71.78 220.26,71.78 v1(220.91,71.13)
  IN2 w0.127: v1(220.91,71.13) 221.57,71.79 224.9,71.79 227.52,74.41 234.88,74.41 240.14,79.67 245.96,79.67 247.28,80.99 247.28,86.29 248.83,87.84 248.83,89.92 258.24,99.34 259.47,99.34 260.59,100.45 v1(260.59,102.98)
  BOTTOM w0.102: U46.B10 217.42,77.5 v1(216.92,78) ; R1626.1 257.74,104.44 259.13,104.44 v1(260.59,102.98) 260.59,101.78 v4(260.4,101.59) ; RP2.7 221.63,69.63 220.89,70.37 220.89,71.11 v1(220.91,71.13)
USB_PWR_SHR_VBUS_EN: length 70.2
  IN1 w0.109: v1(220.96,84.62) 221.37,85.02 221.37,85.1 221.62,85.35 222.48,85.35 223.29,84.54 224.42,84.54 224.67,84.29 225.33,84.29 v1(225.76,84.72)
  IN2 w0.127: v1(220.96,84.62) 221.01,84.62 221.4,85 221.4,85.13 222.49,86.22 225.4,86.22 229.7,81.93 246.24,81.93 246.62,82.31 246.62,90.54 v1(252.76,96.68)
  BOTTOM w0.102: v1(220.96,84.62) 221.42,85.07 U46.B50 ; Q55.2 255.07,94.38 v1(252.76,96.68) 252.05,97.39 v2(252.05,98.16) 252.05,100.01 253.09,101.05 253.09,104.77 254.76,106.44 254.76,107.38 255.16,107.78 U2.1 ; RP1.7 225.4,83.73 225.66,83.98 225.66,84.62 v1(225.76,84.72)
USB_SIDE_EN#: length 295
  TOP w0.102: JIO1.73 8.68,89.4 9.25,89.98 v1(9.25,90.33) ; v1(256.07,98.14) v2(256.64,98.14)
  IN2 w0.127: v1(196.58,92.54) 195.54,93.58 180.08,93.58 179.44,94.22 164.61,94.22 161.13,97.7 155.16,97.7 154.52,98.33 140.27,98.33 137.12,101.48 135.26,101.48 132.57,98.79 132.57,96.69 130.79,94.91 118.6,94.91 117.34,96.16 114.04,96.16 113.79,96.42 89.59,96.42 87.48,94.31 83.54,94.31 81.44,92.21 76.44,92.21 72.68,88.45 71.52,88.45 66.76,83.69 53.58,83.69 51.96,82.08 47.39,82.08 46.2,80.88 35.56,80.88 34.11,82.33 29.63,82.33 28.99,81.7 28.99,80.63 28.73,80.38 25.23,80.38 24.6,79.74 16.98,79.74 16.34,79.11 13.77,79.11 8.26,84.61 8.26,89.34 v1(9.25,90.33) ; v1(256.07,98.14) 253.44,98.14 246.36,91.07 246.36,83.4 245.45,82.48 230.69,82.48 229.22,83.96 229.22,84.16 224.47,88.91 220.35,88.91 218.24,86.8 214.84,86.8 v1(214.17,87.47)
  BOTTOM w0.102: U45.4 256.33,98.41 v1(256.07,98.14) ; U46.A33 v1(214.17,87.47) 213.39,88.25 R768.2 210.5,88.86 207.05,92.31 196.81,92.31 v1(196.58,92.54)
USBP0+: length 296.3
  TOP w0.089: v1(26.35,103.74) 26.35,103.96 26.08,104.23 26.08,104.39 26.25,104.56 26.25,104.7 26.16,104.79 UH1.D37
  IN4 w0.089: v1(26.35,103.74) 26.11,103.74 25.92,103.55 25.92,103.19 26.45,102.65 26.45,102.11 26.32,101.98 26.32,101.7 26.55,101.47 29.73,101.47 30.02,101.18 37.56,101.18 37.82,101.44 43.02,101.44 43.54,100.91 43.93,100.91 43.95,100.93 43.96,100.93
  IN4 w0.117: 43.96,100.93 47.78,100.93 48.15,101.3 48.15,101.64 52.02,105.5 54.15,105.5 54.64,105.01 64.99,105.01 67.25,107.27 80.06,107.27 80.85,106.48 85.81,106.48 86.61,105.69 114.98,105.69 115.75,104.92 162.83,104.92 164.66,103.09 176.6,103.09 181.25,98.44 181.78,98.44 187.13,93.1 192.59,93.1 204.32,81.36 204.32,77.93 208.5,73.76 208.5,73.25 210.95,70.8 217.19,70.8 219.46,73.07 221.03,73.07 222.31,74.36 223.3,74.36 228.01,79.07 228.01,81.14 228.7,81.82 232.04,81.82 236.22,77.64 246.09,77.64 246.53,78.09 254.36,78.09 259.67,83.4 259.67,95.23 255.12,99.77 255.12,101.08 253.58,102.62 253.58,103.35 253.97,103.74 254.26,103.74 v1(254.51,103.99)
  BOTTOM w0.102: U2.6 256.16,105.6 255.68,105.12 254.84,105.12 254.81,105.09 v3(254.25,104.53) 254.05,104.32 254.05,103.78 254.14,103.69 254.21,103.69 v1(254.51,103.99)
USBP0-: length 296.7
  TOP w0.089: v1(25.8,103.97) 25.88,104.05 25.88,104.46 25.53,104.81 UH1.B37
  IN4 w0.089: 43.96,100.69 43.95,100.69 43.92,100.72 43.85,100.72 43.83,100.7 43.46,100.7 42.93,101.23 37.91,101.23 37.65,100.97 29.93,100.97 29.64,101.26 26.47,101.26 26.11,101.61 26.11,102.07 26.24,102.19 26.24,102.57 25.71,103.1 25.71,103.64 25.8,103.73 v1(25.8,103.97)
  IN4 w0.117: v1(254.51,103.41) 254.42,103.5 254.07,103.5 253.82,103.25 253.82,102.72 255.36,101.18 255.36,99.87 259.9,95.33 259.9,83.3 254.45,77.85 246.63,77.85 246.19,77.4 236.12,77.4 231.94,81.59 228.8,81.59 228.25,81.04 228.25,78.97 223.4,74.12 222.41,74.12 221.12,72.84 219.56,72.84 217.29,70.56 210.85,70.56 208.26,73.15 208.26,73.66 204.08,77.84 204.08,81.27 192.49,92.86 187.03,92.86 181.68,98.21 181.15,98.21 176.5,102.86 164.56,102.86 162.73,104.68 115.65,104.68 114.88,105.45 86.51,105.45 85.72,106.25 80.75,106.25 79.96,107.03 67.35,107.03 65.09,104.77 54.54,104.77 54.05,105.27 52.12,105.27 48.39,101.54 48.39,101.2 47.88,100.69 43.96,100.69
  BOTTOM w0.102: U2.7 255.66,105.41 255.59,105.33 254.75,105.33 254.72,105.3 254.31,104.89 254.29,104.89 253.83,104.43 253.83,103.69 254.05,103.48 254.44,103.48 v1(254.51,103.41)
USBP0_D+: length 3.4
  BOTTOM w0.102: L39.2 256.77,109.33 256.69,109.41 256.69,109.74 256.59,109.84 256.34,109.84 255.93,109.43 255.93,108.84 256.16,108.6 U2.3
USBP0_D-: length 3.3
  BOTTOM w0.102: U2.2 255.66,108.62 255.71,108.67 255.71,109.54 v3(256,109.83) 256.23,110.06 256.71,110.06 256.83,110.18 L39.3
USBP0_R_D+: length 24.2
  BOTTOM w0.102: L39.1 259.32,109.33 259.63,109.64 260.07,109.64 260.28,109.85 v3(260.28,110.06) 260.28,110.44 259.43,111.29 259.43,112.24 259.72,112.53 259.9,112.53 259.99,112.44 259.99,111.8 260.13,111.66 D15.3 260.41,112.37 260.54,112.49 261.02,112.49 261.95,113.42 261.95,117.9 262.23,118.18 263.94,118.18 263.95,118.17 264.49,118.17 264.5,118.18 265.11,118.18 265.91,117.38 265.91,113.5 265.54,113.13 264.59,113.13 264.4,113.32 JUSB1.3
USBP0_R_D-: length 24.1
  BOTTOM w0.102: JUSB1.2 265.06,112.91 265.63,112.91 266.13,113.41 266.13,117.47 265.2,118.4 v3(264.22,118.4) 262.14,118.4 261.73,117.99 261.73,113.51 260.93,112.71 260.6,112.71 260.41,112.9 D15.2 260.14,113.59 259.93,113.37 259.93,112.88 259.8,112.75 259.63,112.75 259.22,112.33 259.22,111.2 260.05,110.36 260.05,109.93 259.98,109.85 259.69,109.85 259.36,110.18 L39.4
USBP1+: length 349
  TOP w0.102: L41.3 261.38,121.82 261.22,121.66 261.22,121.5 v1(260.82,121.09) ; v1(23.16,106.86) 23.16,106.32 23.63,105.85 24.35,105.85 24.71,105.5 24.77,105.5 24.97,105.29 25.43,105.29 UH1.C38
  IN4 w0.117: v1(23.16,106.86) 23.01,106.86 22.9,106.96 22.9,107.13 22.95,107.18 22.95,107.53 23.05,107.63 23.05,108.03 22.95,108.13 22.95,108.48 23.05,108.58 23.05,108.98 22.95,109.08 22.95,109.43 22.36,110.02 21.96,110.02 21.58,110.4 21.58,112.47 22.16,113.04 22.16,114.29 22.79,114.92 22.79,115.81 26.97,119.98 26.97,121.5 28.79,123.33 28.79,125.44 29.82,126.46 29.82,131.87 31.94,133.99 31.94,135.77 37.65,141.49 40.6,141.49 42.91,143.8 44.38,143.8 45.78,145.2 45.78,145.37 50.88,150.48 50.88,151.78 52.31,153.2 55.3,153.2 58.05,155.94 68.69,155.94 70.78,158.03 72.43,158.03 76.16,161.76 77.81,161.76 78.75,162.7 94.4,162.7 96.6,164.91 98.74,164.91 99.5,165.67 108.56,165.67 108.88,165.36 111.99,165.36 112.25,165.61 114.59,165.61 114.85,165.36 127.25,165.36 130.29,162.32 134.15,162.32 135.9,160.56 135.9,159.39 142.27,153.02 144.61,153.02 145.4,153.81 150.83,153.81 151.29,153.35 151.29,150.91 152.88,149.32 152.88,146.19 153.14,145.94 153.14,143.02 154.36,141.79 163.96,141.79 165.09,140.67 166.59,140.67 169.81,137.45 171,137.45 175.36,133.09 175.36,121.25 180.66,115.95 180.66,108.05 187.87,100.85 195.64,100.85 202.63,93.86 209.62,93.86 210.83,92.64 215.14,92.64 215.78,92.01 226.65,92.01 227.39,92.75 233.67,92.75 234.8,93.88 237.19,93.88 241.31,98 248.59,98 252.7,102.1 252.7,103.75 256.84,107.9 256.84,109.38 258.69,111.23 258.69,119.4 259.83,120.53 259.83,120.97 260.13,121.27 260.64,121.27 v1(260.82,121.09)
USBP1-: length 349.2
  TOP w0.102: L41.2 261.48,122.67 261.21,122.4 261.21,121.96 260.95,121.7 v1(260.82,121.7) ; UH1.A38 24.63,105.27 24.26,105.64 23.54,105.64 22.94,106.23 22.94,106.49 22.84,106.59 22.49,106.59 22.41,106.67 22.41,106.77 v1(22.5,106.86)
  IN4 w0.117: v1(260.82,121.7) 260.62,121.51 260.03,121.51 259.59,121.06 259.59,120.63 258.45,119.5 258.45,111.33 256.61,109.48 256.61,107.99 252.46,103.85 252.46,102.19 248.5,98.23 241.21,98.23 237.09,94.12 234.7,94.12 233.57,92.98 227.29,92.98 226.55,92.25 215.88,92.25 215.24,92.88 210.93,92.88 209.72,94.09 202.73,94.09 195.74,101.08 187.97,101.08 180.9,108.15 180.9,116.05 175.6,121.35 175.6,133.19 171.1,137.69 169.91,137.69 166.69,140.9 165.18,140.9 164.06,142.03 154.46,142.03 153.37,143.12 153.37,146.04 153.12,146.29 153.12,149.42 151.53,151.01 151.53,153.44 150.93,154.04 145.3,154.04 144.51,153.26 142.37,153.26 136.13,159.49 136.13,160.66 134.24,162.55 130.39,162.55 127.35,165.59 114.94,165.59 114.69,165.85 112.15,165.85 111.9,165.59 108.97,165.59 108.66,165.91 99.4,165.91 98.64,165.14 96.51,165.14 94.3,162.93 78.65,162.93 77.71,161.99 76.06,161.99 72.34,158.27 70.68,158.27 68.59,156.18 57.95,156.18 55.21,153.43 52.21,153.43 50.65,151.87 50.65,150.57 45.54,145.47 45.54,145.3 44.28,144.04 42.81,144.04 40.5,141.72 37.55,141.72 31.7,135.87 31.7,134.09 29.58,131.97 29.58,126.56 28.56,125.54 28.56,123.43 26.73,121.6 26.73,120.08 22.56,115.91 22.56,115.02 21.92,114.38 21.92,113.14 21.34,112.57 21.34,110.3 21.86,109.78 22.26,109.78 22.71,109.33 22.71,107.27 22.67,107.23 22.67,107.02 v1(22.5,106.86)
USBP1_D+: length 21.4
  TOP w0.102: L41.4 263.81,121.82 264.13,122.15 264.51,122.15 265.08,122.72 265.08,122.92 266.17,124.01 266.51,124.01 266.63,123.89 D17.2 267.48,124.03 267.93,124.03 v3(268.5,124.6) 269.31,125.41 269.31,126.03 269.3,126.05 269.3,131.34 265.18,135.46 264.68,135.46 264.4,135.75 JUSB2.3
USBP1_D-: length 21.4
  TOP w0.102: JUSB2.2 264.4,135.04 264.61,135.25 265.09,135.25 269.08,131.25 v3(269.08,125.77) 269.08,125.49 268.54,124.95 268.53,124.95 268.09,124.51 268.09,124.49 267.84,124.24 267.5,124.24 D17.3 266.63,124.32 266.53,124.22 266.08,124.22 264.87,123.01 264.87,122.81 264.42,122.36 264.14,122.36 263.83,122.67 L41.1
USBP2+: length 15.9
  TOP w0.102: JIO1.18 14.07,106.2 14.18,106.31 14.82,106.31 15.07,106.06 15.07,104.89 16.33,103.63 v3(16.58,103.63) 16.84,103.63 17.7,104.49 17.7,104.51 18.09,104.9 18.11,104.9 18.46,105.26 19.12,105.92 19.65,105.92 20.04,105.53 23.14,105.53 23.36,105.31 23.99,105.31 24.61,104.68 24.76,104.68 24.95,104.5 25.41,104.5 UH1.C36
