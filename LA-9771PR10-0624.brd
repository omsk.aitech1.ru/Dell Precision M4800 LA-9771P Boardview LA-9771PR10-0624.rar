# Allegro board LA-9771PR10-0624.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_CTX_GRX_P14: length 3.3
  TOP w0.109: JMXM1.92 110.5,96.17 110.65,96.02 110.65,95.82 111.24,95.24 111.8,95.24 111.99,95.05 111.99,94.92 CC68.1
PEG_CTX_GRX_P15: length 3.3
  TOP w0.109: JMXM1.86 112,96.23 113.13,95.1 113.59,95.1 113.72,94.96 113.72,94.88 CC67.1
PEQ: length 4.1
  TOP w0.102: U9.8 v1(22.06,161.5)
  BOTTOM w0.102: v2(23.87,160.77) R69.2 ; R69.2 22.56,160.69 R70.2 ; R69.2 22.64,160.92 v1(22.06,161.5)
PHASE1: length 24.4
  IN3 w1.016: 45.37,51.98 45.37,48.12 50.15,43.34 50.15,36.02 53.37,32.79 53.37,30.9
  vias: v2(43.54,53.07) v3(44.23,53.25) v3(44.23,52.49) v3(53.13,29.88) v3(53.13,29.25)
PHASE2: length 15
  TOP w0.102: v3(44.58,38.39) v2(43.65,38.39)
  TOP w0.762: PQ502.3 v3(44.58,39.15)
  IN4 w0.762: v3(44.58,39.15) v3(44.58,38.39) 47.28,38.39 48.78,36.89 48.78,29.58 49.01,29.35
  vias: v3(49.6,28.74) v3(50.16,28.18)
PHASE3: length 6.1
  TOP w0.635: PQ500.3 42.48,69.63 v3(42.2,69.35)
  IN4 w0.762: 39.4,70.27 40.32,69.35 v3(42.2,69.35)
  BOTTOM w0.102: v2(36.89,70.58) 38.07,71.77 PC501.2
  vias: v3(38.9,71.54) v3(38.9,70.9)
PM_APWROK: length 136.7
  TOP w0.102: v1(14.64,130.57) 14.56,130.57 RH87.1 13.88,129.69 v2(12.9,128.71) 12.81,128.62 11.65,128.62 11.21,129.07 UH2.2
  IN2 w0.127: v1(109.91,156.17) 109.23,156.86 109.23,159.15 107.55,160.83 104.73,160.83 104.34,161.22 98.64,161.22 98.03,160.61 97.31,160.61 96.57,159.88 96.57,159.75 91.8,154.98 88.56,154.98 87.95,155.59 82.08,155.59 81.09,154.6 80.09,154.6 79.18,155.51 77.5,155.51 77.2,155.81 69.04,155.81 68.56,155.34 68.56,152.99 68.97,152.58 68.97,148.99 65.87,145.88 61.26,145.88 58.53,143.16 58.53,136.74 56.52,134.73 49.44,134.73 48.6,135.57 44.86,135.57 44.5,135.21 v1(44.5,130.66)
  IN3 w0.127: v1(44.5,130.66) 44.41,130.74 27.2,130.74 20.8,124.34 18.56,124.34 15.76,127.15 15.76,129.45 v1(14.64,130.57)
  BOTTOM w0.102: v1(109.91,156.17) 109.81,156.27 U51.A9
PM_APWROK_R: length 109.6
  TOP w0.102: UH1.AB7 33.49,92.31 v1(33.2,92.61) ; RH87.2 13.88,131.53 13.19,132.22 12.25,132.22 11.86,131.83 UH2.4 11.4,131.42 10.8,132.01 10.37,132.01 10.07,131.71 v1(10.07,130.67)
  IN1 w0.109: v1(10.07,130.67) 10.66,130.08 10.66,128.97 9.33,127.65 9.33,125.77 13.1,122 13.1,117 9.23,113.13 9.23,111.59 8.67,111.03 8.67,99.83 6.1,97.27 6.1,93.51 3.97,91.37 3.97,90.54 3.39,89.96 3.39,85.6 3.98,85.01 5.54,85.01 6.34,85.81 15.92,85.81 21.56,80.17 24.29,80.17 24.53,79.93 28.88,79.93 29.37,79.43 32.36,79.43 33.77,78.03 v1(33.77,78.01)
  BOTTOM w0.102: v1(33.2,92.61) 33.2,92.6 33.54,92.26 33.54,91.73 33,91.2 33,88.57 v4(34.42,87.16) 35.39,86.19 35.39,79.64 v1(33.77,78.01)
PM_DRAM_PWRGD: length 9.3
  TOP w0.102: T104.1 22.82,86.18 23.21,86.57 23.81,86.57 24.05,86.81 24.05,87.55 24.78,88.28 26.91,88.28 27.31,88.68 27.31,89.52 27.54,89.75 27.54,89.91 27.85,90.22 27.85,90.69
PM_DRAM_PWRGD_A: length 3.5
  BOTTOM w0.102: v2(114,82) 113.76,82.24 112.7,82.24 RC18.2 112.18,82.66 UC2.2
PM_DRAM_PWRGD_CPU: length 36.5
  TOP w0.102: JCPU1.AC10 v1(98.12,62.75)
  IN4 w0.109: v1(115.27,78.67) 115.27,71.03 107.45,63.21 98.58,63.21 v1(98.12,62.75)
  BOTTOM w0.102: v1(115.27,78.67) 115.27,79.04 v4(114.16,80.16) 112.98,80.16 112.83,80.01 UC2.4 112.83,78.56 113.04,78.34 113.04,77.4 RC16.2 RC14.1
PM_LANPHY_ENABLE: length 181.5
  TOP w0.102: UH1.K13 27.95,94.47 v1(27.95,94.35)
  IN2 w0.127: v1(124.24,159.9) 118.47,165.67 116.11,165.67 113.52,168.26 107.2,168.26 106.99,168.06 105.88,168.06 105.65,168.29 103.5,168.29 102.86,167.65 101.51,167.65 101.05,167.19 101.05,166.71 100.52,166.18 99.68,166.18 98.54,165.04 96.31,165.04 93.82,162.55 87.82,162.55 86.7,163.66 82.05,163.66 81.32,164.39 78.78,164.39 78.05,165.11 74.8,165.11 74.51,164.81 74.51,163.44 70.54,159.48 69.24,159.48 65.82,156.06 58.91,156.06 53.14,150.29 51.04,150.29 50.8,150.05 50.8,143.92 49.23,142.35 48.81,142.35 47.02,140.57 47.02,139.87 46.7,139.55 44.2,139.55 43.45,138.8 42.69,138.8 41.9,138 41.9,136.4 36.04,130.54 29.42,130.54 26.86,127.98 26.86,124.3 25.83,123.27 25.83,119.17 23.17,116.51 22.78,116.51 21.03,114.76 21.03,114.47 20.44,113.87 20.44,111.53 17.72,108.82 17.72,106.61 17.59,106.47 17.59,102.48 19.08,100.98 19.08,97.15 19.52,96.71 19.52,95.45 19.85,95.12 19.85,94.93 20.86,93.91 22.56,93.91 22.59,93.94 24.93,93.94 25.78,94.79 27.53,94.79 27.95,94.37 v1(27.95,94.35)
  BOTTOM w0.102: R555.1 122.46,158.79 v2(123.58,159.9) v1(124.24,159.9) ; RH217.1 24.04,95.79 24.62,95.21 26.35,95.21 26.65,94.92 27.38,94.92 v1(27.95,94.35)
POWER_SW#: length 16
  TOP w0.102: U29.20 168.82,130.13 v1(168.44,129.75) ; v1(164.82,139.56) U10.4 164.52,140.13 163.89,140.76 v4(163.89,141.02)
  BOTTOM w0.102: v1(164.82,139.56) 164.82,131.07 165.12,130.77 165.95,130.77 167.09,129.63 168.32,129.63 v1(168.44,129.75)
POWER_SW#_MB: length 382.9
  TOP w0.102: v1(206.89,95.39) 208.81,93.47 225.24,93.47 225.41,93.64 229.46,93.64 230.6,94.78 236.94,94.78 242.03,99.87 251.84,99.87 252.89,100.92 252.89,103.21 252.8,103.3 JPB1.1 ; v1(91.74,31.54) 91.74,29.78 89.23,27.26 87.66,27.26 87.48,27.45 JAPS1.11 ; v1(113.29,164.78) PWRSW1.1 112.33,164.55 109.86,164.55 R811.2
  IN1 w0.109: v1(91.74,31.54) 91.47,31.81 91.47,33.18 92.62,34.33 92.62,44.97 92.11,45.48 91.55,45.48 86.5,50.53 86.5,68.74 87.54,69.78 87.54,79.44 91.22,83.12 91.22,88.81 93.94,91.52 93.94,93.19 94.58,93.83 94.58,104.54 95.67,105.63 95.67,106.95 97.32,108.6 97.32,109.99 97.05,110.26 97.05,112.08 97.87,112.9 97.87,115 98.61,115.73 v1(98.61,116.55) ; v1(99.02,163.31) 99.69,163.98 100.71,163.98 103.01,166.28 105.65,166.28 106.26,165.66 111.03,165.66 111.92,164.78 v1(113.29,164.78)
  IN2 w0.127: v1(98.61,116.55) 98.19,116.13 96.56,116.13 94.76,117.92 94.76,123.75 94.23,124.28 94.23,126.44 94.09,126.58 94.09,131.66 94.67,132.24 94.67,134.08 100.26,139.67 100.26,146.64 101.38,147.76 103.12,147.76 106.29,150.94 109.58,150.94 111.5,152.86 111.5,159.9 110.04,161.36 107.73,161.36 107.22,161.87 100.45,161.87 v1(99.02,163.31)
  IN3 w0.127: v1(113.29,164.78) 113.39,164.88 123.65,164.88 125.82,162.71 128.71,162.71 129.04,162.38 136.15,162.38 140.65,157.88 143.55,157.88 150.13,151.31 151.16,151.31 154.12,148.35 154.12,146.8 155.79,145.13 155.79,142.6 158.81,139.58 158.81,132.81 161.31,130.31 164.42,130.31 167.01,127.72 167.01,125.1 174.51,117.61 174.51,108.82 176.13,107.19 176.13,106.28 181.33,101.08 197.45,101.08 203.14,95.39 v1(206.89,95.39)
  BOTTOM w0.102: v1(91.74,31.54) v4(91.74,32.1)
POWER_SW_IN#: length 78.5
  TOP w0.102: R810.2 109.84,163.61 R811.1 C1352.1 108.67,163.41 107.63,162.37 107.63,160.84 107.2,160.41 v1(107.17,160.41) ; v1(153.97,139.19) 154.31,139.53 160.82,139.53 v2(161.13,139.84) 162.68,141.4 164.31,141.4 165.46,140.24 165.46,139.99 165.97,139.48 U10.2
  IN3 w0.127: v1(153.97,139.19) 153.97,139.79 150.01,143.75 150.01,145.19 139.44,155.76 137.96,155.76 137.62,156.11 126.39,156.11 124.04,158.46 114.33,158.46 113.69,159.1 112.44,159.1 111.82,159.73 109.46,159.73 108.66,160.53 107.29,160.53 v1(107.17,160.41)
  BOTTOM w0.102: U51.B67 107.25,160.49 v1(107.17,160.41)
PROCHOT_GATE: length 47.7
  IN3 w0.127: v1(237.96,63.05) 235.39,63.05 233.71,64.73 230.21,64.73 225.89,69.05 225.89,76.62 228.33,79.06 228.33,83.65 226.22,85.76 v1(224.65,85.76)
  BOTTOM w0.102: v1(237.96,63.05) 238.01,63.11 PU704.2 239.77,63.11 v2(239.86,63.02) ; U46.A50 224.02,84.52 224.54,85.05 224.54,85.66 v1(224.65,85.76) 224.85,85.96 226.63,85.96 227.52,85.08 227.52,82.59 227.24,82.31 226.04,82.31 225.69,82.66 225.69,82.97 225.43,83.23 RP1.6
PS2_CLK_TS: length 200.5
  TOP w0.102: v1(175.55,110.5) JKB1.4 JKB1.3 ; JIO1.118 v1(14.36,76.2)
  IN2 w0.127: v1(14.36,76.2) 14.05,75.9 14.05,75.42 14.33,75.14 14.72,75.14 16.14,76.57 19.45,76.57 20.09,77.2 29.25,77.2 29.62,76.83 36.11,76.83 36.51,77.23 44.65,77.23 44.83,77.05 46.48,77.05 47.24,76.29 50.56,76.29 52.23,77.96 53.01,77.96 53.65,78.6 57.35,78.6 58.74,79.98 69.92,79.98 71.79,81.85 83.75,81.85 89.26,87.36 96.17,87.36 99.15,90.35 116.34,90.35 117.75,91.76 131.36,91.76 135.66,96.05 144.46,96.05 145.38,95.13 158.68,95.13 161.65,92.16 172.63,92.16 173.11,91.68 v1(173.11,91.68)
  BOTTOM w0.102: v1(175.55,110.5) 175.97,110.08 175.97,109.12 169.49,102.64 v2(169.49,102.27) 169.49,96.85 172.7,93.64 172.7,92.09 173.11,91.68 v1(173.11,91.68)
PS2_DAT_TS: length 199.5
  TOP w0.102: v1(14.97,76.21) 14.38,76.8 JIO1.116 ; JKB1.5 JKB1.6 175.5,111.5 v1(175.42,111.42)
  IN2 w0.127: v1(173.16,92.26) 172.98,92.44 161.73,92.44 158.78,95.39 145.48,95.39 144.57,96.3 135.55,96.3 131.26,92.01 117.64,92.01 116.26,90.63 99.07,90.63 96.06,87.62 88.78,87.62 83.6,82.43 71.26,82.43 69.07,80.25 58.64,80.25 57.25,78.85 53.55,78.85 52.91,78.21 52.12,78.21 50.45,76.54 47.35,76.54 46.58,77.3 44.94,77.3 44.76,77.48 36.31,77.48 35.92,77.09 29.72,77.09 29.35,77.46 19.98,77.46 19.35,76.82 15.58,76.82 v1(14.97,76.21)
  BOTTOM w0.102: v1(173.16,92.26) 173.16,93.5 169.82,96.84 v2(169.82,99.86) 169.82,102.65 176.21,109.03 176.21,110.75 175.55,111.42 v1(175.42,111.42)
PS_ID: length 240.3
  TOP w0.102: PU1.4 3.81,83.88 v1(3.48,83.54) ; v1(103.72,163.26) 103.82,163.26 v2(104.45,163.89)
  IN1 w0.109: v1(103.72,163.26) 104.89,162.09 107.33,162.09 108.07,162.82 110.86,162.82 111.88,161.81 114.67,161.81 115.99,160.49 115.99,156.8 118.91,153.88 118.91,149.9 117.76,148.75 117.76,144.78 115.22,142.23 115.22,139.78 118.7,136.29 118.7,133.21 124.16,127.75 124.16,123.35 123.21,122.4 123.21,112.15 125.3,110.06 125.3,101.49 127.64,99.15 128.43,99.15 130.26,97.32 135.37,97.32 v1(135.47,97.22)
  IN2 w0.127: v1(135.47,97.22) 135.39,97.14 135.39,96.78 130.87,92.26 117.54,92.26 116.15,90.88 98.97,90.88 95.96,87.87 88.68,87.87 83.49,82.69 70.29,82.69 68.1,80.5 58.54,80.5 57.14,79.11 53.44,79.11 52.8,78.46 50.77,78.46 49.28,76.97 48.38,76.97 47.8,77.56 45.04,77.56 44.87,77.73 36.21,77.73 35.81,77.34 29.83,77.34 29.46,77.71 19.88,77.71 19.24,77.07 12.88,77.07 6.4,83.55 3.49,83.55 v1(3.48,83.54)
  BOTTOM w0.102: U51.A55 103,162.54 v1(103.72,163.26)
PSATA_PRX_DTX_N0: length 6.9
  TOP w0.102: JSATA1.5 170.33,52.18 169.77,52.74 169.25,52.74 168.91,53.08 v3(168.91,53.4) 168.91,54.43 168.61,54.72 168.38,54.72 168.37,54.71 167.84,54.71 167.83,54.72 167.56,54.72 167.38,54.54 167.38,54.11 C385.1
PSATA_PRX_DTX_N0_C: length 169.8
  TOP w0.102: v1(44.89,90.48) 45.08,90.67 45.08,91.36 43.95,92.49 43.33,92.49 42.92,92.9 42.45,92.9 UH1.BC8 ; C385.2 167.48,52.61 167.48,52.2 v1(167.56,52.12)
  IN4 w0.117: v1(44.89,90.48) 45.05,90.64 45.05,91.05 45.36,91.36 47.08,91.36 47.81,92.09 51.22,92.09 52.77,93.64 55.57,93.64 57.69,95.77 65.03,95.77 65.7,96.44 69.15,96.44 70.41,97.7 82.03,97.7 82.23,97.5 106.51,97.5 107.37,96.64 116.13,96.64 117.72,95.06 129.29,95.06 130.07,94.28 158.55,94.28 166.82,86.01 166.82,73.65 167.25,73.21 167.25,70.61 166.82,70.17 166.82,55.13 167.48,54.47 167.48,52.2 v1(167.56,52.12)
PSATA_PRX_DTX_P0: length 7.2
  TOP w0.102: JSATA1.6 170.3,53.45 169.81,52.96 169.34,52.96 169.13,53.16 169.13,53.67 169.12,53.68 169.12,54.52 168.7,54.94 v3(168.11,54.94) 167.47,54.94 167.17,54.63 167.17,54.09 C386.1
PSATA_PRX_DTX_P0_C: length 169.5
  TOP w0.102: C386.2 167.03,53.05 167.22,53.05 167.27,53 167.27,52.41 v1(166.98,52.12) ; UH1.BE8 43.34,93.09 43.54,93.09 43.61,93.03 43.61,92.76 43.66,92.71 44.04,92.71 44.79,91.96 44.79,91.96 45.3,91.45 45.3,90.59 45.4,90.48 v1(45.53,90.48)
  IN4 w0.117: v1(166.98,52.12) 167.25,52.39 167.25,54.37 166.58,55.04 166.58,70.27 167.02,70.71 167.02,73.12 166.58,73.55 166.58,85.91 158.45,94.04 129.98,94.04 129.2,94.82 117.62,94.82 116.04,96.4 107.27,96.4 106.42,97.26 82.13,97.26 81.93,97.46 70.51,97.46 69.25,96.2 65.8,96.2 65.13,95.53 57.79,95.53 55.66,93.41 52.87,93.41 51.31,91.85 47.91,91.85 47.18,91.12 45.45,91.12 45.28,90.95 45.28,90.63 45.43,90.48 v1(45.53,90.48)
PSATA_PTX_DRX_N0: length 5.4
  TOP w0.102: C384.1 168.17,50.8 168.45,50.8 168.86,50.39 v3(168.86,50.11) 168.86,49.22 168.94,49.13 169.48,49.13 169.98,49.64 JSATA1.3
PSATA_PTX_DRX_N0_C: length 180
  TOP w0.102: v1(166.54,48.89) 166.14,49.29 166.14,49.45 166.05,49.54 166.05,50.51 166.45,50.91 166.66,50.91 C384.2 ; v1(40.64,92.18) 40.72,92.26 UH1.AW8
  IN4 w0.117: v1(40.64,92.18) 40.7,92.24 40.7,92.62 41.08,93.01 41.36,93.01 42.58,94.23 48.01,94.23 48.65,93.58 50.61,93.58 51.74,94.72 51.74,95.36 52.13,95.75 52.68,95.75 53.3,95.13 55.81,95.13 57.31,96.63 64.62,96.63 65.29,97.3 68.54,97.3 70.14,98.9 73.9,98.9 73.97,98.97 106.87,98.97 108.34,97.5 116.92,97.5 118.45,95.97 130.89,95.97 131.73,95.14 159.61,95.14 167.68,87.07 167.68,79 168.37,78.32 168.37,55.1 168.49,54.98 168.49,49.98 167.4,48.89 v1(166.54,48.89)
PSATA_PTX_DRX_P0: length 5.4
  TOP w0.102: JSATA1.2 169.99,48.37 169.46,48.89 v3(169.22,48.89) 168.88,48.89 168.64,49.13 168.64,49.83 168.63,49.85 168.63,50.31 168.36,50.58 168.13,50.58 C383.1
PSATA_PTX_DRX_P0_C: length 179.8
  TOP w0.102: C383.2 167.09,50.46 167.09,50.63 167.03,50.7 166.54,50.7 166.26,50.42 166.26,49.63 166.38,49.51 v1(166.54,49.51) ; v1(41.23,92.19) 41.17,92.19 40.94,92.42 40.94,92.56 41,92.62 41.52,92.62 41.61,92.71 41.61,92.83 41.64,92.86 41.64,92.95 41.56,93.03 41.42,93.03 UH1.AY8
  IN4 w0.117: v1(166.54,49.51) 166.93,49.12 167.3,49.12 168.26,50.08 168.26,54.88 168.13,55.01 168.13,78.22 167.45,78.9 167.45,86.98 159.52,94.91 131.63,94.91 130.8,95.74 118.35,95.74 116.82,97.27 108.24,97.27 106.77,98.73 74.06,98.73 74,98.66 70.24,98.66 68.64,97.06 65.39,97.06 64.72,96.4 57.41,96.4 55.91,94.9 53.2,94.9 52.58,95.51 52.23,95.51 51.98,95.26 51.98,94.62 50.7,93.35 48.56,93.35 47.91,93.99 42.68,93.99 41.46,92.77 41.18,92.77 40.94,92.53 40.94,92.43 41.18,92.19 v1(41.23,92.19)
PSID_DISABLE#: length 235.2
  TOP w0.102: PR13.2 v1(4.89,80.4)
  IN2 w0.127: v1(177.41,90.66) 177.3,90.56 175.7,90.56 175.01,91.25 172.37,91.25 171.71,91.91 161.54,91.91 158.57,94.88 145.27,94.88 144.36,95.79 135.85,95.79 131.56,91.5 117.85,91.5 116.44,90.09 99.26,90.09 96.27,87.11 89.37,87.11 83.85,81.6 72.55,81.6 70.68,79.73 58.84,79.73 57.46,78.34 53.76,78.34 53.12,77.7 52.33,77.7 50.66,76.03 47.14,76.03 46.37,76.79 44.73,76.79 44.55,76.97 36.61,76.97 36.22,76.58 29.51,76.58 29.14,76.95 20.19,76.95 19.56,76.31 16.24,76.31 14.82,74.89 14.23,74.89 8.72,80.4 v1(4.89,80.4)
  BOTTOM w0.102: v1(177.41,90.66) 177.41,92.24 181.56,96.39 182.04,96.39 182.63,96.99 191.78,96.99 193.4,95.36 204.61,95.36 209.15,90.82 v2(213.05,90.82) 214.23,90.82 215.83,89.22 215.83,87.39 216.17,87.05 U46.A37
PWM3: length 85.5
  TOP w0.203: PR523.2 51.9,31.33 51.9,30.58 51.57,30.25 51.57,29.7 52.05,29.22 52.05,29.04 52.33,28.77 PU500.22
  TOP w0.254: PR523.2 51.37,32.23 50.87,32.73 v1(49.51,32.73)
  IN1 w0.109: v1(49.51,32.73) 47.1,30.31 47.1,24.89 v1(46.66,24.45)
  IN4 w0.109: v1(46.66,24.45) 46.48,24.45 41.6,29.33 41.6,32.67 40.61,33.66 40.61,37.8 39.28,39.13 39.28,42.76 38.16,43.88 38.16,45.94 38.85,46.62 38.85,48.95 40.89,50.99 40.89,53.94 38.52,56.31 38.52,65.78 35.98,68.32 35.98,76.59 v1(38.57,79.18)
  BOTTOM w0.102: PU501.3 40.47,74.16 38.57,76.06 v2(38.57,77.73) v1(38.57,79.18)
PWR_SRC_ON: length 1.2
  BOTTOM w0.102: R422.2 53.01,158.98 v2(52.39,159.59)
PWRSHARE_EN#: length 4.3
  BOTTOM w0.102: U45.5 255.83,98.52 255.63,98.32 255.63,97.81 R816.1 ; R816.1 254.42,96.59 Q55.1 ; R816.1 256.33,97.6 v2(256.41,97.69)
RED_CRT: length 17.3
  TOP w0.102: v1(75.09,162.55) 74.49,162.55 73.3,163.74 73.3,164.02 C20.1 R53.1 71.65,165.28 L1.1
  BOTTOM w0.102: U19.33 82.6,163.58 81.96,164.22 76.37,164.22 v2(75.71,163.55) 75.09,162.94 v1(75.09,162.55)
RED_CRT_L: length 7.1
  TOP w0.102: L1.2 v2(72.09,167.4) 72.09,171.66 72.01,171.74 JCRT1.1
RED_DOCK: length 52.5
  TOP w0.102: v1(79.61,156.98) 79.64,156.98 80.25,157.59 83.32,157.59 85.71,155.2 v2(85.71,153.78) 85.71,153.35 86.14,152.92 86.14,142.07 88.18,140.02 88.18,136.99 89.3,135.88 89.64,135.88 90.89,134.62 90.89,132.36 92.85,130.41 92.85,124.37 89.39,120.92 89.39,120.81 87.82,119.24 87.36,119.24 v1(87.05,119.54)
  BOTTOM w0.102: JDOCK1.53 87.2,119.4 v1(87.05,119.54) ; U19.24 80.21,157.55 79.64,156.98 v1(79.61,156.98)
REGCTL_PNP10: length 3.9
  TOP w0.102: L29.1 123.99,156.26 v2(124.04,156.31)
  TOP w0.508: L29.1 122.39,156.05 122.39,155.08 v1(122.56,154.9)
  BOTTOM w0.203: U31.7 122.54,154.88 v1(122.56,154.9)
REM_DIODE1_N: length 120.4
  TOP w0.254: C1343.1 108.21,154.29 107.3,154.29 v1(107.04,154.04) ; Q26.3 90.03,54.29 C339.2 v1(90.03,52.87)
  IN1 w0.254: v1(90.03,52.87) 89.77,53.12 89.77,54.03 87.56,56.24 87.56,67.9 88.65,69 88.65,79.08 92.79,83.22 92.79,88.4 96.49,92.1 96.49,94.44 95.89,95.03 95.89,104.28 97.27,105.65 97.27,106.82 98.92,108.47 98.92,114.56 99.65,115.3 99.65,126.83 98.76,127.72 98.76,130.13 99.39,130.76 99.39,134.57 98.74,135.21 98.74,146.92 100.16,148.35 100.16,150.41 101.53,151.78 102.24,151.78 102.7,152.23 102.7,153.93 103.54,154.77 103.54,154.77 103.59,154.82 106.52,154.82 107.04,154.3 v1(107.04,154.04)
  BOTTOM w0.254: v1(107.04,154.04) 107.04,154.14 107.43,154.52 U51.B13
REM_DIODE1_N_4021: length 100.3
  TOP w0.254: U29.23 170.32,129 C271.2 170.14,128.79 170.42,128.51 170.42,128 v1(170.26,127.85) ; Q16.3 91.29,112.92 C273.2 90.81,113.12 v1(90.46,113.47)
  IN4 w0.254: v1(170.26,127.85) 170.39,127.98 170.39,128.23 170.19,128.43 164.93,128.43 164.12,129.25 148.27,129.25 146.06,127.04 146.06,117.56 145.02,116.52 142.6,116.52 139.68,113.6 129.67,113.6 126.99,116.28 123.19,116.28 120.51,113.6 90.59,113.6 v1(90.46,113.47)
REM_DIODE1_P: length 124.4
  TOP w0.254: v1(89.11,52.87) C339.1 89.11,54.29 Q26.2 88.92,55.68 Q26.1 ; C1343.2 109.89,154.21 v1(109.91,154.24)
  IN1 w0.254: v1(109.91,154.24) 109.91,154.25 109.9,154.26 109.89,154.26 109.76,154.39 107.45,154.39 106.66,155.18 103.44,155.18 102.35,154.08 102.35,152.38 102.1,152.13 101.38,152.13 99.81,150.56 99.81,148.49 98.38,147.07 98.38,135.07 99.03,134.42 99.03,130.9 98.41,130.28 98.41,127.57 99.3,126.69 99.3,115.45 98.56,114.71 98.56,108.62 96.91,106.96 96.91,105.8 95.54,104.42 95.54,94.88 96.13,94.29 96.13,92.25 92.44,88.55 92.44,83.37 88.3,79.23 88.3,69.14 87.21,68.05 87.21,56.09 89.42,53.88 89.42,53.17 v1(89.11,52.87)
  BOTTOM w0.254: v1(109.91,154.24) 109.91,154.25 109.9,154.26 109.89,154.26 109.88,154.27 U51.A13
REM_DIODE1_P_4021: length 102.9
  TOP w0.254: U29.24 170.82,129.05 C271.1 170.77,128.53 170.77,127.98 v1(170.9,127.85) ; Q16.1 92.85,113.57 Q16.2 91.29,114.22 C273.1 90.97,114.16 v1(90.46,114.16)
  IN4 w0.254: v1(170.9,127.85) 170.75,128 170.75,128.38 170.34,128.79 165.08,128.79 164.27,129.6 148.12,129.6 145.7,127.18 145.7,117.71 144.87,116.88 142.45,116.88 139.53,113.96 129.82,113.96 127.14,116.63 123.05,116.63 120.37,113.96 90.66,113.96 v1(90.46,114.16)
REM_DIODE2_N: length 110.7
  TOP w0.254: Q17.3 119.3,71.67 C340.2 119.19,72.25 118.97,72.47 118.97,86.71 113.82,91.86 113.32,91.86 v1(113.19,91.98) ; C1350.1 108.16,153.33 107.7,153.78 v1(107.7,153.79)
  IN1 w0.254: v1(107.7,153.79) 108.61,153.79 109.23,153.17 110.12,153.17 110.45,152.85 110.45,152.48 109.21,151.24 107.76,151.24 107.35,150.84 105.95,150.84 104.99,149.87 104.99,149.23 103.87,148.12 101.97,148.12 100.11,146.26 100.11,139.06 103.01,136.16 103.01,129.96 102.5,129.45 102.5,125.48 102.93,125.05 102.93,119.17 104.35,117.74 104.35,111.88 105.11,111.12 105.11,108.97 102.83,106.69 102.83,103.08 107.5,98.41 107.5,97.35 110.83,94.02 113.55,94.02 114.97,92.6 114.97,91.88 114.69,91.6 114.08,91.6 113.88,91.81 113.37,91.81 v1(113.19,91.98)
  BOTTOM w0.254: v1(107.7,153.79) 107.93,154.02 U51.B14
REM_DIODE2_N_4021: length 133.2
  TOP w0.254: U29.26 173.61,132.01 C315.1 173.68,131.51 v1(173.26,131.51)
  IN4 w0.254: v1(173.26,131.51) 173.26,131.94 173.06,132.14 172.61,132.14 171.56,133.19 171.56,134.64 170.5,135.7 167.12,135.7 163.25,139.56 154.5,139.56 151.77,142.28 151.77,148.25 149.56,150.45 149.56,151.7 149.06,152.21 147.33,152.21 146.67,151.55 140.17,151.55 133.97,157.74 133.13,157.74 132.34,158.53 132.34,158.77 130.93,160.18 128.02,160.18 127.01,161.2 116.29,161.2 114.9,162.6 112.07,162.6 110.75,161.27 96.58,161.27 93.89,158.58 93.89,151.42 93.4,150.94 93.4,146.48 91.44,144.51 91.44,141.4 91.75,141.08 92.24,141.08 v1(92.35,141.2)
  BOTTOM w0.254: v1(92.35,141.2) 92.26,141.11 86.71,141.11 v2(86.3,141.51) 85.87,141.95 85.27,141.95 C291.2 84.34,142.23 84.14,142.42 Q27.3
REM_DIODE2_P: length 109.4
  TOP w0.254: v1(110.09,153.66) 109.76,153.33 C1350.2 ; Q17.2 118,70.16 Q17.1 118.27,71.19 C340.1 118.27,72.25 118.55,72.53 118.55,86.62 113.67,91.5 113.42,91.5 v1(113.22,91.3)
  IN1 w0.254: v1(110.09,153.66) 110.14,153.66 110.8,152.99 110.8,152.33 109.36,150.89 107.91,150.89 107.5,150.48 106.1,150.48 105.34,149.72 105.34,149.08 104.02,147.76 102.12,147.76 100.47,146.11 100.47,139.2 103.36,136.31 103.36,129.81 102.85,129.31 102.85,125.63 103.29,125.2 103.29,119.31 104.71,117.89 104.71,112.02 105.47,111.26 105.47,108.82 103.18,106.54 103.18,103.23 107.86,98.56 107.86,97.5 110.98,94.37 113.7,94.37 115.32,92.75 115.32,91.74 114.84,91.25 113.93,91.25 113.73,91.45 113.37,91.45 v1(113.22,91.3)
  BOTTOM w0.254: v1(110.09,153.66) 109.98,153.77 U51.A14
REM_DIODE2_P_4021: length 134.7
  TOP w0.254: U29.27 173.77,132.51 C315.2 173.53,133.01 v1(173.26,133.01)
  IN4 w0.254: v1(173.26,133.01) 173.26,132.62 173.14,132.5 172.75,132.5 171.92,133.34 171.92,134.78 170.65,136.05 167.26,136.05 163.4,139.91 154.64,139.91 152.13,142.43 152.13,148.39 149.92,150.6 149.92,151.85 149.2,152.56 147.18,152.56 146.52,151.9 140.31,151.9 134.12,158.1 133.28,158.1 132.7,158.68 132.7,158.91 131.07,160.54 128.17,160.54 127.16,161.55 116.44,161.55 115.05,162.95 111.93,162.95 110.6,161.63 96.43,161.63 93.53,158.73 93.53,151.57 93.05,151.08 93.05,146.63 91.08,144.66 91.08,141.25 91.61,140.73 92.24,140.73 v1(92.35,140.61)
  BOTTOM w0.254: Q27.2 82.82,141.77 Q27.1 84.47,141.31 C291.1 85.28,141.59 85.63,141.59 86.49,140.73 92.23,140.73 v1(92.35,140.61)
REM_DIODE3_N: length 123.5
  TOP w0.254: v1(109.91,152.66) 109.69,152.44 C1351.1
  IN1 w0.254: v1(118.37,91.07) 118.19,90.89 116.63,90.89 116.42,90.69 106.28,90.69 105.6,91.37 105.6,96.05 104.94,96.71 104.94,100.19 101.61,103.52 101.61,106.89 103.41,108.7 103.41,112.48 102.09,113.8 102.09,124.57 101.15,125.51 101.15,134.14 100.3,134.99 100.3,137.93 99.6,138.63 99.6,146.52 101.56,148.48 101.56,150.56 101.86,150.86 104.12,150.86 104.68,151.42 107.07,151.42 107.4,151.75 108.62,151.75 108.92,152.06 108.92,152.49 109.1,152.66 v1(109.91,152.66)
  BOTTOM w0.254: v1(109.91,152.66) 109.91,152.94 109.59,153.27 U51.A15 ; Q14.3 124.66,62.17 124.54,62.29 124.54,63 C272.2 124.82,63.74 124.54,64.02 124.54,84.13 123.68,84.99 v2(123.68,86.85) 123.68,87.94 122.89,88.73 122.89,90.58 122.1,91.37 120.07,91.37 119.57,90.87 118.58,90.87 v1(118.37,91.07)
REM_DIODE3_P: length 125.2
  TOP w0.254: v1(107.65,152.66) 107.88,152.44 C1351.2
  IN1 w0.254: v1(118.4,90.36) 118.22,90.54 116.77,90.54 116.57,90.33 106.13,90.33 105.24,91.22 105.24,95.9 104.58,96.56 104.58,100.04 101.25,103.37 101.25,107.04 103.06,108.84 103.06,112.33 101.74,113.66 101.74,124.42 100.8,125.36 100.8,133.99 99.94,134.84 99.94,137.79 99.25,138.48 99.25,146.67 101.2,148.63 101.2,150.71 101.71,151.22 103.98,151.22 104.53,151.78 106.92,151.78 107.25,152.11 108.47,152.11 108.57,152.2 108.57,152.54 108.44,152.66 v1(107.65,152.66)
  BOTTOM w0.254: v1(107.65,152.66) 107.76,152.66 108.11,153.02 U51.B16 ; v1(118.4,90.36) 118.55,90.51 119.71,90.51 120.22,91.02 121.95,91.02 122.54,90.43 122.54,88.58 123.27,87.84 123.27,84.9 124.19,83.98 124.19,64.02 123.91,63.74 C272.1 123.96,63.28 124.19,63.05 124.19,62.29 124.07,62.17 Q14.2 124.37,61.52 Q14.1
REM_DIODE4_N: length 220.1
  TOP w0.254: v1(62.54,35.03) 62.4,34.89 61.95,34.89 61.5,34.45 61.5,33.19 69.46,25.23 75.45,25.23 79.22,21.46 85.85,21.46 87.85,23.47 93.87,23.47 94.55,24.15 94.55,27.62 92.92,29.25 92.92,33.92 95.96,36.97 111.13,36.97 120.3,46.14 120.3,89.96 120.94,90.59 120.94,92.77 v1(121.12,92.95)
  IN1 w0.254: v1(114.84,150) 114.69,149.85 114.69,149.57 113.93,148.8 113.93,144.57 112.68,143.32 112.68,138.16 111.54,137.02 111.54,135.21 121.01,125.74 121.01,112.1 117.43,108.52 117.43,104.78 118.55,103.66 118.55,96.58 120.9,94.23 120.9,93.17 v1(121.12,92.95)
  BOTTOM w0.254: Q15.3 56.82,43.28 C335.2 C288.2 56.82,41.95 60.1,41.95 62.01,40.04 62.01,35.08 62.16,34.94 62.44,34.94 v1(62.54,35.03) ; U51.A16 109.2,152.49 109.58,152.11 111.77,152.11 C1346.1 112.35,152.08 113.01,152.08 114.69,150.4 114.69,150.15 v1(114.84,150)
REM_DIODE4_P: length 219.9
  TOP w0.254: v1(62.54,34.4) 62.41,34.54 62.1,34.54 61.86,34.3 61.86,33.34 69.6,25.59 75.59,25.59 79.37,21.82 85.7,21.82 87.71,23.82 93.72,23.82 94.19,24.29 94.19,27.44 92.57,29.07 92.57,34.07 95.82,37.32 110.99,37.32 119.95,46.28 119.95,90.1 120.58,90.74 120.58,92.72 v1(120.35,92.95)
  IN1 w0.254: v1(114.21,150) 114.33,149.87 114.33,149.71 113.57,148.95 113.57,144.71 112.33,143.47 112.33,138.31 111.18,137.17 111.18,135.07 120.66,125.59 120.66,112.25 117.08,108.67 117.08,104.63 118.19,103.52 118.19,96.43 120.54,94.08 120.54,93.14 v1(120.35,92.95)
  BOTTOM w0.254: U51.B17 108.66,152.52 109.43,151.75 111.77,151.75 C1346.2 112.3,151.72 112.86,151.72 114.33,150.25 114.33,150.12 v1(114.21,150) ; Q15.2 55.52,44.82 Q15.1 56.17,43.55 C335.1 C288.1 56.26,41.59 59.95,41.59 61.65,39.89 61.65,34.94 62.01,34.58 62.37,34.58 v1(62.54,34.4)
RES_BIAS: length 3.5
  BOTTOM w0.102: U31.12 124.54,154.38 124.75,154.6 v2(126.4,154.6) R562.1
RESET_OUT#: length 383.2
  TOP w0.102: v1(26.75,93.41) 26.56,93.59 UH1.F10 ; v1(13.67,112.38) 14.18,112.38 14.72,111.85 18.11,111.85 19.85,113.58 RH27.1 ; v1(100.39,154.72) 99.93,155.18 98.37,155.18 97.83,154.65 96.3,154.65 R843.2 96.44,153.89 Q52.2 95.75,153.88 92.31,153.88 90.97,155.23 90.97,158.84 90.38,159.42 v1(90.38,166.81)
  IN1 w0.109: v1(90.38,166.81) 89.24,167.96 72.22,167.96 69.53,165.26 63.23,165.26 59.33,161.37 55.21,161.37 52.84,163.74 52.84,164.79 49.8,167.83 45.28,167.83 44.87,167.41 27.97,167.41 26.25,165.69 25.31,165.69 25.03,165.97 21.6,165.97 20.97,165.34 18.68,165.34 14.47,161.13 14.47,155.93 12.97,154.42 12.97,143.63 14.54,142.05 14.54,133.7 13.34,132.5 13.34,125.44 15.85,122.93 15.85,118.62 16.42,118.05 16.42,116.26 14.16,113.99 14.16,112.86 v1(13.67,112.38) ; v1(39.53,83.3) 39.84,82.99 39.84,79.6 38.64,78.4 38.64,75.54 38.05,74.96 38.05,68.47 40.1,66.42 40.1,57.09 42.42,54.77 42.42,50.3 39.65,47.54 39.65,39.81 46.62,32.84 46.62,29.03 45.59,28 45.59,26.81 46.2,26.2 46.2,24.3 50.46,20.05 52.15,20.05 v1(52.92,19.29)
  IN2 w0.127: v1(38.82,86.84) 38.31,87.35 36.03,87.35 35.42,87.96 30.81,87.96 30.14,87.29 29.35,87.29 28.28,88.36 28.28,89.57 26.96,90.89 26.96,91.37 26.98,91.4 26.98,91.7 26.45,92.24 26.45,93.12 v1(26.75,93.41)
  IN4 w0.109: v1(13.67,112.38) 13.66,112.38 13.12,111.84 13.12,111.48 12.67,111.03 12.67,108.49 11.32,107.13 11.32,104.04 12.12,103.23 12.12,101.3 12.85,100.57 12.85,93.68 13.81,92.72 14.67,92.72 15.06,93.11 16.1,93.11 16.87,92.35 16.87,91.16 18.54,89.5 18.54,88.99 21.74,85.79 24.65,85.79 24.91,85.53 25.53,85.53 25.95,85.11 31.43,85.11 31.67,84.87 34.79,84.87 35.14,84.52 38.79,84.52 39.53,83.78 v1(39.53,83.3)
  BOTTOM w0.102: RC73.1 89.26,33.13 87.74,31.61 87.74,31.55 84.69,28.5 84.37,28.5 78.61,22.73 78.61,19.64 77.16,18.2 77.16,11.69 76.65,11.19 76.07,11.19 73.38,8.49 61.11,8.49 58.75,10.86 58.75,13.46 v1(52.92,19.29) ; v1(38.82,86.84) 38.82,86.69 39.98,85.53 40.12,85.53 40.24,85.41 40.24,83.69 39.85,83.3 v1(39.53,83.3) 39.53,82.38 39.91,82 v4(39.91,81.07) ; v1(100.39,154.72) 100.39,154.67 100.01,154.29 99.63,154.29 99.4,154.52 U51.B39
RESET_OUT#_R: length 3.1
  TOP w0.102: JXDP2.46 21.3,116.02 19.95,114.67 RH27.2
REXT3: length 2.9
  TOP w0.102: U9.27 18.23,154.93 18.2,154.9 17.61,154.9 v2(17.24,155.27) 17.03,155.48 R74.2
RF_+1.05VSP: length 2.8
  BOTTOM w0.102: v2(23.57,148.23) 24.04,147.76 PR305.1
  BOTTOM w0.254: PU300.5 24.02,147.17 PR305.1
RSMRST#: length 8
  TOP w0.102: v2(141.3,140.52) 141.56,140.79 R1622.1 R1630.1 142.35,141.69 144.19,141.69 144.34,141.54 U7.2 144.34,139.98 143.96,139.6 143.96,138.61 U4.3
RSMRST#_XDP: length 8
  TOP w0.102: v1(23.3,124.9) 22.8,124.4 JXDP2.39
  BOTTOM w0.102: v1(23.3,124.9) 22.69,124.29 22.69,122.64 22.31,122.26 21.5,122.26 RH26.2 20.99,122.15 v2(20.62,121.78)
RUN_ON: length 526.4
  TOP w0.102: v1(216.67,75.09) 219.06,72.71 221.2,72.71 222.11,71.79 225.39,71.79 v1(226.83,70.35) ; JIO1.87 7.12,85.2 v1(5.93,86.4) ; v1(59.98,79.31) 59.98,81.75 58.33,83.4 58.33,90.26 55.31,93.28 55.15,93.28 52.36,96.07 52.36,97.5 52.94,98.08 53.98,98.08 55.14,99.25 55.14,99.49 55.94,100.28 55.94,102.11 52.15,105.9 52.13,105.9 49.14,108.89 49.14,110.22 49.34,110.41 49.34,111.98 48.47,112.85 48.47,114.45 49.02,115 53.1,115 56.82,118.71 56.82,130.01 57.33,130.52 57.33,132.11 Q304.2 55.3,130.91 47.3,130.91 v1(47.09,130.69)
  IN1 w0.109: v1(89.19,136.59) 89.19,136.8 88.48,137.5 88.48,140.95 v1(86.72,142.71) ; v1(216.67,75.09) 216.09,75.67 213.04,75.67 212.48,76.24 209.08,76.24 208.59,76.72 203.46,76.72 197.52,82.66 185.34,82.66 179.75,88.25 179.75,92.14 174.55,97.33 172.14,97.33 158.91,110.56 158.91,113.08 156.04,115.95 156.04,117.55 155.88,117.71 155.88,118.89 155.15,119.62 155.15,123.73 152.38,126.5 151.95,126.5 151.35,127.09 151.35,129.23 137.84,142.74 v1(137.84,142.78)
  IN2 w0.127: v1(91.97,151.66) 92.79,150.84 92.79,149.15 90.84,147.19 90.84,146.71 86.84,142.71 v1(86.72,142.71) 85.75,141.73 78.39,141.73 77.21,140.55 74.3,140.55 65.96,132.2 48.81,132.2 47.3,130.69 v1(47.09,130.69) ; v1(5.93,86.4) 5.5,86.83 5.5,87.79 5.98,88.28 6.87,88.28 7.63,89.04 7.63,112.91 9.2,114.49 10.45,114.49 13.14,117.18 13.14,122.79 v1(12.66,123.28)
  IN3 w0.127: v1(87.59,160.28) 89.77,158.1 89.77,153.86 v1(91.97,151.66) 93.35,150.28 93.35,149.67 94.95,148.07 96.86,148.07 97.76,147.17 98.26,147.17 101.12,144.31 103.56,144.31 103.95,144.7 108.49,144.7 108.76,144.42 113.8,144.42 114.06,144.69 118.77,144.69 120.28,143.18 131.84,143.18 133.67,145.01 135.62,145.01 v1(137.84,142.78) ; v1(12.66,123.28) 12.66,124.39 14.46,126.2 15.99,126.2 18.35,123.84 21.01,123.84 23.55,126.38 27.14,126.38 27.49,126.02 33.54,126.02 34.63,127.11 39.68,127.11 39.9,127.33 39.9,129.93 40.19,130.22 46.61,130.22 v1(47.09,130.69) ; v1(261.45,38.87) 261.5,38.92 263.8,38.92 270.66,45.78 270.66,62.63 268.77,64.53 259.34,64.53 258.69,65.17 255.67,65.17 253.7,63.21 251.34,63.21 249.82,64.73 244.99,64.73 243.92,65.8 229.5,65.8 226.35,68.95 226.35,69.86 v1(226.83,70.35)
  BOTTOM w0.102: v1(226.83,70.35) 227.23,70.75 228.08,70.75 228.26,70.57 RP4.2 ; v1(261.45,38.87) 261.45,38.36 260.66,37.58 PR406.1 ; v1(87.59,160.28) v2(87.23,159.92) 86.95,159.65 86.7,159.65 86.6,159.55 U19.2 ; v1(59.98,79.31) 57.92,79.31 57.16,78.55 52.31,78.55 51.7,79.16 49.92,79.16 49.67,78.9 49.67,77.73 49.28,77.35 49.28,74 49.77,73.52 50.55,73.52 50.94,73.9 U37.3 ; v1(89.19,136.59) 88.87,136.59 87.54,135.25 R15.1 ; v1(216.67,75.09) 216.67,75.09 U46.A11
RUN_ON_ENABLE#: length 72.4
  TOP w0.102: v1(45.12,134.86) 45.12,134.12 46.49,132.75 51.48,132.75 53.29,134.55 54.15,134.55 54.73,135.14 R909.2 55.55,135.14 Q304.6 Q304.5
  IN2 w0.127: v1(45.12,134.86) 45.12,134.49 46,133.61 66.29,133.61 73.44,140.77 73.44,141.11 74.43,142.1 74.52,142.1 77.17,144.75 79.28,144.75 79.56,145.03 86.41,145.03 v1(87.07,144.37)
  BOTTOM w0.102: Q45.2 94.11,144.67 93.89,144.89 v2(89.82,144.89) 87.59,144.89 v1(87.07,144.37)
RUNPWROK: length 204.3
  TOP w0.102: v1(104.07,153.1) 103.97,152.99 103.97,151.66 104.05,151.59 104.05,148.52 102.85,147.32 102.85,146.8 v1(101.08,145.02)
  IN1 w0.109: v1(101.08,145.02) 101.2,144.89 101.2,143.8 102.79,142.21 102.79,137.87 104.4,136.26 104.4,129.07 105.29,128.18 105.29,124.69 104.35,123.75 104.35,119.46 106.78,117.03 106.78,108.82 104.68,106.72 104.68,102.83 109.2,98.31 109.2,97.62 111.64,95.18 113.88,95.18 117,92.06 118.4,92.06 118.86,91.6 123.03,91.6 125.09,93.66 158.09,93.66 158.56,93.2 165.6,93.2 177.13,81.68 181.23,81.68 183.42,79.49 195.29,79.49 204.69,70.09 216.8,70.09 218.42,71.71 219.77,71.71 220.28,72.22 v1(220.28,72.25)
  BOTTOM w0.102: v1(101.08,145.02) 100.77,145.32 Q45.1 ; v1(220.28,72.25) 220.28,72.12 220.24,72.16 220.24,75.25 220.17,75.32 U46.A4 ; v1(104.07,153.1) 103.75,152.77 U51.B26 ; Q45.1 v4(95.45,145.32) 92.49,145.32 92.24,145.58 U50.2 ; Q45.1 98.79,145.37 R799.2
S3_1.35V: length 3.8
  BOTTOM w0.102: PU200.7 177.49,79.12 176.82,79.79 176.31,79.79 v2(176.02,80.08) 175.8,80.3 175.8,81.24 PR208.2
S5_1.35V: length 3.8
  BOTTOM w0.102: PU200.8 177.89,79.39 177.91,79.41 PC215.1 177.91,81.32 PR240.1 PR206.2
SATA_ACT#: length 139.5
  TOP w0.102: v1(30.62,78.26) 31.9,79.54 v2(32.56,79.54) 34.98,79.54 35.29,79.84 38.51,79.84 41.21,77.15 45.75,77.15 46.39,77.79 46.39,78.53 44.33,80.59 43.81,80.59 42.66,81.75 42.66,84.63 42.51,84.77 42.51,85.31 38.72,89.11 38.72,89.91 38.69,89.94 38.69,89.95 38.51,90.13 38.51,90.38 38.46,90.43 38.46,90.43 38.41,90.49 UH1.AP3 ; Q74.4 v1(8.06,150.03)
  IN1 w0.109: v1(30.62,78.26) 29.68,79.19 29.27,79.19 28.78,79.69 24.44,79.69 24.19,79.94 21.46,79.94 16.63,84.77 12.93,84.77 12.21,85.49 6.35,85.49 5.64,84.78 3.88,84.78 3.15,85.5 3.15,90.06 3.65,90.55 3.65,91.66 5.67,93.68 5.67,97.39 8.14,99.86 8.14,112.37 12.86,117.09 12.86,121.9 9.08,125.69 9.08,127.73 10.42,129.07 10.42,129.73 9.64,130.52 9.64,131.1 10.58,132.04 10.58,133.64 11.85,134.91 11.85,141.04 8.06,144.83 v1(8.06,150.03)
SATA_COMP: length 2
  TOP w0.254: UH1.AY5 40.94,91.53 41.23,91.24 v1(41.23,91.27)
  BOTTOM w0.254: v1(41.23,91.27) 41.23,91.28 41.11,91.16 RH57.1
SATA_LED: length 79.4
  TOP w0.102: v1(8.54,145.41) 8.53,145.43 R934.2 7.58,146.05 v2(7.55,146.07) ; JIO1.98 14.25,82.2 v1(16.06,84.01)
  IN2 w0.127: v1(16.06,84.01) 16.06,83.98 15.15,83.07 13.92,83.07 12.48,84.51 12.48,90.44 11.29,91.63 11.29,92.67 10.38,93.58 10.38,94.82 8.39,96.81 8.39,110.65 9.05,111.31 9.05,113.22 9.56,113.73 10.84,113.73 13.9,116.79 13.9,123.44 11.06,126.29 11.06,133.55 12.86,135.35 12.86,141.18 8.63,145.41 v1(8.54,145.41)
SATA_ODD_PRX_DTX_N1: length 3.6
  TOP w0.102: C432.1 39.23,45.1 39.05,44.92 37.95,44.92 37.37,45.5 JODD1.5
SATA_ODD_PRX_DTX_N1_C: length 66.4
  TOP w0.102: v1(40.83,45.5) 41.03,45.3 41.03,45.1 40.85,44.91 40.6,44.91 C432.2 ; UH1.BC10 42.45,93.91 42.92,93.91 43.13,94.12 43.57,94.12 43.66,94.03 45.26,94.03 46.59,92.7 46.95,92.7 49.17,90.47 49.17,89.77 v1(49.27,89.67)
  IN4 w0.117: v1(40.83,45.5) 41.02,45.31 41.02,45.12 40.88,44.98 40.34,44.98 40.12,45.19 40.12,45.81 40.92,46.61 41.23,46.61 42.21,47.58 42.21,50.23 42.38,50.4 42.38,54.57 40,56.94 40,66.39 37.45,68.95 37.45,75.8 39.56,77.91 41.69,77.91 46.59,82.81 46.59,86.98 48.5,88.89 48.8,88.89 49.09,89.17 49.09,89.49 v1(49.27,89.67)
SATA_ODD_PRX_DTX_P1: length 3.5
  TOP w0.102: C430.1 39.23,44.53 39.05,44.71 37.95,44.71 37.47,44.23 JODD1.6
SATA_ODD_PRX_DTX_P1_C: length 66.3
  TOP w0.102: C430.2 40.6,44.7 40.94,44.7 41.25,45.01 41.25,45.29 v1(41.46,45.5) ; v1(48.68,89.67) 48.7,89.67 48.95,89.93 48.95,90.38 46.86,92.48 46.5,92.48 45.17,93.81 43.57,93.81 43.48,93.91 43.35,93.91 UH1.BE10
  IN4 w0.117: v1(48.68,89.67) 48.75,89.67 48.85,89.57 48.85,89.27 48.7,89.12 48.4,89.12 46.36,87.08 46.36,82.91 41.59,78.15 39.46,78.15 37.21,75.9 37.21,68.85 39.76,66.3 39.76,56.85 42.14,54.47 42.14,50.5 41.97,50.33 41.97,47.68 41.13,46.85 40.83,46.85 39.89,45.91 39.89,45.1 40.24,44.74 40.98,44.74 41.26,45.02 41.26,45.3 v1(41.46,45.5)
SATA_ODD_PTX_DRX_N1: length 3.6
  TOP w0.102: C434.1 39.23,48.37 39.03,48.57 37.97,48.57 37.45,48.04 JODD1.3
SATA_ODD_PTX_DRX_N1_C: length 57.6
  TOP w0.102: C434.2 40.14,48.3 40.45,48.61 40.82,48.61 41.03,48.4 41.03,48.17 v1(40.83,47.97) ; v1(40.48,93.41) 40.13,93.77 UH1.AV10
  IN3 w0.127: v1(43.72,86.95) 43.9,87.13 43.9,91.32 42.17,93.06 41.84,93.06 41.44,92.65 41.05,92.65 40.75,92.95 40.75,93.3 40.64,93.41 v1(40.48,93.41)
  IN4 w0.117: v1(40.83,47.97) 41.02,48.16 41.02,50.43 41.39,50.79 41.39,54.16 39.03,56.52 39.03,65.97 36.48,68.52 36.48,76.21 40.14,79.88 41.89,79.88 44.36,82.34 44.36,84.64 43.92,85.08 43.92,86.76 v1(43.72,86.95)
SATA_ODD_PTX_DRX_P1: length 3.5
  TOP w0.102: C433.1 39.23,48.96 39.05,48.78 38,48.78 37.48,49.31 JODD1.2
SATA_ODD_PTX_DRX_P1_C: length 57.6
  TOP w0.102: UH1.AW10 40.72,93.82 v1(41.14,93.41) ; C433.2 40.5,48.82 40.91,48.82 41.25,48.49 41.25,48.18 v1(41.46,47.97)
  IN3 w0.127: v1(44.35,86.95) 44.15,87.16 44.15,91.43 42.27,93.3 41.74,93.3 41.33,92.9 41.15,92.9 41,93.05 41,93.28 v1(41.14,93.41)
  IN4 w0.117: v1(41.46,47.97) 41.26,48.17 41.26,50.33 41.62,50.69 41.62,54.26 39.26,56.62 39.26,66.07 36.71,68.62 36.71,76.11 40.24,79.64 41.99,79.64 44.59,82.24 44.59,84.74 44.15,85.18 44.15,86.76 v1(44.35,86.95)
SATA_PRX_DKTX_N2: length 4.8
  TOP w0.102: C698.2 88.34,127.07 88.34,127.37 87.56,128.15 87.56,128.37 v1(87.77,128.57)
  BOTTOM w0.102: v1(87.77,128.57) 87.56,128.36 87.56,127.37 87.7,127.23 JDOCK1.56
SATA_PRX_DKTX_N2_C: length 74.2
  TOP w0.076: 43.43,93.29 43.41,93.29 43.39,93.31 43.15,93.31 42.93,93.09 42.68,93.09 42.36,93.41 UH1.BB9
  TOP w0.102: C698.1 88.34,125.48 88.34,124.92 87.93,124.51 83.36,124.51 80.98,122.13 80.22,122.13 v1(80.04,121.96) ; v1(45.58,91.78) 45.78,91.98 45.78,92.21 44.7,93.29 43.43,93.29
  IN3 w0.127: v1(80.04,121.96) 80.2,122.11 80.42,122.11 80.56,121.98 80.56,119.82 78.29,117.56 78.29,107.63 77.66,107 77.66,106.55 74.38,103.28 74.38,102.28 71.91,99.8 70.84,99.8 69.47,98.42 69.47,97.87 68.17,96.57 67.43,96.57 65.15,94.29 63.21,94.29 62.78,93.86 57.34,93.86 56.98,94.22 54.34,94.22 52.71,95.84 51.98,95.84 51.42,95.29 51.42,94.93 49.41,92.92 46.15,92.92 45.7,92.46 45.7,91.9 v1(45.58,91.78)
SATA_PRX_DKTX_P2: length 4.8
  TOP w0.102: C697.2 88.13,127.07 88.13,127.28 87.35,128.06 87.35,128.38 v1(87.16,128.57)
  BOTTOM w0.102: v1(87.16,128.57) 87.34,128.39 87.34,127.34 87.2,127.2 JDOCK1.54
SATA_PRX_DKTX_P2_C: length 74.1
  TOP w0.076: 43.43,93.51 43.41,93.51 43.39,93.48 43.17,93.48 43.04,93.61 42.81,93.61 42.73,93.53 42.73,93.46 UH1.BD9
  TOP w0.102: C697.1 88.13,125.48 88.13,125.01 87.84,124.72 83.27,124.72 80.89,122.35 80.16,122.35 80.04,122.46 v1(80.04,122.57) ; 43.43,93.51 44.79,93.51 46,92.3 46,91.86 46.07,91.79 v1(46.19,91.79)
  IN3 w0.127: v1(80.04,122.57) 80.04,122.49 80.17,122.36 80.53,122.36 80.81,122.08 80.81,119.72 78.54,117.46 78.54,107.53 77.91,106.9 77.91,106.45 74.63,103.18 74.63,102.17 72.01,99.55 70.95,99.55 69.72,98.32 69.72,97.76 68.27,96.32 67.53,96.32 65.25,94.04 63.31,94.04 62.88,93.61 57.23,93.61 56.87,93.97 54.24,93.97 52.61,95.6 52.08,95.6 51.67,95.18 51.67,94.82 49.51,92.67 46.26,92.67 45.95,92.36 45.95,91.99 46.16,91.79 v1(46.19,91.79)
SATA_PRX_DTX_N3: length 3.3
  TOP w0.102: JESA1.9 43.98,169.27 44.12,169.14 44.12,168.5 43.36,167.75 43.36,167.34 C673.2
SATA_PRX_DTX_P3: length 3.2
  TOP w0.102: JESA1.10 44.48,169.27 44.33,169.12 44.33,168.41 43.58,167.66 43.58,167.34 C674.2
SATA_PTX_DKRX_N2: length 6.4
  TOP w0.102: C700.1 90.33,126.73 90.12,126.95 90.12,127.23 89.65,127.7 89.65,128.05 90.12,128.52 90.12,128.88 v1(90.33,129.09)
  BOTTOM w0.102: v1(90.33,129.09) 90.12,128.88 90.12,128.62 89.06,127.57 89.06,127.33 89.2,127.19 JDOCK1.62
SATA_PTX_DKRX_N2_C: length 74.5
  TOP w0.102: C700.2 90.13,125.49 90.13,125.33 90.34,125.12 90.34,124.58 89.49,123.73 89.11,123.73 89.1,123.72 88.57,123.72 88.55,123.73 84.59,123.73 81.23,120.37 80.26,120.37 v1(80.04,120.15) ; UH1.AY13 41.32,94.55 v1(41.11,94.34)
  IN3 w0.089: 41.49,94.69 41.46,94.69 41.43,94.73 40.98,94.73 40.88,94.63 40.88,94.5 41.04,94.34 v1(41.11,94.34)
  IN3 w0.127: 41.49,94.69 43.61,94.69 44.51,93.79 49.54,93.79 50.91,95.15 50.91,95.51 51.75,96.36 52.94,96.36 54.5,94.8 64.93,94.8 67.21,97.08 67.95,97.08 68.96,98.08 68.96,98.67 70.61,100.32 71.69,100.32 73.87,102.5 73.87,103.5 76.97,106.6 76.97,107.23 77.61,107.88 77.61,116.38 77.27,116.72 77.27,118.03 79.58,120.33 79.87,120.33 v1(80.04,120.15)
SATA_PTX_DKRX_P2: length 6.4
  TOP w0.102: C699.1 89.72,126.73 89.9,126.91 89.9,127.14 89.43,127.61 89.43,128.14 89.9,128.61 89.9,128.89 v1(89.7,129.09)
  BOTTOM w0.102: v1(89.7,129.09) 89.9,128.89 89.9,128.71 88.85,127.66 88.85,127.33 88.7,127.18 JDOCK1.60
SATA_PTX_DKRX_P2_C: length 74.5
  TOP w0.102: UH1.AW13 40.72,94.58 v1(40.48,94.34) ; C699.2 89.91,125.47 89.91,125.24 90.13,125.03 90.13,124.67 89.4,123.95 v3(88.83,123.95) 84.5,123.95 81.14,120.58 80.25,120.58 v1(80.04,120.79)
  IN3 w0.089: 41.49,94.94 41.46,94.94 41.43,94.91 40.9,94.91 40.7,94.7 40.7,94.5 40.54,94.34 v1(40.48,94.34)
  IN3 w0.127: v1(80.04,120.79) 79.83,120.58 79.47,120.58 77.03,118.13 77.03,116.61 77.37,116.27 77.37,107.98 76.72,107.33 76.72,106.7 73.62,103.61 73.62,102.61 71.59,100.57 70.51,100.57 68.71,98.77 68.71,98.19 67.85,97.33 67.11,97.33 64.83,95.05 54.6,95.05 53.04,96.61 51.65,96.61 50.66,95.62 50.66,95.25 49.44,94.04 44.61,94.04 43.71,94.94 41.49,94.94
SATA_PTX_DRX_N3: length 2.9
  TOP w0.102: JESA1.7 40.67,169.27 40.53,169.12 40.53,167.34 C672.2
SATA_PTX_DRX_P3: length 3
  TOP w0.102: C671.2 40.31,167.34 40.31,169.13 40.17,169.27 JESA1.6
SATA_SIDE_LED: length 70
  TOP w0.102: JIO1.90 14.37,84.6 v1(14.97,85.2) ; v1(16.04,143.6) 16.53,143.6 v2(16.89,143.95)
  IN2 w0.127: v1(16.04,143.6) 14.99,143.6 14.13,142.73 14.13,141.78 14.74,141.17 14.74,138.57 14.23,138.06 14.23,133.18 13.37,132.32 13.37,127.75 15.17,125.94 15.17,119.33 16.59,117.9 16.59,116.59 15.53,115.52 15.29,115.52 13.6,113.83 13.6,113.44 11.13,110.98 11.13,108.19 10.82,107.88 10.82,104.63 11.26,104.19 11.26,101.31 12.23,100.34 12.23,95.15 12.81,94.57 12.81,91.91 13.78,90.94 13.78,87.64 14.97,86.45 v1(14.97,85.2)
  BOTTOM w0.102: R943.2 v1(16.04,143.6)
SB#: length 21
  IN2 w0.127: v1(258.71,104.87) 259.14,104.44 259.14,103.08 258.59,102.54 255.21,102.54 253.98,101.31 253.98,100.65 v1(254.48,100.15)
  BOTTOM w0.102: R1626.2 258.23,104.87 v1(258.71,104.87) 260.11,104.87 Q338.2 ; U2.8 254.55,105.91 253.32,104.68 253.32,101.31 v2(253.7,100.92) v1(254.48,100.15)
SCLK: length 4.8
  TOP w0.102: PU500.1 50.92,24.16 49.46,22.71 49.42,22.71 v2(49.37,22.65) 48.93,22.21 v1(48.93,22.2) 48.87,22.13 PR508.2
  BOTTOM w0.102: PR504.1 48.99,22.13 v1(48.93,22.2)
SDA: length 5.1
  TOP w0.102: PU500.31 50.34,25.2 49.78,24.64 49.4,24.64 48.93,24.17 v1(48.93,23.98) 48.31,23.98 PR505.2
  BOTTOM w0.102: v2(48.71,24.95) 48.93,24.74 v1(48.93,23.98) 48.99,23.91 PR500.1
SEL: length 6.2
  BOTTOM w0.102: U2.4 256.66,107.79 256.97,107.49 256.97,107.39 257.81,106.55 v2(257.92,106.55) 259.03,105.45 Q338.1 259.56,105.58 R1614.1
SIO_14M: length 3.9
  TOP w0.102: UH1.F38 v1(26.56,105.78)
  BOTTOM w0.102: RH157.2 23.63,105.6 25.21,105.6 25.41,105.8 26.54,105.8 v1(26.56,105.78)
SIO_A20GATE: length 140.1
  TOP w0.102: v1(38.64,93.26) 38.59,93.26 38.34,93.51 UH1.AN10
  IN2 w0.127: v1(38.64,93.26) 38.59,93.3 38.59,93.79 38.16,94.22 38.16,94.52 38.46,94.83 43.44,94.83 45.12,96.51 50.18,96.51 51.39,97.72 51.39,101.29 52.27,102.16 53.3,102.16 54.66,103.52 60.43,103.52 62.1,101.84 64.15,101.84 67.52,105.21 67.52,106.95 68.39,107.81 68.39,109.18 71.46,112.25 81.54,112.25 82.75,113.46 89.49,113.46 89.93,113.02 91.01,113.02 92.19,114.19 92.19,125.25 93.58,126.65 93.58,131.87 94.17,132.45 94.17,135.88 98.71,140.43 98.71,146.67 101.96,149.92 102.22,149.92 102.47,150.18 102.47,150.63 103.89,152.06 105.9,152.06 106.26,152.41 106.26,154.52 104.99,155.79 104.99,156.4 102.07,159.32 101.56,159.32 100.86,160.02 98.74,160.02 v1(97.57,158.85)
  BOTTOM w0.102: RH202.1 v2(40.93,86.05) 40.93,86.78 40.44,87.26 39.59,87.26 37.98,88.87 37.98,91.53 38.06,91.6 38.06,92.17 38.24,92.35 38.24,92.49 38.24,92.86 v1(38.64,93.26) ; v1(97.57,158.85) 97.65,158.77 U51.A45
SIO_EXT_SCI#: length 116.4
  TOP w0.102: v1(97.6,152.33) v2(97.6,151.74)
  IN1 w0.109: v1(92.19,102.7) 92.46,102.98 92.46,106.59 93.6,107.73 93.6,109.85 93.25,110.2 93.25,110.86 94.79,112.39 94.79,117.8 93.91,118.68 93.91,122.22 92.89,123.24 92.89,124.96 94.92,126.99 94.92,128.53 95.36,128.97 95.36,139.66 94.61,140.41 94.61,141.76 94.44,141.93 94.44,146.73 97.93,150.23 97.93,151.16 97.6,151.5 v1(97.6,152.33)
  IN2 w0.127: v1(92.19,102.7) 91.84,102.36 81.4,102.36 79.58,100.54 74.7,100.54 73.49,99.33 73.49,98.92 72.3,97.72 71.76,97.72 69.3,95.26 69.3,93.64 66.63,90.97 65.03,90.97 64.29,91.7 54.85,91.7 54.17,91.02 49.06,91.02 45.42,87.37 43.55,87.37 43.14,86.96 v1(43.14,86.95)
  BOTTOM w0.102: v1(97.6,152.33) 98.03,152.77 U51.A33 ; RH195.1 v1(43.14,86.95) 43.9,86.19 44.03,86.19 44.47,85.75 RPH10.8
SIO_EXT_SMI#: length 257
  TOP w0.102: UH1.M1 29.47,89.55 29.27,89.34 29.27,88.35 27.8,86.88 26.94,86.88 25.83,85.77 RPH7.4 25.83,85.09 25.36,84.62 25.36,82.21 v1(26.17,81.39)
  IN1 w0.109: v1(118.09,170.19) 117.37,170.91 115.77,170.91 112.95,173.74 101.37,173.74 93.72,166.08 89.71,166.08 89.29,166.5 71.38,166.5 69.88,165.01 63.41,165.01 59.53,161.13 54.88,161.13 52.6,163.41 52.6,164.69 49.75,167.55 45.33,167.55 44.9,167.12 28.01,167.12 25.98,165.09 18.76,165.09 14.71,161.04 14.71,155.83 13.2,154.32 13.2,143.72 14.78,142.15 14.78,133.55 13.6,132.37 13.6,127.82 15.55,125.87 v1(17.64,125.87)
  IN4 w0.109: v1(26.17,81.39) 25.37,82.19 24.11,82.19 23.89,82.41 19.57,82.41 17.89,84.1 17.33,84.1 15.46,85.96 11.66,85.96 8.02,89.6 8.02,109.72 9.46,111.16 9.46,113.05 13.09,116.68 13.09,118.07 17.64,122.61 v1(17.64,125.87)
  BOTTOM w0.102: v1(118.09,170.19) 118.09,170.11 v2(117.33,169.35) 116.52,168.54 116.11,168.54 115.27,167.7 115.27,160.23 113.19,158.15 111.08,158.15 110.83,157.9 109.81,157.9 109.69,157.77 U51.A6 ; v1(17.64,125.87) 20.1,125.87 20.33,126.1 23.33,126.1 23.73,125.69 23.73,123.23 RH10.1
SIO_EXT_WAKE#: length 376.1
  TOP w0.102: RH24.1 v2(38.52,117.82) v1(38.52,118.5) ; UH1.Y1 32.65,89.71 32.65,87.4 32.21,86.97 31.79,86.97 30.31,85.49 30.31,82.46 RH210.1 v1(30.77,81.39) ; v1(221.22,92.7) 221.22,88.86 220.6,88.24 220.6,86.17 220.96,85.81 v1(220.96,85.2)
  IN2 w0.127: v1(38.52,118.5) 38.52,120.74 38.22,121.03 38.22,131.64 42.91,136.33 48.92,136.33 49.76,135.49 52.77,135.49 54.57,137.29 54.57,141.64 55.49,142.57 56.86,142.57 60.94,146.64 65.55,146.64 68.21,149.3 68.21,152.27 67.8,152.67 67.8,155.65 68.73,156.58 75.32,156.58 79.28,160.54 84.97,160.54 85.76,161.33 86.34,161.33 86.78,160.89 94.95,160.89 95.39,161.33 96.69,161.33 97.57,162.21 97.57,163.37 98.26,164.06 113.11,164.06 113.2,164.15 114.14,164.15 114.91,163.38 114.91,162.86 116.46,161.3 119.54,161.3 120.46,160.38 120.46,159.96 123.04,157.38 125.12,157.38 126.03,156.46 126.03,154.84 126.63,154.24 126.93,154.24 128.73,152.44 133.21,152.44 134.18,151.46 134.18,149.28 135.34,148.13 144.07,148.13 147.81,144.38 147.81,142.71 155.93,134.59 155.93,131.4 157.24,130.08 164.58,130.08 166.01,128.66 171.26,128.66 171.74,128.18 171.74,125.87 176.95,120.66 176.95,108.96 178.39,107.52 182.57,107.52 187.84,102.25 196.27,102.25 199.65,98.87 200.19,98.87 205.55,93.51 220.4,93.51 v1(221.22,92.7)
  IN3 w0.127: v1(30.77,81.39) 29.83,82.33 13.49,82.33 7.5,88.33 6.03,88.33 4.81,89.55 4.81,90.33 4.94,90.46 4.94,96.44 6.69,98.19 6.69,113.6 8.09,115 10.24,115 17.84,122.6 24.87,122.6 25.51,123.25 31.24,123.25 33.76,120.74 36,120.74 36.36,121.09 38.11,121.09 38.52,120.69 v1(38.52,118.5)
  BOTTOM w0.102: v1(220.96,85.2) 220.96,85.23 220.92,85.18 U46.B49
SIO_PWRBTN#: length 339.1
  TOP w0.102: UH1.K1 28.58,89.71 28.58,88.63 27.52,87.57 26.65,87.57 24.97,85.89 24.37,85.89 23.71,85.22 v1(23.71,83.55) 23.61,83.55 23.1,83.04 23.1,81.37 v1(23.38,81.09)
  IN1 w0.109: v1(95.72,114.44) 95.72,117.88 95.25,118.34 95.25,123.39 96.16,124.3 96.16,127.94 96.02,128.08 96.02,128.51 96.09,128.58 96.09,136.83 v1(97.01,137.75)
  IN2 w0.127: v1(102.24,159.85) 102.24,159.5 105.24,156.51 105.24,155.89 106.51,154.62 106.51,152.31 106,151.8 104,151.8 102.74,150.54 102.74,148.66 102.1,148.02 101.28,148.02 100.01,146.75 100.01,140.75 v1(97.01,137.75)
  IN3 w0.127: v1(23.38,81.09) 24.11,81.82 28.25,81.82 29.69,80.39 31.01,80.39 31.25,80.63 31.25,81.54 31.63,81.93 34.85,81.93 35.37,81.4 36.2,81.4 36.65,80.96 37.83,80.96 38.21,81.34 38.21,81.42 38.79,82 42.3,82 42.93,81.37 44.82,81.37 47.26,83.81 50.75,83.81 52.37,85.42 53.36,85.42 57.36,89.42 57.36,90.26 57.87,90.76 66.09,90.76 72.53,97.2 72.81,97.2 73.39,97.78 73.39,98.76 75.36,100.72 78.47,100.72 80.05,102.3 82.16,102.3 85.84,105.97 85.84,109.99 87.13,111.29 87.13,114.31 88.43,115.61 91.32,115.61 91.9,115.02 95.13,115.02 v1(95.72,114.44)
  IN4 w0.109: v1(72.17,13.45) 72.17,13.34 71.1,12.27 48.53,12.27 43.29,17.51 43.29,24.83 39.68,28.44 39.68,30.94 39.17,31.45 39.17,37.21 36.73,39.66 36.73,48.86 39.45,51.59 39.45,53.34 37.06,55.73 37.06,65.19 34.5,67.76 34.5,77.41 35.18,78.1 35.18,80.47 33.46,82.19 26.78,82.19 26.07,82.9 24.41,82.9 23.75,83.55 v1(23.71,83.55) 23.28,83.12 19.87,83.12 18.17,84.82 17.61,84.82 15.05,87.38 14.43,87.38 12.12,89.69 11.5,89.69 8.49,92.7 8.49,109.53 10.12,111.15 10.12,111.19 11.21,112.28 11.21,113.96 13.56,116.31 13.56,117.87 18.14,122.44 18.14,124.92 v1(18.68,125.46)
  BOTTOM w0.102: U51.B58 102.75,160.36 v1(102.24,159.85) ; RH28.1 21.48,123.29 21.48,125.25 v2(21.31,125.42) 20.86,125.87 20.42,125.87 20.02,125.46 v1(18.68,125.46) ; RC6.1 v1(72.17,13.45)
SIO_RCIN#: length 120.8
  TOP w0.102: v1(39.63,91.91) 39.55,91.91 39.36,91.72 UH1.AT6
  IN2 w0.127: v1(102.14,149.49) 102,149.49 98.97,146.45 98.97,140.32 94.42,135.77 94.42,132.34 93.84,131.76 93.84,126.54 92.44,125.15 92.44,114.08 91.12,112.76 89.82,112.76 89.38,113.2 82.85,113.2 81.65,112 71.56,112 68.64,109.08 68.64,107.71 67.78,106.84 67.78,105.11 64.26,101.59 62,101.59 60.32,103.26 54.77,103.26 53.41,101.9 52.37,101.9 51.65,101.18 51.65,97.61 50.29,96.25 45.22,96.25 42.68,93.71 41.56,93.71 41.36,93.91 39.53,93.91 39.12,93.51 39.12,92.41 v1(39.63,91.91)
  BOTTOM w0.102: v1(102.14,149.49) 102.14,149.87 102.45,150.18 102.45,150.68 102.5,150.73 U51.A27 ; RPH10.7 43.97,85.74 43.16,86.55 42.45,86.55 40.55,88.45 39.69,88.45 39.2,88.94 39.2,89.93 v2(39.38,90.1) 39.51,90.23 39.51,91.79 v1(39.63,91.91)
SIO_SLP_A#: length 528.4
  TOP w0.102: v1(86.15,25.13) 86.15,26.66 85.01,27.8 85.01,28.33 84.98,28.36 JAPS1.6 ; PR303.1 v1(17.36,146.39) ; v1(19.67,80.6) 19.19,81.09 v2(19.19,83.87) 19.19,85.52 19.75,86.09 20.54,86.09 21.05,86.6 22.67,86.6 22.92,86.85 22.92,87.43 24.35,88.86 26.17,88.86 26.59,89.28 v1(26.59,89.28) 26.64,89.28 26.79,89.43 26.79,89.92 26.99,90.12 UH1.F3 ; UH2.1 v1(9.99,129.52)
  IN1 w0.109: v1(221.83,79.77) 223.71,79.77 223.88,79.94 225.46,79.94 228.26,77.14 237.08,77.14 238.38,75.85 244.13,75.85 246.58,78.3 251.13,78.3 253.48,80.66 261.31,80.66 271.94,70.03 271.94,46.57 262.51,37.13 261.38,37.13 260.65,37.87 257.9,37.87 257.08,37.05 251.73,37.05 250.56,35.87 236.87,35.87 222.64,21.64 200.37,21.64 199.56,20.84 132.02,20.84 131.43,21.43 107.05,21.43 103.69,24.79 86.49,24.79 v1(86.15,25.13) ; v1(19.67,80.6) 19.67,81.01 16.15,84.53 12.84,84.53 12.12,85.25 6.45,85.25 5.74,84.54 3.78,84.54 2.92,85.41 2.92,90.16 3.41,90.65 3.41,91.76 5.43,93.77 5.43,97.51 7.9,99.98 7.9,112.47 12.63,117.19 12.63,121.8 8.84,125.59 8.84,127.82 9.99,128.97 v1(9.99,129.52)
  IN4 w0.109: v1(17.36,146.39) 16.67,145.71 16.67,137.51 12.52,133.36 12.52,132.04 v1(9.99,129.52) ; v1(86.15,25.13) 85.31,24.29 85.31,23.39 85.28,23.35 85.28,22.24 74.74,11.69 74.74,10.58 72.89,8.73 54.45,8.73 54.01,9.17 50.6,9.17 42.56,17.21 42.56,24.4 38.96,28.01 38.96,30.66 38.46,31.16 38.46,36.92 36.02,39.36 36.02,49.16 38.73,51.87 38.73,53.06 36.34,55.46 36.34,64.9 33.77,67.46 33.77,71.51 31.47,73.81 31.47,76.09 28.01,79.55 20.72,79.55 v1(19.67,80.6)
  BOTTOM w0.102: U46.B63 v1(221.83,79.77)
