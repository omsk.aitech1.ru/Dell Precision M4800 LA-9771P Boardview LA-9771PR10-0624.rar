# Allegro board LA-9771PR10-0624.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_CHASSIS: length 14.9
  BOTTOM w0.508: R574.2 R572.2 R573.2 R571.2
  BOTTOM w1.016: 167.06,158.05 172.09,158.05 173.52,156.63 v1(173.52,152.31) v1(173.52,151.42)
V1N: length 5.3
  TOP w0.102: PR516.1 58.62,33.2 v2(58.62,33.13)
  TOP w0.254: PR546.2 54.82,33.56 57.13,33.56 PR516.1
V2N: length 1.1
  TOP w0.254: PR518.1 PR556.2
V3N: length 3.2
  BOTTOM w0.102: PR557.2 57.22,34.12 v2(57.43,33.92)
  BOTTOM w0.254: PR547.2 PR557.2
VCC_PGOOD: length 4.8
  TOP w0.102: PU500.3 52.33,23.5 51.85,23.02 51.23,23.02 50.35,22.15 v2(50.35,21.8) 49.49,20.94 PR522.2
VCCSENSE: length 89.9
  TOP w0.254: JCPU1.AL35 72.21,69.9 71.52,69.9 66.56,74.85 64.28,74.85 v2(63.56,74.13) 62.91,74.13 62.45,74.59 RC66.2 61.96,73.59 61.38,73.01 58.15,73.01 v1(58,73.16) ; v1(58.96,25.55) 57.91,24.5 PC542.2 PC544.1 ; v1(64.22,22.85) 64.02,22.64 PC520.1 63.28,22.69 PR536.1
  IN2 w0.254: v1(58.96,25.55) 59.07,25.66 60.23,25.66 62.95,22.95 64.12,22.95 v1(64.22,22.85) 64.32,22.95 65.19,22.95 66.23,23.99 66.23,40.61 61.27,45.57 61.27,54.42 60.54,55.15 60.54,55.81 61.25,56.53 61.25,57.21 60.56,57.9 60.56,58.78 61.25,59.47 61.25,60.67 60.54,61.38 60.54,61.88 61.25,62.59 61.25,63.94 60.51,64.68 60.51,65.29 61.25,66.03 61.25,67.04 60.66,67.63 60.66,68.31 61.25,68.9 61.25,69.76 60.66,70.34 60.66,70.79 61.25,71.38 61.25,72.18 60.42,73.01 58.15,73.01 v1(58,73.16)
VDD_1.35V: length 6.7
  BOTTOM w0.102: PR201.1 183.12,80.17 v2(183.42,80.48)
  BOTTOM w0.203: PU200.11 179.83,77.9 180.02,78.09 180.02,78.4 180.62,78.99 PR203.2 182.57,78.99 PC210.1 182.6,79.68 PR201.1
VDD_PWRGD: length 4.6
  TOP w0.102: R402.2 164.17,132.73 162.68,132.73 v2(162.42,132.99)
  TOP w0.254: R402.2 164.95,133.01 U29.13
VIN: length 2.5
  TOP w0.102: v1(107.52,153.24) 107.13,153.63 106.74,153.63 T137.1
  BOTTOM w0.102: U51.B15 108.1,153.52 107.82,153.24 v1(107.52,153.24)
VSSSENSE: length 91.5
  TOP w0.203: 55.76,26.4 PU500.13
  TOP w0.254: JCPU1.AK35 72.35,69.52 71.36,69.52 66.41,74.47 64.58,74.47 v2(63.04,72.93) 62.73,72.63 58.09,72.63 v1(57.99,72.53) ; v1(57.44,27.21) 58,27.21 RC70.1 58.05,27.14 PC544.2 56.64,26.27 56.33,26.58 55.94,26.58 55.76,26.4
  IN2 w0.254: v1(57.44,27.21) 58.61,26.04 60.39,26.04 63.11,23.33 65.03,23.33 65.85,24.15 65.85,40.45 60.89,45.41 60.89,54.26 60.16,55 60.16,55.97 60.87,56.68 60.87,57.05 60.18,57.74 60.18,58.94 60.87,59.62 60.87,60.51 60.16,61.22 60.16,62.04 60.87,62.75 60.87,63.78 60.13,64.52 60.13,65.45 60.87,66.18 60.87,66.88 60.28,67.47 60.28,68.47 60.87,69.05 60.87,69.6 60.28,70.19 60.28,70.95 60.87,71.54 60.87,72.02 60.26,72.63 58.09,72.63 v1(57.99,72.53)
  BOTTOM w0.254: v1(57.44,27.21) 56.57,27.21 55.3,25.94 PC546.2
3301_ACAV_IN_NB: length 2.8
  BOTTOM w0.254: PR1019.1 152.82,124.86 v2(152.58,124.63) 152.58,124.59 152.2,124.22 PU1001.24
3301_DC_IN_SS: length 2.5
  BOTTOM w0.254: PR1010.2 155.99,118.53 v2(155.87,118.65) 155.23,119.28 PU1001.34
3301_PWRSRC: length 2.6
  BOTTOM w0.254: PU1001.15 147.52,120.78 v2(147.49,120.76) 147.49,120.76 146.97,120.24 PR1029.1
24737_BST_CHG_MODE#: length 75
  IN3 w0.127: v1(174.23,56.58) 175.45,55.36 178.7,55.36 180.37,53.68 185.76,53.68 186.47,54.39 190.92,54.39 192.01,55.48 201.79,55.48 205.14,58.84 205.14,66.61 v1(205.09,66.66)
  BOTTOM w0.254: PU700.11 177.23,50.68 176.06,51.85 176.06,52.49 174.53,54.01 PR757.2 v1(174.23,56.58) v2(173.7,57.1) 173.24,57.57 169.96,57.57 169.05,56.65 169.05,55.51 169.41,55.14 169.41,53.29 169.58,53.12 PQ710.2 ; v1(205.09,66.66) 205.09,63.41 211.87,56.63 212.99,56.63 213.62,57.26 PR718.1
+ADDR_XEN: length 2.6
  TOP w0.254: 172.37,135.42 171.96,135.01 U29.32
  TOP w0.508: 172.37,135.42 172.55,135.6 v2(172.78,135.6) R394.1
+BL_PWR_SRC: length 3.8
  TOP w0.254: v3(51.55,155.38) 51.48,155.45 JLVDS1.1 ; JLVDS1.2 51.24,154.95 v3(51.44,154.75) 51.15,154.45 JLVDS1.3
  vias: v2(52,155)
+CAMERA_VDD:
  vias: v2(52.19,151.67)
+CAP_LDO: length 3.6
  BOTTOM w0.102: v2(216.66,89.52) 216.52,89.66 v1(216.52,90.33)
  BOTTOM w0.318: U46.B46 219.42,84.83 219.17,84.57 v1(218.8,84.57)
  BOTTOM w0.508: v1(216.52,90.33) 215.95,90.9 C714.1
+CHAGER_SRC: length 1.2
  BOTTOM w0.102: PC705.1 v2(183.93,44.77)
+CHG_VCC: length 4
  BOTTOM w0.102: v2(176.03,39.39) 175.55,39.88 PD701.1
  BOTTOM w0.635: PR775.2 175.61,41.31 174.92,40.62 PD701.1
+COINCELL: length 2.8
  BOTTOM w0.102: PR1.1 41.23,155.14 v2(40.7,154.61)
  BOTTOM w0.508: JRTC1.1 39.78,155.74 PR1.1
+CRT_VCC: length 8.6
  TOP w1.016: JCRT1.9 77.35,172.45 78.15,171.65 78.15,168.1 v2(78.91,167.33) C14.1 79.97,165.08 U6.3
+DC1_PWR_SRC: length 11.5
  IN1 w0.508: v3(247.33,56.88) 247.33,54.93 246.67,54.27 246.67,48.98 244.51,46.82 v3(244.51,46.52)
  vias: v4(251.98,43.95)
+DC_IN: length 445.3
  TOP w0.508: v1(16.62,66.1) 16.73,66.1 17.12,66.49 PQ8.3 ; v3(228.63,55.74) 228.63,58.8 225.87,61.57 224.75,61.57 219.99,66.33 218.13,66.33 216.94,67.52 216.94,68.02 215.31,69.66 211.82,69.66 208.21,73.26 208.21,75.04 206.03,77.23 206.03,79.89 202.43,83.49 202.43,87.96 199.63,90.76 199.63,91.12 197.52,93.23 197.52,93.97 194.69,96.8 192.2,96.8 190.9,98.09 181.87,98.09 170.18,109.79 v1(170.18,109.85)
  IN2 w0.508: v3(228.63,55.74) 229.42,54.95 229.42,42.33 217.56,30.47 195.84,30.47 194.8,31.51 189.87,31.51 187.64,29.27 185.67,29.27 185.31,29.63 184.54,29.63 183.27,28.36 173.2,28.36 168.93,24.09 151.14,24.09 148.13,21.08 136.43,21.08 132.55,24.97 126.89,24.97 126.22,25.64 v3(126.22,25.92) ; v1(90.51,26.81) 90.51,27.04 90.03,27.52 89.49,27.52 88.42,26.45 85.33,26.45 85.01,26.13 83.16,26.13 77.63,20.61 76.36,20.61 75.57,19.82 75.57,17.39 76.2,16.77 76.2,13 75.04,11.85 75.04,9.48 73.11,7.55 69.2,7.55 68.08,6.44 62.47,6.44 59.98,3.95 50.91,3.95 44.94,9.92 44.94,25.43 41.54,28.84 41.54,32.7 39.1,35.14 39.1,48.15 41.59,50.63 41.59,54.42 39.35,56.65 39.35,65.81 36.22,68.95 28.99,68.95 27.72,67.68 18.41,67.68 16.84,66.1 v1(16.62,66.1)
  IN3 w0.508: v1(16.25,74.62) 16.8,74.08 16.8,66.33 16.62,66.15 v1(16.62,66.1)
  BOTTOM w0.508: PR1011.1 156.99,113.12 157.34,112.77 157.34,111.9 v4(159.24,109.99) 160.71,108.52 168.84,108.52 v1(170.18,109.85) ; PL4.2 16.8,75.17 v1(16.25,74.62) ; v1(90.51,26.81) 90.51,27.56 91.11,28.15 v4(91.85,28.15) 92.69,28.99 92.69,33.89 95.89,37.09 100.24,37.09 106.12,31.21 119.38,31.21 v4(120.8,29.79) 124.67,25.92 v3(126.22,25.92) ; PR736.1 v3(228.63,55.74)
+DC_IN_SS: length 383
  IN1 w0.508: v1(30.26,75.27) 30.26,75.04 29.68,74.46 29.02,74.46 26.78,72.22 v3(23.43,72.22) ; v1(178.32,90.05) 178.37,90.1 178.37,90.61 174.49,94.49 172.41,94.49 161.53,105.37 160.45,105.37 158.19,107.63 158.19,110.15 157.2,111.14 157.2,113.78 155.61,115.36 v1(155.61,117.08)
  IN2 w0.508: v1(144.2,111.39) 144.99,112.18 146.85,112.18 147.13,111.9 151.04,111.9 151.6,111.34 153.74,111.34 154.28,111.87 154.28,112.65 155.61,113.98 v1(155.61,117.08) ; v1(173.91,40.56) 173.2,40.56 171.03,42.73 171.03,46.92 170.77,47.18 170.77,52.07 167.65,55.19 167.65,58.25 168.31,58.91 168.31,72.07 166.18,74.2 166.18,82.31 168,84.14 170.7,84.14 172.53,85.96 173.54,85.96 176.61,89.04 177.3,89.04 v1(178.32,90.05)
  IN3 w0.508: v1(30.26,75.27) 30.26,73.87 31.97,72.16 33.12,72.16 39.2,66.07 39.2,56.83 41.31,54.72 41.31,50.28 39.1,48.07 39.1,35.11 41.64,32.57 41.64,28.74 44.97,25.41 44.97,10.32 50.58,4.71 69.43,4.71 75.07,10.35 75.07,13.07 76.54,14.54 76.54,18.44 84.3,26.2 92.52,26.2 93.24,26.92 v3(93.24,27.54)
  IN4 w0.508: v3(123.96,90.21) 120.08,86.32 120.08,72.77 114.56,67.25 114.56,42.51 107.32,35.28 96.64,35.28 94.19,32.83 94.19,29.26 93.24,28.31 v3(93.24,27.54)
  BOTTOM w0.508: PD701.3 173.87,40.53 v1(173.91,40.56) ; v3(123.96,90.21) 123.96,92.4 127.63,96.07 137.09,96.07 142.81,101.79 142.81,104.66 144.2,106.06 v4(144.2,107.78) v1(144.2,111.39) ; PR1010.1 157.72,118.27 157.31,117.87 156.17,117.87 155.61,117.31 v1(155.61,117.08)
+DCIN_JACK:
  vias: v4(17.65,86.22) v4(18.77,87.6) v4(20.28,82.64)
+DOCK_PWR_BAR: length 78.2
  IN1 w0.635: v3(228.76,40.17) 216.57,27.98 200.1,27.98 199.14,27.02 198.19,27.02 193.63,31.58 185.5,31.58 182.23,28.31 174.84,28.31 172.86,30.29 172.86,31.86 173.92,32.93 v3(173.92,39.26)
  BOTTOM w0.102: PR1001.1 229.73,39.48 v4(230.01,39.2)
  BOTTOM w0.508: v1(158.45,118.81) 158.45,118.96 157.87,119.54 PR1007.1 ; PD701.2 173.11,39.26 v3(173.92,39.26)
  vias: v3(228,48.68) v3(228,48.04) v3(228,47.41) v3(228,46.77) v3(228,46.14) v3(228,43.72) v3(228.63,48.68) v3(228.63,48.04) v3(228.63,47.41) v3(228.63,46.77) v3(228.63,46.14) v3(228.63,45.5) v3(228.63,44.87) v3(228.63,44.23) v3(228.63,43.6)
+DP_VCC:
  vias: v2(262.82,148.38)
+LCDVDD: length 47.3
  TOP w0.508: R161.1 57.25,145.67 v1(57.73,146.15) ; v1(56.47,143.3) 56.78,143 R162.1
  TOP w0.762: v3(44.71,145.17) 44.51,144.97 43.95,144.97 v1(43.93,144.94) 43.93,143.11 44.33,142.71 44.33,137.73 43.19,136.59 42.27,136.59 40.57,134.88
  IN1 w0.508: v1(57.73,146.15) 57.72,146.15 57.07,145.5 51.35,145.5 50.24,144.38 50.24,143.1 49.44,142.3 48.73,142.3 47.53,143.5 47.53,144.66 47.04,145.16 44.73,145.16 v3(44.71,145.17)
  IN2 w0.508: v1(57.73,146.15) 57.73,144.56 v1(56.47,143.3)
  IN2 w0.762: v1(43.93,144.94) 44.48,144.94 v3(44.71,145.17) 44.71,145.86 46.31,147.46 46.31,149.24 45.35,150.2 45.35,151.46 46.2,152.31 47.28,152.31
  BOTTOM w0.102: C769.1 46.14,153.83 v4(46.12,153.85)
  vias: v1(47.58,153.02) v1(48.19,153.02)
+LOM_VCT: length 3.4
  TOP w0.102: v1(103.92,125.08) v2(103.92,124.34)
  BOTTOM w0.254: JDOCK1.118 104.2,125.36 v1(103.92,125.08) 103.7,125.3 JDOCK1.116
+MXM_PWR_SRC: length 1.7
  BOTTOM w0.102: v4(133.28,100.26) 133.68,99.87 v1(133.68,98.74)
+NBDOCK_DC_IN_SS: length 206.6
  TOP w0.508: v1(232.75,67.57) 232.75,67.83 232.47,68.11 230.72,68.11 229.95,67.35 218.55,67.35 218.09,67.8 218.09,68.31 215.73,70.67 213.34,70.67 211.82,72.2 v1(210.9,72.2)
  IN1 w0.508: v1(210.9,72.2) 210.83,72.12 209.13,72.12 206.46,74.79 203.21,74.79 196.48,81.51 184.86,81.51 181.73,84.64 179.1,84.64 178.85,84.89 177.18,84.89 160.14,101.94 154.69,101.94 147.35,109.28 147.35,112.94 146.95,113.35 146.95,114.31 147.51,114.87 147.51,116.77 147.01,117.27 147.01,124.05 147.18,124.22 147.18,126.53 v1(147.1,126.6)
  IN2 w0.508: v1(147.1,126.6) 147.18,126.53 147.18,124.42 146.11,123.35 146.11,118.04 142.43,114.36 131.72,114.36 128.37,117.71 118.78,117.71 116.7,115.63 108.59,115.63 102.88,121.35 v1(101.23,121.35)
  BOTTOM w0.102: v1(147.1,126.6) 146.45,126.6 v2(146.43,126.63)
  BOTTOM w0.254: JDOCK1.41 83.2,119.45
  BOTTOM w0.508: v1(232.75,67.57) 232.75,67.63 233.13,68.01 234.29,68.01 PQ1070.1 ; PR1024.2 v1(147.1,126.6) ; v1(101.23,121.35) 100.14,121.35 99.12,120.33 94.8,120.33 93.43,121.7 87.49,121.7 86.62,120.84 84.17,120.84 83.2,119.86 83.2,119.45
+PCH_DCPRTC: length 1.9
  TOP w0.305: UH1.P16 30.16,96.04 v1(30.48,95.72) 30.16,95.4 UH1.P14
  BOTTOM w0.457: CH54.1 30.51,96.12 30.51,95.75 v1(30.48,95.72)
+PCH_USB_DCPSUS1: length 4
  TOP w0.305: v1(32.21,94.46) 32.45,94.7 UH1.Y12
  BOTTOM w0.381: RH234.2 33.18,96.95 33.47,96.66 CH39.1 33.47,96.31 33.08,95.92 33.08,95.58 32.29,94.79 32.29,94.54 v1(32.21,94.46)
+PCH_USB_DCPSUS2: length 12.3
  TOP w0.254: UH1.Y35 32.55,104.09 32.3,104.34 v1(32.17,104.34)
  BOTTOM w0.254: v1(32.17,104.34) 32.17,104.92 32.67,105.42 32.67,106.7 32.85,106.88 v2(32.85,106.92) 32.85,109.09 32.41,109.54 32.41,111.86 RH239.2 31.2,114.36 CH58.1
+PCH_USB_DCPSUS3: length 15.9
  TOP w0.305: UH1.AJ26 36.1,100.24 v1(35.77,100.57) 36.1,100.9 UH1.AJ28
  IN2 w0.508: 38.73,103.87 37.82,102.96 37.42,102.96 37.04,102.58 37.04,101.85 35.77,100.58 v1(35.77,100.57) ; 38.63,108.01 38.63,110.23 37.75,111.11 35.53,111.11 35.23,111.42 v1(34.39,111.42)
  BOTTOM w0.508: v1(35.77,100.57) 35.92,100.41 CH42.1 ; v1(34.39,111.42) RH236.1 34.39,110.18 33.94,109.74 CH41.1
+PCH_VCC: length 12.3
  TOP w0.102: CH64.1 43.29,112.43 43.29,113.88 v2(42.81,114.36)
  TOP w0.254: UH1.AP45 38.41,109.55 38.57,109.7 38.57,109.95 40.93,112.32 42.22,112.32 42.57,111.97 CH64.1 43.96,111.97 CH63.1 45.32,111.99 LH2.2
+PCH_VCCCFUSE: length 28.5
  TOP w0.254: UH1.P20 30.16,97.65 v1(30.47,97.33) 30.16,97.01 UH1.P18
  IN4 w0.254: v1(20.58,100.52) 20.58,100.49 ; 20.58,100.49 20.68,100.59 21.27,100.59 22.39,99.48 24.55,99.48 26.2,97.83 29.5,97.83 29.99,97.33 v1(30.47,97.33) 30.47,97.13 30.21,96.86 26.12,96.86 25.99,96.99 25.69,96.99 24.35,98.32 22.75,98.32 20.58,100.49
  BOTTOM w0.508: v1(20.58,100.52) 20.3,100.52 19.77,101.05 19.77,101.49 v2(19.44,101.82) 18.81,102.45 CH66.1 18.14,102.45 RH242.2
+PCH_VCCCLK: length 5.6
  TOP w0.254: 34.5,104.34 34.5,104.48 34.3,104.68 UH1.AD36 ; 34.5,104.34 v1(34.74,104.34) ; 34.5,104.34 UH1.AD35 ; v1(34.74,103.69) 34.54,103.49 UH1.AD34
  TOP w0.305: UH1.AG32 35.11,102.28 v1(35.11,102.21) ; v1(33.15,103.17) 32.8,102.82 UH1.Y32 ; v1(35.11,102.21) 35.11,102.13 UH1.AG30 ; v1(35.11,102.21) 34.78,102.54 UH1.AE32 ; v1(35.11,102.21) 34.78,101.88 UH1.AE30 ; UH1.AA30 33.13,102.13 v1(33.13,102.21) 33.13,102.28 UH1.AA32
  vias: v2(34.08,102.86) v3(33.31,118.78) v3(33.51,117.16) v3(33.54,116.52)
+PCH_VCCCLK3_3: length 4.4
  TOP w0.305: v1(31.15,102.21) 31.15,102.28 UH1.U32 31.64,102.78 31.97,102.78 UH1.V32
  BOTTOM w0.381: CH72.1 28.89,101.33 v1(29.35,100.87) ; CH73.1 29.7,102.35 v1(29.25,101.9)
  BOTTOM w0.508: v1(28.66,101.94) 28.66,101.41 CH72.1 ; CH74.1 30.82,101.69 31.15,102.01 v1(31.15,102.21)
  vias: v1(19.39,105.29) v1(19.39,104.71)
+PCH_VCCDSW: length 1.2
  TOP w0.305: UH1.U14 31.81,95.63 v1(31.81,95.71)
  BOTTOM w0.508: RH232.2 31.73,95.63 v1(31.81,95.71)
+PCH_VCCDSW3_3: length 401.5
  TOP w0.254: v1(20.13,83.55) 20.13,81.55 21.29,80.38 23.68,80.38 24.52,81.21 v1(24.52,81.39) 24.34,81.39 23.78,81.95 RH78.1 ; UH1.A16 24.35,96.25 24.11,96.01 21.97,96.01 v1(21.7,95.74)
  TOP w0.305: v1(84.98,25.39) 84.98,25.52 85.09,25.63 83.48,27.23 JAPS1.3
  TOP w0.508: v1(90.98,31.53) 90.98,33.74 95.45,38.21 106.88,38.21 113.24,44.58 113.24,79.17 111.7,80.71 v1(110.96,80.71) 112.96,82.71 v1(115.65,82.71) 116.37,82 117.1,82 117.48,82.38 117.48,82.94 113.67,86.75 108.9,86.75 104.48,91.17 104.2,91.17 103.72,91.65 v3(103.72,91.83) ; v1(100.54,123.66) 99.58,124.62 99.58,126.6 98.36,127.82 98.36,130.77 96.66,132.47 96.66,137.22 94.69,139.19 94.69,139.63 93.11,141.21 93.11,143.28 90.97,145.42 90.97,154.24 90.31,154.9 90.31,158.53 88.9,159.94 88.9,168.96 92.34,172.4 99.53,172.4 v1(102.14,169.78)
  IN1 w0.508: v1(21.7,95.74) 21.37,95.74 20.3,94.68 v1(20.3,90.21) ; v3(103.72,91.83) 103.64,91.76 100.92,91.76 99.91,92.77 99.91,93.74 100.19,94.02 100.19,100.49 100.03,100.65 100.03,107.08 101.94,108.98 101.94,110.4 100.54,111.8 v1(100.54,123.66)
  IN2 w0.508: v1(20.3,90.21) 20.3,91.82 19.12,93 18.15,93 17.66,93.48 17.66,94.54 17.24,94.97 17.24,96.79 16.73,97.29 16.73,100.45 15.45,101.74 15.45,104.53 14.87,105.12 14.87,105.88 15.43,106.44 15.49,106.44 16.26,107.22 16.26,109.43 17.13,110.29 17.13,111.28 17.7,111.85 18.06,111.85 18.95,112.74 18.95,114.46 19.57,115.07 19.57,115.36 22.17,117.97 22.56,117.97 24.19,119.6 24.19,127.38 28.89,132.08 35.14,132.08 38.16,135.1 38.16,136.21 39.07,137.12 39.07,137.25 41,139.18 41,139.46 43.91,142.36 45.57,142.36 47.03,143.83 47.03,145.74 49.34,148.04 49.34,149.39 49.31,149.41 49.31,151.22 52.43,154.34 52.43,155.2 53.37,156.13 55.26,156.13 57.08,157.95 61.78,157.95 67.86,164.03 70.76,164.03 73.94,167.21 78.92,167.21 79.64,166.48 82.23,166.48 82.28,166.53 86.11,166.53 86.34,166.3 88.2,166.3 89.76,164.74 93.01,164.74 98.05,169.78 v1(102.14,169.78)
  BOTTOM w0.254: v1(24.52,81.39) 24.52,81.47 24.93,81.87 25.97,81.87 26.58,82.48 RH216.2 ; v1(115.65,82.71) RC18.1
  BOTTOM w0.356: UC2.5 111.53,80.14 v1(110.96,80.71)
  BOTTOM w0.508: RH238.2 20.68,95.74 v1(21.7,95.74) 21.75,95.79 RH217.2 ; v1(84.98,25.39) 84.98,25.68 85.81,26.5 87.54,26.5 90.98,29.94 v4(90.98,30.45) v1(90.98,31.53) ; v1(102.14,169.78) 100.9,168.54 100.9,166.63 101.43,166.1 101.76,166.1 102.27,165.59 R835.1 ; v1(20.13,83.55) 19.41,84.26 19.41,87.83 18.35,88.9 18.35,89.42 18.75,89.83 19.52,89.83 RH80.1 19.85,89.75 v1(20.3,90.21) 20.3,90.64 19.26,91.68 CH44.1 19.08,92.11 19.01,92.19 RH112.1
+PCH_VCCDSW_R: length 1
  BOTTOM w0.508: CH40.1 30.79,95.1 RH232.1
+PCH_VCCSST: length 1.4
  TOP w0.305: UH1.AA14 33.46,95.37 v1(33.79,95.71)
  BOTTOM w0.508: v1(33.79,95.71) 33.79,95.52 34.12,95.18 CH46.1
+PECI_VREF: length 5.1
  BOTTOM w0.305: U51.B51 99.04,160.52 98.79,160.77 98.79,161.1
  BOTTOM w0.508: R866.1 C740.1 v2(98.33,163.07) 98.33,161.55 98.79,161.1
+PWR_SRC: length 1145.7
  TOP w0.254: v1(28.72,143.93) 28.72,143.29 31.09,140.93 31.09,140.31 29.27,138.49 29.27,136.8 27.87,135.4 27.87,133.33 28.7,132.5 31.34,132.5 31.66,132.18 31.66,130.2 32.14,129.72 v3(32.14,129.25)
  TOP w3.048: 182.76,63.54 182.76,78.85 181.19,80.43 179.51,80.43 178.04,81.9 176.92,81.9 171.17,87.65 166.16,87.65 159.93,93.89
  IN1 w0.508: v1(144.88,120.24) 144.47,120.24 144.05,119.82 144.05,118.6 143.52,118.07 143.52,109.15 153.83,98.84 155.51,98.84 v3(155.86,99.2)
  IN1 w1.27: 177.2,141.39 177.2,146.45 175.92,147.74 156.37,147.74 155.61,148.5 155.61,152.18 153.07,154.72 153.07,158.91 150.53,161.45 150.53,162.88 148.62,164.78 148.62,172.4
  IN2 w1.27: 78.16,10.78 77.81,11.14 77.81,14.91 77.55,15.16 77.55,18.02 80.93,21.4 84.87,21.4
  IN2 w1.778: 84.87,21.4 82.74,19.26 82.74,18.81 79.69,15.76 79.69,11.14
  IN2 w2.54: 34.43,67.13 34.44,67.14 35.66,67.14 37.7,65.1 37.7,55.97 39.94,53.73 39.94,51.32 36.41,47.79 36.41,34.61 39.66,31.35 39.66,28.38 43.29,24.75 43.29,8.82 46.44,5.67 46.44,3.41 47.56,2.3 70.32,2.3 73.9,5.88 76.23,5.88
  IN2 w3.048: 84.87,21.4 85.2,21.4 88.13,24.33 94.27,24.33 95.09,25.16 110.42,25.16 113.57,22.01 131.86,22.01 136.57,17.3 148.96,17.3 152.32,20.66 173.95,20.66 175.68,22.39 180.25,22.39
  IN3 w1.27: 78.16,10.78 77.83,11.11 77.83,12.8 77.55,13.08 77.55,18.02 80.65,21.12 84.62,21.12 81.54,18.04 81.54,17.13 79.94,15.53 79.94,10.88 ; v3(147.86,173.29) 147.86,170.6 151.29,167.17 151.29,164.12 150.53,163.36 150.53,161.58 153.07,159.04 153.07,156.75 153.58,156.25 153.58,154.21 156.28,151.51 156.28,149.17 157.72,147.74 175.99,147.74 177.2,146.53 177.2,141.13
  IN3 w2.54: 76.23,5.88 73.9,5.88 70.32,2.3 47.56,2.3 46.44,3.41 46.44,5.67 43.32,8.8 43.32,24.72 39.99,28.05 39.99,31.02 36.41,34.61 36.41,47.71 39.66,50.96 39.66,54.04 37.55,56.14 37.55,65.39 35.52,67.42 34.24,67.42 34.21,67.45 ; 177.71,32.04 177.71,26.33 172.8,21.42 153.42,21.42 149.12,17.12 136.32,17.12 131.68,21.75 109.38,21.75 106.21,24.93 94.29,24.93 93.9,24.53 88.03,24.53 84.62,21.12
  IN4 w0.508: 12.85,153.05 13,152.89 16.89,152.89 19.85,149.93 24.61,149.93 28.72,145.82 v1(28.72,143.93)
  IN4 w1.27: 53.25,162.47 53.25,162.85 49.36,166.74 28.1,166.74 25.56,164.2 17.84,164.2 14.66,161.02 14.66,155.98 12.85,154.16 12.85,151.79 10.33,149.27 10.33,147.05 12.63,144.75 12.63,142.63 15.03,140.23
  IN4 w2.54: 54.9,161.33 58.58,161.33 61.38,164.12 61.38,165.67 65.24,169.53 94.73,169.53 98.48,173.29 144.92,173.29 144.94,173.26
  BOTTOM w0.254: v3(32.14,129.25) 33.08,128.31 R933.1
  BOTTOM w0.381: 78.29,9.69 78.29,13.37 78.01,13.65 78.01,17.89 81.24,21.12 84.77,21.12
  BOTTOM w0.508: PR1029.2 v1(144.88,120.24) ; PR15.1 26.84,146.77 PC7.1 27.35,146.26 PQ4.3 28.06,144.59 v1(28.72,143.93)
  BOTTOM w1.524: 84.77,21.12 84.77,21.02 79.79,16.04 79.79,10.07
  BOTTOM w2.032: 84.77,21.12 84.77,21.35 88.32,24.9 98.18,24.9 99.13,25.86 99.91,26.02 100.91,26.45 104.91,26.45 106.03,25.33 121.67,25.33 125.26,21.75 131.23,21.75 135.92,17.05 147.86,17.05 152.05,21.25 172.37,21.25 174.02,22.9 178.98,22.9
  BOTTOM w2.54: 175.41,136.36 175.4,136.35 175.4,123.38 173.24,121.22 173.24,109.51 169.88,106.16 168.56,106.16 163.4,101 157.51,101 ; 35.53,67.49 37.79,65.23 37.79,55.31 39.4,53.69 39.4,50.53 36.41,47.53 36.41,34.61 39.53,31.48 39.53,30.72 41.75,28.5 42.15,28.5 44.95,25.71 44.95,14.01 47.33,11.63 52.62,11.63 53.81,10.45 56.59,10.45 61.16,5.88 v4(69.1,5.88) 76.23,5.88
  vias: v3(16.07,140.56) v3(16.06,139.82) v3(16.07,139.11) v3(30.9,67.85) v3(30.9,66.97) v3(30.9,66.11) v3(31.53,67.85) v3(31.53,66.97) v3(31.53,66.11) v3(32.17,67.85) v3(32.17,66.97) v3(32.17,66.11) v3(32.8,67.85) v3(32.8,66.97) v3(32.8,66.11) v3(54.21,157.72) v3(54.52,158.28) v3(54.85,157.72) v3(77.76,8.8) v3(77.76,8.16) v3(77.76,7.53) v3(78.39,8.8) v3(78.39,8.16) v3(78.39,7.53) v3(79.03,8.8) v3(79.03,8.16) v3(79.03,7.53) v3(79.66,8.8) v3(79.66,8.16) v3(79.66,7.53) v3(80.3,8.8) v3(80.3,8.16) v3(80.3,7.53) v3(146.59,174.03) v3(146.59,172.38) v3(148.75,174.03) v3(149.51,173.29) v3(156.5,99.2) v3(157.13,99.2) v3(157.77,99.2) v3(158.4,99.2) v3(174.98,139.8) v3(175.47,140.5) v3(175.65,139.81) v3(175.64,139.14) v3(175.65,138.48) v3(175.85,62.93) v3(176.49,62.93) v3(176.56,38.77) v3(176.56,34.83) v3(176.56,33.69) v3(177.12,62.93) v3(177.45,37.37) v3(177.45,36.1) v3(177.45,34.83) v3(177.45,33.69) v3(177.76,62.93) v3(177.71,38.77) v3(178.39,62.93) v3(178.34,24.29) v3(178.98,24.29) v3(179.03,62.93) v3(179.21,38.67) v3(179.61,24.29) v3(180.25,24.29) v3(180.73,38.67) v3(180.88,24.29) v3(181.52,24.29) v3(182.18,40.7) v3(182.15,24.29) v3(182.23,38.57) v3(182.79,24.29) v3(183.42,24.29) v3(183.57,40.7) v3(184.06,24.29) v3(184.97,40.7) v3(185.71,42.58) v3(185.71,41.95) v3(185.71,41.31) v3(185.71,40.68) v3(186.34,43.22) v3(186.34,42.58) v3(186.34,41.95) v3(186.34,41.31) v3(186.34,40.68) v3(186.98,43.22) v3(186.98,42.58) v3(186.98,41.95) v3(186.98,41.31) v3(186.98,40.68) v3(218.73,51.73) v3(219.49,51.73) v3(220.38,51.73) v3(221.27,51.73) v3(222.16,51.73) v3(222.79,50.71) v3(222.79,49.82) v3(222.92,53) v3(222.92,51.85) v3(223.81,53) v3(223.81,51.85) v3(224.57,53) v3(224.57,51.85) v3(244.89,41.57) v3(244.89,40.55) v3(244.86,39.81) v3(245.63,39.81) v3(246.52,39.81) v3(247.28,39.81) v3(248.17,39.81) v3(248.95,41.57) v3(248.95,40.55) v3(248.93,39.81)
+PWR_SRC_MXM:
  vias: v2(153.64,106.74)
+PWR_SRC_S: length 4.6
  BOTTOM w0.102: v2(29.24,140.02) PC8.1
  BOTTOM w0.508: PC8.1 28,142.5 PQ4.1
+RSVD_VCC3P3_2: length 3.5
  BOTTOM w0.102: v2(117.9,156.16) 118.35,155.71 R554.2
  BOTTOM w0.254: 119.74,154.93 120.14,154.53 U31.1
  BOTTOM w0.508: R554.2 118.91,155.53 119.52,154.93 119.74,154.93
+RTC_CELL: length 321.4
  TOP w0.254: C278.1 165.07,130.71 165.55,130.71 166.36,131.51 U29.16 ; UH1.A6 24.28,92.27 22.67,90.66 22.67,88.48 22.54,88.35 20.46,88.35 20.33,88.48 20.33,89.49 19.59,90.23 18.27,90.23 17.89,90.61 17.89,91.4 18.09,91.6 v1(18.37,91.6)
  TOP w0.356: v1(14.28,93.97) 14.23,93.97 14,94.2 JIO1.58
  TOP w0.381: U10.5 163.55,138.83 C287.1
  TOP w0.508: v1(105.85,160.34) 105.98,160.34 106.66,161.02 C1353.1 106.66,161.73 106.36,162.04 R870.1 104.81,162.47 v1(105.16,162.82) 105.16,163 105.57,163.41 R819.1 ; v1(169.15,129.68) 169.13,129.66 R395.2 ; v1(112.76,163.48) 112.76,163.56 112.71,163.61 R810.1 ; v1(165.64,130.11) 165.59,130.16 164.97,130.16 164.55,130.58 164.55,131.07 C278.1 ; C287.1 163.46,138.92 v1(162.75,138.92) ; RH43.1 RH67.2 18.5,91.73 v1(18.37,91.6) 17.76,92.21 RH44.1
  IN1 w0.508: v1(46.49,156.98) 46.95,156.53 46.95,151.93 v1(46.27,151.25)
  IN2 w0.508: v1(105.16,162.82) 105.16,163.15 105.62,163.61 112.71,163.61 112.76,163.56 v1(112.76,163.48) ; v1(169.15,129.68) 169.15,129.55 168.72,129.12 166.51,129.12 165.64,129.98 v1(165.64,130.11) 165.64,130.36 166.18,130.9 166.18,137.17 164.42,138.92 v1(162.75,138.92) 159.14,138.92 154.82,143.24 154.24,143.24 153.3,144.18 153.3,146.28 153.04,146.53 153.04,148.32 153.83,149.11 153.83,151.04 152.94,151.93 152.43,151.93 151.8,152.56 151.8,153.45 150.28,154.98 150.28,155.61 150.91,156.25 150.91,157.28 150.29,157.9 148.81,157.9 147.06,159.65 147.06,161.27 137.78,170.55 v1(118.7,170.55) ; v1(18.37,91.6) 17.57,91.6 16.23,92.94 16.23,94 15.4,94.83 15.4,96.99 14.94,97.45 14.94,100.39 13.69,101.65 13.69,105.71 15.05,107.07 15.22,107.07 15.63,107.48 15.63,109.69 16.49,110.55 16.49,112.53 18.31,114.35 18.31,114.72 18.93,115.34 18.93,115.63 21.09,117.78 21.09,119.11 21.83,119.85 22.44,119.85 22.87,120.28 22.87,123.38 22.69,123.56 22.69,126.78 28.63,132.71 30.29,132.71 31.86,134.29 31.86,135.04 33.05,136.23 36.28,136.23 38.08,138.03 38.96,138.03 40.04,139.11 40.04,140.98 42.76,143.7 44.92,143.7 46.34,145.12 46.34,145.94 47.09,146.69 47.09,150.44 v1(46.27,151.25)
  IN3 w0.508: v1(118.7,170.55) 118.7,169.9 118.39,169.58 115.5,169.58 115.15,169.22 115.15,167.7 112.68,165.24 112.68,163.57 112.76,163.5 v1(112.76,163.48)
  IN4 w0.457: v1(14.28,93.97) 14.85,93.97 15.25,94.37 15.99,94.37 18.37,91.98 v1(18.37,91.6)
  IN4 w0.508: v1(118.7,170.55) 118.44,170.81 99.94,170.81 95.04,165.91 91.66,165.91 91.41,166.16 82.01,166.16 81.49,165.64 73.31,165.64 68.93,161.27 64.32,161.27 61.4,158.34 56.54,158.34 55.1,156.9 51.85,156.9 51.36,157.39 48.55,157.39 48.14,156.98 v1(46.49,156.98)
  BOTTOM w0.254: v1(105.85,160.34) 105.75,160.44 U51.B64
  BOTTOM w0.356: 14.99,93.99 14.3,93.99 v1(14.28,93.97)
  BOTTOM w0.508: v1(46.49,156.98) 46.27,157.2 PC2.1 44.17,157.52 PD1.1 ; 14.99,93.99 15.32,94.32 v4(15.57,94.32) 16.52,94.32 16.72,94.52 RH5.1 RH42.1 ; v1(18.37,91.6) 17.99,91.6 CH55.1 CH56.1 16.71,91.21 15.5,91.21 CH57.1 ; v1(112.76,163.48) 112.76,164.3 112.3,164.76 110.22,164.76 109.97,164.5 R873.1
+SA_DIMM1_VREFDQ: length 38.1
  TOP w0.356: 136.33,91.1 136.87,90.55 JDIMM1.1
  TOP w0.508: RD41.2 RD44.2 RD43.1 129.04,84.85 v1(129.04,85.49) 129.04,86.17 129.07,86.19 129.07,87.11 129.56,87.6 CD1.1 130.86,87.6 CD2.1 131.35,87.13 135.31,91.1 136.33,91.1
  BOTTOM w0.356: 144.42,91.44 144.42,91.23 145.1,90.55 JDIMM2.1
  BOTTOM w0.508: 144.42,91.44 142.22,93.64 137.88,93.64 v2(132.44,88.2) CD2.1 130.7,87.11 CD1.1 129.42,87.6 129.04,87.22 v1(129.04,85.49)
+SA_DIMM_VREFDQ: length 92
  TOP w0.254: JCPU1.F16 91.59,45.22 v1(91.12,44.75)
  TOP w0.508: v1(127.03,83.25) RD41.1 126.56,83.91 125.73,84.75 CD89.1
  BOTTOM w0.305: v1(91.12,44.75) 91.6,44.26 91.6,39.55 91.6,39.54 91.6,39.46 91.98,39.08
  BOTTOM w0.508: v1(127.03,83.25) v2(127.03,63.5) 127.03,43.78 115.1,31.85 106.38,31.85 100.4,37.83 93.23,37.83 91.98,39.08
+SB_DIMM1_VREFDQ: length 121.2
  TOP w0.356: 150.63,92.62 149.97,91.96 149.97,90.94 150.35,90.56 JDIMM3.1
  TOP w0.508: 150.63,92.62 v1(153.68,92.62)
  IN3 w0.508: v1(153.68,92.62) 155.33,94.27 159.82,94.27 163.84,90.25 163.84,83.22 164.6,82.46 170.98,82.46 171.56,83.04 174.84,83.04 176.8,81.09 181.57,81.09 184.31,78.34 185.07,78.34 186.32,77.1 190.13,77.1 v1(190.74,77.71)
  BOTTOM w0.356: JDIMM4.1 159.4,91.39
  BOTTOM w0.508: RD50.1 RD49.2 ; RD49.2 180.67,89.11 181.01,89.46 CD45.1 CD46.1 183.49,91.08 185.58,89 185.58,86.62 190.74,81.46 v1(190.74,77.71) ; RD49.2 RD48.2 180.6,88.12 181.01,87.72 181.01,87.21 ; CD72.1 184.04,87.35 CD71.1 182.05,87.35 181.89,87.18 181.03,87.18 181.01,87.21 ; 181.01,87.21 181.01,86.98 180.55,86.52 179.47,86.52 178.12,85.18 176.39,85.18 174.96,86.6 v2(167.27,86.6) 165.74,86.6 163.31,89.04 163.31,95.41 162.01,96.71 160.77,96.71 159.4,95.34 159.4,91.39
+SB_DIMM_VREFDQ: length 160.5
  TOP w0.254: v1(94.12,44.75) 94.59,45.22 JCPU1.F13
  BOTTOM w0.305: v1(94.12,44.75) 93.64,44.26 93.64,39.17
  BOTTOM w0.508: RD48.1 CD91.1 178.98,87.11 178.29,86.42 176.56,86.42 175.68,87.31 165.93,87.31 163.94,89.3 163.94,95.68 162.27,97.34 160.5,97.34 158.29,95.13 127.59,95.13 126.27,93.81 126.27,89.9 126.4,89.77 v2(126.4,69.85) 126.4,44.04 114.84,32.48 106.65,32.48 100.54,38.59 94.21,38.59 93.64,39.17
+SDC_IN: length 354.6
  TOP w0.254: v1(25.18,74.84) 24.04,73.7 21.31,73.7 20.8,74.2 18.99,74.2 18.51,74.67 PC700.1
  IN2 w0.508: v1(176.89,87.95) 176.51,87.95 173.77,85.2 173.21,85.2 168.82,80.81 168.82,77.43 167.42,76.03 167.42,75.14 168.94,73.62 168.94,58.65 168.28,57.99 168.28,55.46 171.53,52.21 171.53,47.38 171.87,47.05 171.87,46.14 172.53,45.48 v1(172.65,45.48) ; v1(95.06,27.44) 94.99,27.44 94,28.43 89.5,28.43 88.16,27.09 85.06,27.09 84.77,26.79 82.92,26.79 77.37,21.25 76.1,21.25 74.94,20.09 74.94,17.13 75.56,16.51 75.56,13.27 74.41,12.11 74.41,9.75 72.85,8.19 68.94,8.19 67.82,7.07 62.2,7.07 59.71,4.58 51.17,4.58 45.58,10.18 45.58,25.7 42.91,28.36 42.91,33.25 40.75,35.41 40.75,44.11 39.73,45.12 39.73,47.88 42.22,50.37 42.22,54.68 39.99,56.91 39.99,66.08 35,71.07 30.43,71.07 v3(29.33,72.16)
  IN4 w0.508: v1(172.65,45.48) 174.41,45.48 175.07,44.82 175.07,32.95 166.4,24.29 136.31,24.29 134.27,26.33 128.18,26.33 126.78,27.72 95.96,27.72 95.64,27.4 95.09,27.4 v1(95.06,27.44)
  BOTTOM w0.254: v1(172.65,45.48) 174.43,45.48 174.91,44.99 174.91,44.23 175.5,43.65 PR762.1
  BOTTOM w0.508: PR1015.1 151.1,113.82 150.45,113.17 150.45,111.85 150.96,111.34 v4(150.96,104.53) 150.96,100.59 154.64,96.92 159.18,96.92 160.24,97.98 162.54,97.98 164.58,95.94 164.58,89.56 166.19,87.95 v1(176.89,87.95)
+SIM_PWR: length 97.5
  IN3 w0.508: v3(249.84,83.35) 255.48,83.35 271.38,67.45 271.38,45.45 263.05,37.12 260.26,37.12 258.01,39.37 253.56,39.37 249.31,35.11 240.37,35.11 v1(239.73,34.48)
  BOTTOM w0.508: JSIM1.1 241.39,35.47 C616.1 v4(240.07,35.02) 239.73,34.68 v1(239.73,34.48) ; JMINI2.8 250.86,85.8 250.62,85.56 C617.1 250.1,84.3 C119.1 250.03,83.54 v3(249.84,83.35)
+SM_VREF: length 66.5
  TOP w0.254: JCPU1.AM3 105.06,71.75 v1(105.12,71.75)
  TOP w0.508: v3(121.22,83.23) v2(121.22,58.63) 121.22,54.87 127.29,48.8 RD45.1 CD90.1
  BOTTOM w0.33: v1(105.12,71.75) 104.62,71.24 104.62,70.54 104.9,70.25 107.53,70.25
  BOTTOM w0.508: 107.53,70.25 114.36,70.25 121.22,77.11 v3(121.22,83.23)
+SM_VREF_DIMM: length 111.1
  TOP w0.356: v1(161.45,50.07) 161.45,50.2 160.99,50.66 JDIMM3.126 ; v1(147.8,52.33) 147.8,51.41 147.04,50.65 JDIMM1.126
  TOP w0.508: v1(130.29,46.26) 127.64,46.26 127.29,46.62 RD45.2 RD46.1 RD47.2 129.62,47.2 130.07,47.65 130.07,48.51 v1(130.34,48.78) 131,48.12 CD20.1 131.58,48.12 132.08,48.61 CD19.1
  IN1 w0.508: v1(148.5,52.33) 148.5,52.74 149.13,53.38 151.27,53.38 151.88,52.77 158.61,52.77 159.39,51.98 161.45,51.98 161.83,51.6 v1(163.1,51.6)
  IN4 w0.508: v1(164.12,44.74) 162.21,44.74 161.2,45.76 160.54,45.76 159.44,46.85 154.01,46.85 153.78,46.62 140.04,46.62 139.07,45.65 130.89,45.65 v1(130.29,46.26) ; v1(147.8,52.33) 147.8,52.07 144.15,48.42 137.83,48.42 137.58,48.17 130.84,48.17 130.34,48.68 v1(130.34,48.78)
  BOTTOM w0.356: CD19.1 132.91,49.03 v2(133.82,49.03) 135.19,49.03 135.64,49.49 135.64,49.74 136.56,50.65 JDIMM2.126 ; v1(148.5,52.33) 148.5,52.11 149.94,50.66 JDIMM4.126
  BOTTOM w0.508: v1(130.34,48.78) 131,48.12 CD20.1 132,48.12 CD19.1 ; v1(163.1,51.6) CD86.1 163.8,51.59 CD85.1 162.73,49.39 162.7,49.39 ; 162.7,49.39 CD64.1 161.96,49.57 v1(161.45,50.07) ; 162.7,49.39 163.42,48.66 CD63.1 164.37,47.41 164.96,46.82 164.96,45.58 v1(164.12,44.74)
+SW_LX: length 2.4
  BOTTOM w0.203: U23.17 75.89,143.51 75.37,142.99 75.37,142.38 75.6,142.15
  vias: v2(75.1,141.78)
+SWR_V12: length 3.4
  BOTTOM w0.203: U23.15 76.69,142.96 v1(76.59,142.86) ; U23.43 v1(75.49,151.24) ; v1(79.1,145.17) 79.07,145.17 78.85,145.39 U23.11
  vias: v1(78.24,142.53) v2(79.37,150.4)
+TRM_CT1: length 4.2
  TOP w0.102: v2(158.03,142.2) 158.43,142.59 C479.1
  TOP w0.508: T156.3 159.36,142.66 C479.1
+TRM_CT2: length 4.3
  TOP w0.102: C480.1 161.26,142.59 v2(161.87,141.98)
  TOP w0.508: C480.1 160.63,142.66 T156.4
+TRM_CT3: length 4.2
  TOP w0.102: v2(165.68,142.19) 166.21,142.72 C484.1
  TOP w0.508: T156.9 166.98,142.78 C484.1
+TRM_CT4: length 4.1
  TOP w0.102: C486.1 168.83,142.72 169.31,142.24 v2(169.57,142.24)
  TOP w0.508: C486.1 168.25,142.78 T156.10
+V_DDR_REF: length 99.6
  TOP w0.508: v1(128.02,85.49) 128.02,85.66 127.49,86.19 PC209.1
  IN3 w0.508: v1(132.55,91.88) 136.77,96.1 143.75,96.1 144.82,95.03 159.95,95.03 164.47,90.51 164.47,86.08 166.57,83.98 174.8,83.98 177.01,81.77 183.14,81.77 187.18,77.73 v1(189.85,77.73)
  IN4 w0.508: v1(189.85,77.73) 187.08,77.73 186.42,77.07 182.91,77.07 179.49,80.5 176.67,80.5 175.85,79.69 175.85,78.17 v1(175.45,77.76)
  BOTTOM w0.203: v1(175.45,77.76) 175.47,77.76 175.73,77.5 PU200.4
  BOTTOM w0.508: v1(132.55,91.88) 132.55,89.78 131.58,88.81 128.94,88.81 128.05,87.92 v4(128.05,87.25) 128.05,85.51 v1(128.02,85.49)
+VCHGR: length 25.2
  BOTTOM w0.102: v4(204.49,38.45) 205.49,39.46 205.86,39.46 PQ1005.3
  BOTTOM w0.508: PQ1083.3 209.66,28.25 212.84,31.43 212.84,38.31
+VCOMP_OUT: length 5.3
  TOP w0.381: v1(86.12,45.75) 85.65,45.28 JCPU1.F22
  BOTTOM w0.381: RC1.1 83.57,48.12 RC2.1 83.78,48.14 84.18,47.74 84.18,47.46 84.79,46.85 85.07,46.85 v2(85.42,46.51) 86.12,45.8 v1(86.12,45.75)
+VDISPLAY_VCC: length 7.5
  TOP w0.102: R461.1 R460.1 23.39,164.36 23.39,165.76 23.25,165.9 23.25,166.16 23.34,166.25 23.34,169.7 v1(22.97,170.06)
  vias: v2(23.48,166.7)
+VR_CAP: length 6.9
  TOP w0.508: v1(107.07,155.51) 107.07,155.26 v2(107.43,154.9) 107.46,154.86 111.59,154.86 C779.1
  BOTTOM w0.305: v1(107.07,155.51) 107.07,155.38 107.45,155 108.06,155 108.08,155.02 U51.B12
A_ON: length 174.1
  TOP w0.102: v1(104.96,152.66) 104.96,147.86 105.32,147.51 105.32,146.77 v1(106.54,145.55) ; PR315.2 19.16,145.96 19.01,145.96 18.63,145.58 18.63,143.77 20.76,141.64 22.21,141.64 22.93,142.36 24.74,142.36 25.86,143.49 26.58,143.49 27.94,144.84 28.89,144.84 29.65,144.08 33.68,144.08 35.47,142.29 37.35,142.29 37.82,142.76 39.35,142.76 43.16,146.57 44.55,146.57 45.49,147.51 45.78,147.51 46.24,147.97 46.24,149.97 47.04,150.77 v1(48.21,150.77)
  IN1 w0.109: v1(106.54,145.55) 106.19,145.21 106.19,143.88 104.73,142.42 104.73,137.58 105.64,136.67 105.64,135.82 108.16,133.3 108.16,131.54 v1(108.15,131.53)
  IN3 w0.127: v1(48.21,150.77) 48.81,150.77 49.6,151.56 49.6,152.26 51.84,154.49 57.06,154.49 60.76,158.19 62.55,158.19 64.57,160.21 77.81,160.21 78.24,160.64 85.28,160.64 85.81,160.11 86.52,160.11 87.13,160.72 87.89,160.72 90.03,158.58 90.03,154.1 91.93,152.19 93.12,152.19 96.25,149.07 97.5,149.07 100.88,145.69 106.4,145.69 v1(106.54,145.55) ; v1(108.15,131.53) 110.59,129.09 114.65,129.09 119.2,124.55 119.2,120.08 123.61,115.67 v1(124.32,115.67)
  BOTTOM w0.102: v1(106.54,145.55) 106.46,145.63 R429.2 ; v1(124.32,115.67) 122.88,115.67 118.74,111.53 v2(118.74,109.75) 119.42,109.07 U35.5 ; v1(104.96,152.66) 104.91,152.61 104.91,152.33 104.75,152.17 U51.B24
AC_DIS: length 530.3
  TOP w0.102: v1(215.92,78) 216.34,78.42 217.1,78.42 217.41,78.12 217.41,75.98 220.46,72.93 221.29,72.93 222.21,72.02 225.79,72.02 226.5,71.31 236.84,71.31 v1(237.57,72.05) ; PQ8.5 18.07,68.51 17.59,68.03 16.82,68.03 16.01,67.22 v1(16.01,66.3)
  IN1 w0.109: v1(237.57,78.27) 238.15,78.27 239.73,79.85 242.85,79.85 243.33,79.37 250.66,79.37 251.09,79.8 251.09,79.8 252.89,81.6 262.89,81.6 266.81,77.68 266.81,76.49 272.96,70.34 272.96,46.25 262.9,36.19 258.58,36.19 258.45,36.32 257.69,36.32 257.47,36.1 252.13,36.1 250.91,34.89 237.25,34.89 223.04,20.68 200.74,20.68 199.95,19.89 131.58,19.89 131,20.48 106.65,20.48 103.3,23.82 86.39,23.82 85.08,22.52 85.08,20.13 79.77,14.81 79.77,13.42 72.5,6.15 60.74,6.15 58.74,4.15 49.47,4.15 43.37,10.26 43.37,16.7 41.87,18.19 41.87,24.43 38.72,27.58 38.72,30.58 35.19,34.1 35.19,48.33 38.71,51.85 38.71,53.21 36.37,55.55 36.37,64.9 34.2,67.07 34.2,68.31 33.47,69.05 30.51,69.05 29.27,67.8 28.3,67.8 28,67.5 17.18,67.5 16.01,66.33 v1(16.01,66.3) ; v1(171.61,111.72) 171.61,111.71 175.91,107.41 177.1,107.41 185.85,98.67 192.68,98.67 197.3,94.05 197.3,91.23 202.08,86.45 208.95,86.45 210.01,85.4 211.97,85.4 212.65,84.71 214.81,84.71 215.41,84.11 215.91,84.11 216.3,83.72 216.3,78.83 215.92,78.44 v1(215.92,78)
  IN3 w0.127: v1(237.57,72.05) v1(237.57,78.27)
  BOTTOM w0.102: U46.B12 216.42,77.5 v1(215.92,78) ; v1(237.57,72.05) v2(238.11,72.05)
  BOTTOM w0.254: v1(171.61,111.72) 171.61,110.04 169.44,107.87 167.33,107.87 162.17,102.72 158.99,102.72 158.49,103.21 158.49,104.15 157.2,105.45 PR1030.2
AC_PRESENT: length 151
  TOP w0.102: UH1.E6 26.37,92.17 v1(26.11,91.91)
  IN2 w0.127: v1(100.29,166.99) 97.55,166.99 93.61,163.06 88.09,163.06 86.98,164.17 82.26,164.17 81.54,164.89 78.99,164.89 78.26,165.62 74.59,165.62 74,165.02 74,163.84 70.15,159.99 69.04,159.99 65.61,156.56 57.76,156.56 52.94,151.74 51.26,151.74 50.29,150.76 50.29,147.63 47.99,145.33 47.99,142.25 46.52,140.78 44.71,140.78 43.24,139.3 42.48,139.3 41.39,138.21 41.39,136.61 35.83,131.05 29.21,131.05 26.35,128.19 26.35,124.51 25.32,123.49 25.32,119.38 22.95,117.02 22.57,117.02 20.52,114.97 20.52,114.68 19.93,114.09 19.93,111.74 17.22,109.03 17.22,106.82 17.08,106.68 17.08,101.46 17.69,100.85 17.69,97.69 18.19,97.18 18.19,96.43 18.83,95.79 18.83,95.42 19.34,94.91 19.34,94.13 20.63,92.84 22.78,92.84 23.71,91.91 v1(26.11,91.91)
  BOTTOM w0.102: U51.A54 102.5,164.07 R835.2 101.81,164.76 101.81,165.44 101.61,165.64 100.97,165.64 v2(100.29,166.33) v1(100.29,166.99)
ACAV_DOCK_SRC#: length 84.7
  IN2 w0.254: v1(152.78,111.99) 152.29,112.47 147.42,112.47 146.52,113.37 131.45,113.37 128.19,116.63 121.59,116.63 119.01,114.06 101.93,114.06 98.75,117.24 96.73,117.24 95.08,118.9 95.08,122.54 v1(95.74,123.2)
  BOTTOM w0.102: v2(153.04,111.5) 152.78,111.77 v1(152.78,111.99)
  BOTTOM w0.254: PR1017.1 152.13,113.93 PR1013.2 152.13,112.7 152.78,112.05 v1(152.78,111.99) ; JDOCK1.42 83.2,125.2 83.96,124.45 88.22,124.45 88.48,124.19 94.75,124.19 v1(95.74,123.2)
ACAV_IN: length 347.2
  TOP w0.102: v1(170.95,127.09) 170.28,127.09 169.58,127.79 169.58,130 169.32,130.26 U29.21
  IN1 w0.109: v1(148.01,113.4) 148.01,109.95 155.51,102.46 160.23,102.46 177.36,85.33 179.03,85.33 179.28,85.08 181.91,85.08 185.04,81.95 196.94,81.95 v1(201.71,77.18)
  IN2 w0.127: v1(170.95,127.09) 170.87,127.16 169.96,127.16 169.33,127.8 166.15,127.8 164.42,129.53 156.77,129.53 155.07,131.23 155.07,134.73 148.55,141.25 146.9,141.25 140.67,147.48 133.33,147.48 126.9,153.91 126.6,153.91 125.78,154.73 125.78,156.31 124.96,157.12 122.93,157.12 120.21,159.85 120.21,160.27 119.43,161.05 116.36,161.05 114.65,162.75 114.65,163.28 114.05,163.88 113.48,163.88 113.22,163.61 113.22,163.18 112.78,162.75 108.52,162.75 108.03,162.27 v1(108.03,162.19)
  IN3 w0.127: v1(205.6,67.98) 205.6,57.9 207.6,55.89 211.13,55.89 215.38,51.65 215.38,47.11 212.16,43.89 197.71,43.89 195.98,45.62 179.06,45.62 177.66,47.01 177.21,47.01 170.9,53.33 170.9,55.81 171.26,56.17 v1(171.56,56.17)
  IN4 w0.109: v1(170.95,127.09) 170.07,126.21 170.07,119.71 169.57,119.2 163.02,119.2 158.59,114.78 149.4,114.78 v1(148.01,113.4)
  BOTTOM w0.102: v1(148.01,113.4) 148.59,113.4 PR1021.1 149.2,113.48 146.87,111.16 145.78,111.16 144.73,112.21 143.83,112.21 140.64,109.01 139.96,109.01 135.02,104.07 v2(132.42,104.07) 122.16,104.07 121.73,103.64 121.73,103.21 122.07,102.87 U17.1 ; U51.A64 107.82,161.97 v1(108.03,162.19) ; PQ710.3 169.99,54.23 170.26,54.51 PR717.1 170.26,55.89 PR772.2 170.54,56.17 v1(171.56,56.17) ; v1(201.71,77.18) 201.96,76.92 201.96,73.44 205.6,69.81 v1(205.6,67.98) 206.16,68.54 214.16,68.54 215.45,69.84 219.32,69.84 220.59,68.57 220.59,67.8 221.02,67.37 224.04,67.37 226.81,64.6 PQ707.2
ACAV_IN_NB: length 181.2
  IN1 w0.254: v1(153.88,128.38) 153.88,126.71 157.16,123.43 157.16,118.26 157.95,117.47 157.95,117.09 159.32,115.72 159.32,114.33 161.02,112.63 161.02,110.38 169.84,101.56 172.42,101.56 181.85,92.13 181.85,88.13 183.45,86.52 v1(183.85,86.52)
  IN2 w0.254: v1(183.85,86.52) 183.96,86.62 184.54,86.62 195.36,75.8 198.83,75.8 203.82,70.81 203.82,66.36 211.21,58.96 224.71,58.96 224.96,58.71 v1(225.9,58.71)
  IN3 w0.254: v1(153.88,128.38) 153.88,128.48 154.11,128.71 154.11,136.6 144.22,146.49 139.13,146.49 136.59,149.03 129.6,149.03 127.08,151.56 125.64,151.56 124.45,152.74 115.69,152.74 115.29,153.15 109.43,153.15 108.06,154.52 106.84,154.52 106.56,154.24 106.56,153.58 v1(106.93,153.21)
  BOTTOM w0.254: v1(153.88,128.38) 153.88,127.98 v2(153.51,127.61) 152.82,126.91 PR1019.2 ; U51.B20 106.75,152.19 106.61,152.32 106.61,152.89 v1(106.93,153.21) ; PR742.1 v1(225.9,58.71)
ACAVDK_SRC: length 2.6
  BOTTOM w0.254: PR1017.2 152.31,115.17 v2(152.31,115.95) 152.31,116.63 152.2,116.74 PU1001.4
ACAVIN: length 5.1
  BOTTOM w0.102: v2(149.25,113.04) 149.25,113.17 149.65,113.57 149.65,114.46 PR1021.2
  BOTTOM w0.254: PU1001.8 150.2,115.93 PR1021.2
ACDET: length 5.9
  BOTTOM w0.254: PU700.6 v2(175.27,47.5) 174.26,47.5 PR732.2 PC783.1 175.8,45.07 PR762.2
ACPRN: length 17.9
  IN1 w0.254: v1(173.34,55.28) 173.74,55.28 175.83,53.2 175.83,46.85 176.59,46.09 v3(176.59,45.48)
  BOTTOM w0.254: PU700.5 177.23,45.13 PR771.2 176.59,44.64 v3(176.59,45.48) ; PQ710.5 172.25,53.12 172.7,53.58 v2(172.7,54.98) 173.01,55.28 v1(173.34,55.28)
ADP_I: length 475.5
  TOP w0.102: v1(172.32,25.77) 172.68,26.12 172.68,33.72 174.44,35.49 174.44,40.8 173.24,42.01 169.2,42.01 167.93,43.28 v1(167.93,46.47)
  IN2 w0.102: v1(52.23,15.02) 52.23,13.89 57.5,8.62 72.67,8.62 73.97,9.93 73.97,12.29 75.13,13.44 75.13,16.33 74.51,16.95 74.51,20.26 75.92,21.68 77.19,21.68 82.74,27.23 84.59,27.23 84.88,27.52 87.22,27.52 87.42,27.72 87.42,28.14 88.15,28.87 94.43,28.87 95.96,27.34 112.02,27.34 114.88,24.48 132.41,24.48 136.32,20.57 148.34,20.57 151.35,23.58 170.14,23.58 v1(172.32,25.77)
  IN3 w0.127: v1(113.14,153.78) 113.37,153.55 115.4,153.55 115.9,153.06 126.58,153.06 129.42,150.21 135.86,150.21 139.26,146.81 144.35,146.81 155.16,136 155.16,127.81 158,124.97 158,123.94 163.19,118.76 167.19,118.76 168.09,117.85 168.09,110.01 180.45,97.65 192.08,97.65 192.71,97.01 195.54,97.01 200.72,91.83 v1(200.72,90.54)
  IN3 w0.254: v3(217.71,52.49) 217.46,52.49 216.7,51.73 216.7,47.05 212.48,42.84 197.42,42.84 195.46,44.79 175.37,44.79 173.36,46.8 172.27,46.8 171.18,45.71 169.53,45.71 169.27,45.45 168.35,45.45 167.93,45.87 v1(167.93,46.47)
  BOTTOM w0.102: v1(52.23,15.02) 52.23,15.25 47.81,19.67 47.81,26.93 45.83,28.92 45.83,31.44 39.42,37.86 39.42,47.62 41.37,49.58 41.37,54.54 39.66,56.26 39.66,66.16 35.02,70.8 35.02,74.8 34.73,75.09 PR702.1 ; v1(200.72,90.54) 200.72,75.27 201.43,74.56 201.43,72.99 203.87,70.55 203.87,63.7 v2(208.86,58.71) 214.91,52.66 216.39,52.66 216.82,52.23 217.46,52.23 v3(217.71,52.49) ; R1982.2 112.33,153.78 v1(113.14,153.78) 113.17,153.76 PC746.1
  BOTTOM w0.254: PR743.1 218.31,53.09 v3(217.71,52.49) ; v1(167.93,46.47) 168.31,46.85 PR704.1
ADP_I_R: length 2.8
  BOTTOM w0.102: R1982.1 110.78,153.58 110.33,154.02 110.33,154.6 v2(110.26,154.66) 110.16,154.77 U51.A12
ALERT#: length 4.1
  TOP w0.102: PR506.2 48.87,23.02 v1(48.93,23.09) 48.93,23.11 49.21,23.39 49.32,23.39 v2(49.84,23.91) 50.13,24.2 50.13,24.2 50.73,24.8 PU500.32
  BOTTOM w0.102: PR503.1 48.99,23.02 v1(48.93,23.09)
ALW_PWRGD_3V_5V: length 210
  IN3 w0.127: v1(251.54,63.64) 250.2,64.98 245.09,64.98 244.03,66.05 238.69,66.05 228.94,75.8 228.94,77.43 230.03,78.53 230.03,82.53 229.22,83.34 229.22,84.62 224.29,89.55 217.53,89.55 217.18,89.9 209.86,89.9 206.66,93.1 202.78,93.1 196.68,99.2 181.06,99.2 172.98,107.27 172.98,116.83 168.66,121.16 162.58,121.16 159.27,124.47 159.27,125.49 156.43,128.33 156.43,137.49 155.25,138.67 155.25,140.08 153.21,142.13 153.21,145.49 148.92,149.78 147.5,149.78 143.92,153.36 142.92,153.36 138.45,157.83 135.12,157.83 132.31,160.64 127.87,160.64 127.33,161.18 124.72,161.18 123.98,161.92 118.21,161.92 117.08,160.79 112.43,160.79 111.06,162.16 v1(110.42,162.16)
  BOTTOM w0.102: v1(110.42,162.16) v2(110.42,161.54) 110.42,161.33 109.37,160.27 U51.A1 ; PR118.1 251.83,60.7 252.23,61.1 252.23,62.95 v1(251.54,63.64)
ALWON: length 200.1
  IN3 w0.127: v1(239,66.48) 238.77,66.48 229.19,76.06 229.19,77.33 230.29,78.42 230.29,84.26 228.18,86.37 227.97,86.37 224.54,89.8 217.71,89.8 216.59,90.92 209.38,90.92 206.92,93.38 202.88,93.38 196.78,99.48 181.14,99.48 173.24,107.38 173.24,116.93 168.76,121.41 162.69,121.41 159.53,124.57 159.53,125.6 156.69,128.44 156.69,139.37 153.72,142.34 153.72,145.7 149.13,150.29 147.71,150.29 143.73,154.26 142.78,154.26 135.9,161.15 128.3,161.15 127.76,161.69 124.93,161.69 124.19,162.43 118,162.43 116.87,161.3 115.71,161.3 114.93,162.08 111.96,162.08 110.91,163.13 106.18,163.13 v1(105.8,162.75)
  BOTTOM w0.102: v1(239,66.48) v2(240.41,65.07) 241.41,64.07 PR112.1 ; U51.A60 105.5,162.45 v1(105.8,162.75)
AUD_HP_NB_SENSE: length 245.4
  TOP w0.102: JIO1.70 12.09,90.6 v1(11.64,90.16) ; v1(198.48,93.46) 200.82,93.46 201.3,92.97 216.47,92.97 218.25,91.2 218.25,89.62 218.3,89.57 218.3,87.6 v1(218.17,87.47)
  IN2 w0.127: v1(198.48,93.46) 198.1,93.84 180.18,93.84 179.55,94.47 164.72,94.47 161.24,97.95 155.26,97.95 154.63,98.59 140.37,98.59 137.22,101.74 135.14,101.74 132.3,98.9 132.3,96.78 130.68,95.16 118.7,95.16 117.45,96.42 114.15,96.42 113.89,96.67 89.49,96.67 87.43,94.61 83.41,94.61 81.44,92.64 76.51,92.64 72.58,88.71 71.42,88.71 66.65,83.94 53.47,83.94 51.86,82.33 47.28,82.33 46.09,81.14 42.88,81.14 42.58,81.44 42.58,81.54 42.3,81.82 36.66,81.82 36.2,81.37 35.44,81.37 34.22,82.59 29.45,82.59 28.69,81.82 24.32,81.82 24.09,81.6 24.09,80.83 23.25,80 19.11,80 17.69,81.42 17.1,81.42 16.67,80.99 16.67,80.22 16.16,79.72 14.1,79.72 8.77,85.04 8.77,88.75 9.23,89.22 10.7,89.22 v1(11.64,90.16)
  BOTTOM w0.102: v1(11.64,90.16) v2(12.37,90.16) ; U46.A41 v1(218.17,87.47)
AUD_NB_MUTE#: length 229.3
  TOP w0.102: v1(15.15,88.71) 15.15,88.83 13.98,90 JIO1.72
  IN2 w0.127: v1(182,97.11) 179.79,97.11 175.98,100.92 140.45,100.92 138.11,103.26 133.41,103.26 129.17,99.02 129.17,97.67 128.71,97.22 120.12,97.22 119.54,97.79 119.54,98.13 118.78,98.89 114.23,98.89 114.01,99.11 87.87,99.11 87.11,98.35 84.4,98.35 80.48,94.42 75.78,94.42 71.84,90.49 70.37,90.49 65.61,85.72 61.89,85.72 60.59,87.02 59.37,87.02 58.4,86.05 52,86.05 50.75,84.81 46.89,84.81 46.57,84.49 41.15,84.49 41.03,84.38 35.68,84.38 35.08,84.98 23.21,84.98 22.06,83.83 22.06,83.29 21.63,82.87 19.27,82.87 15.71,86.43 15.71,88.32 15.32,88.71 v1(15.15,88.71)
  BOTTOM w0.102: v1(182,97.11) 182.18,97.29 191.8,97.29 193.5,95.59 204.7,95.59 209.04,91.25 211.34,91.25 v2(211.65,91.56) 213.62,91.56 214.14,91.04 214.33,91.04 216.34,89.03 216.34,88.15 216.98,87.51 v1(216.98,87.47) 217.17,87.28 U46.A39
AUDIO_BACKLITE#: length 251.9
  TOP w0.102: v1(15.02,80.4) 14.42,81 JIO1.102
  IN2 w0.127: v1(15.02,80.4) 16.54,81.93 19.32,81.93 20.74,80.5 22.51,80.5 22.96,80.95 22.96,81.38 23.91,82.33 28.33,82.33 29.09,83.09 34.43,83.09 35.65,81.87 35.99,81.87 36.45,82.33 43.37,82.33 43.72,81.98 46.21,81.98 47.07,82.84 51.65,82.84 53.26,84.45 66.44,84.45 71.2,89.22 72.37,89.22 76.3,93.15 81.23,93.15 84.56,96.48 88.45,96.48 89.15,97.18 114.15,97.18 114.4,96.92 117.66,96.92 118.91,95.67 129.88,95.67 131.53,97.32 131.53,98.87 134.91,102.25 137.43,102.25 140.53,99.15 154.79,99.15 155.48,98.46 161.45,98.46 164.93,94.98 179.76,94.98 180.4,94.35 198.55,94.35 199.25,93.65 199.25,83.17 203.49,78.92 203.49,74.84 208.07,70.25 215.96,70.25 217.56,71.86 217.56,72.38 218.57,73.39 v1(222.39,73.39)
  BOTTOM w0.102: U46.B68 222.39,77.15 222.39,76.29 223.6,75.07 v2(223.6,74.84) 223.6,74.61 v1(222.39,73.39)
AUX_EN_WOWL: length 168.2
  TOP w0.102: v2(125.22,167.7) 124.89,168.03 v1(124.89,168.79) 125.09,168.59 R844.1
  IN1 w0.109: v1(124.89,168.79) 126.27,168.79 126.86,168.21 126.86,165.12 125.78,164.05 125.78,163.61 126.41,162.99 128.13,162.99 128.91,162.21 134.66,162.21 137.64,159.23 141.13,159.23 146.89,153.46 147.61,153.46 151.47,149.61 151.47,143.39 155.26,139.59 155.26,137.72 158.5,134.48 159.93,134.48 160.49,133.92 165.85,133.92 167.07,135.14 173.16,135.14 173.71,134.59 173.71,127.49 171.04,124.82 171.04,121.61 172.6,120.05 172.6,112.81 175.37,110.04 175.71,110.04 176.98,108.77 176.98,108.64 186.24,99.38 193,99.38 198.03,94.35 198.03,91.53 202.37,87.18 211.06,87.18 212.12,86.12 218.5,86.12 219.28,85.34 219.28,79.24 220.13,78.4 220.99,78.4 v1(221.42,77.96)
  BOTTOM w0.102: U46.B67 221.61,77.77 v1(221.42,77.96)
AUX_MODE_EN: length 6.6
  TOP w0.102: v1(219.13,90.74) 219.24,90.84 220.56,90.84 220.76,90.64 220.76,90.1 220.17,89.51 v1(220.17,87.47)
  BOTTOM w0.102: RP8.1 218.85,91.03 v1(219.13,90.74) ; U46.A45 v1(220.17,87.47)
BAT1_LED#: length 259.4
  TOP w0.102: JIO1.106 15.03,79.8 v1(15.63,80.4) 15.63,80.72 v2(15.87,80.96)
  IN2 w0.127: v1(15.63,80.4) 16.9,81.67 19.21,81.67 20.63,80.25 23.14,80.25 23.83,80.94 23.83,81.7 24.21,82.08 28.48,82.08 29.24,82.84 34.32,82.84 35.54,81.62 36.1,81.62 36.56,82.08 42.41,82.08 42.83,81.65 42.83,81.57 43.01,81.39 45.99,81.39 47.18,82.59 51.75,82.59 53.37,84.2 66.55,84.2 71.31,88.96 72.47,88.96 76.41,92.9 81.34,92.9 84.67,96.23 88.63,96.23 89.33,96.92 114.04,96.92 114.3,96.67 117.55,96.67 118.81,95.41 130.57,95.41 131.95,96.79 131.95,98.93 135.01,101.99 137.33,101.99 140.45,98.87 154.71,98.87 155.37,98.21 161.35,98.21 164.83,94.73 179.66,94.73 180.29,94.09 198.44,94.09 198.99,93.54 198.99,83.06 203.23,78.82 203.23,74.73 207.97,70 216.06,70 217.93,71.87 218.3,71.87 218.58,72.15 218.58,72.22 219.36,73.01 221.22,73.01 221.32,72.91 223.76,72.91 224.11,73.26 224.11,77.18 221.95,79.33 221.63,79.33 v1(221.19,79.77)
  BOTTOM w0.102: v1(221.19,79.77) 221.69,79.27 U46.B64
BAT2_LED#: length 245.4
  TOP w0.102: v1(14.38,80.4) JIO1.104
  IN2 w0.127: v1(203.62,80.78) 203.62,81.32 201.35,83.58 201.35,91.15 200.11,92.39 200.11,93.56 198.81,94.85 181.69,94.85 175.88,100.67 140.34,100.67 138,103.01 133.51,103.01 129.47,98.97 129.47,97.62 128.79,96.94 119.44,96.94 117.74,98.64 114.12,98.64 113.91,98.85 87.97,98.85 87.33,98.21 87.33,97.78 87.04,97.5 83.96,97.5 80.63,94.17 75.88,94.17 71.94,90.23 70.7,90.23 65.93,85.47 61.78,85.47 61.15,86.1 58.81,86.1 58.51,85.8 52.1,85.8 50.86,84.55 46.99,84.55 46.68,84.24 41.25,84.24 41.14,84.12 35.58,84.12 34.98,84.72 23.31,84.72 22.31,83.72 22.31,83.19 21.73,82.61 16.59,82.61 v1(14.38,80.4)
  BOTTOM w0.102: U46.A9 217.67,74.21 217.4,73.94 217.4,72.5 216.37,71.48 v2(216.1,71.48) 215.87,71.24 214.05,71.24 212.72,69.91 207.58,69.91 203.59,73.9 203.59,80.76 v1(203.62,80.78)
BBS_BIT1: length 9.5
  TOP w0.102: UH1.C10 25.08,93.81 24.98,93.91 24.98,93.91 24.79,94.09 24.79,94.1 24.77,94.12 24.76,94.12 24.76,94.12 24.47,94.12 24.21,93.86 23.19,93.86 23.12,93.94 22.47,93.94 v2(22.25,93.71) 22.22,93.69 20.66,93.69 20.23,94.12 17.38,94.12 17.28,94.02 17.28,93.99 RH119.1
BC_CLK_ECE1117: length 109.6
  TOP w0.102: v2(174.57,118.1) 175.17,117.5 v1(175.47,117.5) JKB1.18 JKB1.17
  IN4 w0.109: v1(106.31,150) 108.06,151.75 108.06,153.41 110.25,155.6 110.75,155.6 112,156.84 123.26,156.84 125.97,159.55 126.5,159.55 126.81,159.24 130.15,159.24 132.63,156.77 133.63,156.77 140.18,150.23 148.47,150.23 150.45,148.25 150.45,146.02 150,145.57 150,140.8 156.51,134.29 164.24,134.29 166.09,132.44 170.47,132.44 172.45,130.46 173.2,130.46 174.22,129.44 174.22,118.89 175.47,117.63 v1(175.47,117.5)
  BOTTOM w0.102: U51.A20 106,150.31 v1(106.31,150)
