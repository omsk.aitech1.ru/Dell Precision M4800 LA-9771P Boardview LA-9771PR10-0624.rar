# Allegro board LA-9771PR10-0624.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCLK_80H: length 156.2
  IN4 w0.109: v1(128.46,153.76) 126.97,153.76 126.65,154.08 120.32,154.08 119.15,155.24 113.67,155.24 113.29,154.87 112.67,154.87 110.36,152.56 110.36,149.27 109.91,148.83 109.91,143.47 110.14,143.24 110.14,140.51 109.76,140.13 109.22,140.13 108.94,140.41 108.94,140.94 108.69,141.19 107.24,141.19 106.77,140.73 97.81,140.73 94.24,137.16 90.76,137.16 89.55,138.37 84.57,138.37 81.22,135.02 68.27,135.02 65.88,137.41 61.62,137.41 60.31,138.72 56.56,138.72 56.28,139 54.53,139 53.03,137.5 53.03,136.14 52.59,135.7 51.85,135.7 51.47,136.08 43,136.08 41.14,134.21 39.26,134.21 34.31,129.26 34.31,122.18 31.96,119.83 31.96,118.61 29.61,116.26 29.61,114.7 28.89,113.98 28.89,113.42 28.36,112.89 24.37,112.89 v1(22.08,110.6)
  BOTTOM w0.102: RH159.1 21.8,110.32 v1(22.08,110.6) ; JMINI4.19 132.52,148.94 129.65,151.81 129.65,152.57 v1(128.46,153.76)
PECI_EC: length 98.4
  TOP w0.102: JCPU1.AR27 v1(80.12,74.75)
  IN1 w0.109: v1(80.12,74.75) 80.12,74.76 80.63,75.27 80.63,79 81.86,80.24 81.86,98.42 82.08,98.64 82.08,103.92 81.88,104.13 81.88,110.86 80.88,111.86 80.88,113.73 83.18,116.02 83.18,125.96 81.75,127.39 81.75,128.03 82.61,128.89 83.3,128.89 84.09,129.68 84.09,130.81 83.45,131.46 83.45,134.15 84.09,134.8 84.09,138.64 80.63,142.1 80.63,147.32 84.09,150.79 86.65,150.79 87.18,151.32 v1(87.18,151.93)
  BOTTOM w0.102: R952.2 92.19,158.41 91.09,157.31 91.09,154.16 v2(89.4,152.47) 88.86,151.93 v1(87.18,151.93)
PECI_EC_R: length 5.6
  BOTTOM w0.102: R952.1 94.67,159.37 v2(96,159.37) 97.21,160.59 97.9,160.59 98.22,160.27 U51.A48
PEG_B_CLKRQ#: length 10.5
  TOP w0.102: RH130.2 27.8,83.25 27.8,85.18 29.78,87.16 v2(30.06,87.16) 30.45,87.16 31.63,88.34 31.63,89.61 31.6,89.64 31.6,89.91 31.61,89.92 31.61,89.93 31.79,90.11 31.79,90.36 31.5,90.65 UH1.U4
PEG_COMP: length 4.4
  TOP w0.305: JCPU1.E23 84.59,44.22 v1(84.12,43.75)
  BOTTOM w0.305: RC2.2 83.63,47.2 83.63,45.32 v2(84.12,44.83) v1(84.12,43.75)
PEG_CRX_GTX_C_N0: length 3.1
  TOP w0.109: CC16.1 87.24,107.36 87.24,106.9 v3(87.42,106.72) 87.61,106.53 87.61,105.91 87.75,105.77 JMXM1.177
PEG_CRX_GTX_C_N1: length 2.9
  TOP w0.109: JMXM1.171 89.25,105.76 89.11,105.91 89.11,106.92 89.04,106.98 89.04,107.38 CC15.1
PEG_CRX_GTX_C_N2: length 3
  TOP w0.109: CC14.1 90.84,107.4 90.84,106.72 90.61,106.48 90.61,105.88 90.75,105.74 JMXM1.165
PEG_CRX_GTX_C_N3: length 3.9
  TOP w0.109: CC13.1 92.67,107.39 92.67,107.03 92.8,106.89 93.54,106.89 v3(93.73,106.7) 94.11,106.33 94.11,105.91 94.25,105.77 JMXM1.157
PEG_CRX_GTX_C_N4: length 3.7
  TOP w0.109: CC12.1 94.42,107.36 94.42,107.24 94.8,106.86 95.24,106.86 95.61,106.5 95.61,105.94 95.75,105.79 JMXM1.151
PEG_CRX_GTX_C_N5: length 3.3
  TOP w0.109: JMXM1.145 97.25,105.77 97.11,105.91 97.11,106.29 v3(96.62,106.78) 96.2,107.2 96.2,107.36 CC11.1
PEG_CRX_GTX_C_N6: length 3.2
  TOP w0.109: CC10.1 98,107.39 98,107.07 98.01,107.07 v3(98.28,106.79) 98.61,106.47 98.61,105.91 98.75,105.76 JMXM1.139
PEG_CRX_GTX_C_N7: length 3
  TOP w0.109: CC9.1 99.79,107.4 99.79,106.82 100.11,106.51 100.11,105.93 100.25,105.78 JMXM1.133
PEG_CRX_GTX_C_N8: length 3
  TOP w0.109: JMXM1.127 101.75,105.74 101.61,105.88 101.61,106.3 101.61,106.3 v3(101.61,106.72) 101.61,107.04 101.61,107.05 101.61,107.25 101.54,107.31 101.54,107.37 CC8.1
PEG_CRX_GTX_C_N9: length 3
  TOP w0.109: JMXM1.121 103.25,105.79 103.11,105.93 103.11,106.62 103.32,106.83 103.32,107.37 CC7.1
PEG_CRX_GTX_C_N10: length 3.1
  TOP w0.109: CC6.1 105.11,107.39 105.11,106.87 104.61,106.36 104.61,105.9 104.75,105.76 JMXM1.115
PEG_CRX_GTX_C_N11: length 3.3
  TOP w0.109: CC5.1 106.89,107.39 106.89,107.02 106.63,106.75 106.63,106.72 106.2,106.3 106.17,106.3 106.11,106.23 106.11,105.93 106.25,105.78 JMXM1.109
PEG_CRX_GTX_C_N12: length 3.5
  TOP w0.109: CC4.1 108.67,107.39 108.67,107.1 108.34,106.77 108.07,106.77 107.61,106.3 107.61,105.9 107.75,105.76 JMXM1.103
PEG_CRX_GTX_C_N13: length 3.7
  TOP w0.109: JMXM1.97 109.25,105.78 109.11,105.92 109.11,106.18 109.58,106.65 109.95,106.65 110.46,107.16 110.46,107.4 CC3.1
PEG_CRX_GTX_C_N14: length 3.9
  TOP w0.109: CC2.1 112.21,107.37 112.21,107.18 111.96,106.94 111.42,106.94 111.24,106.75 111.24,106.72 110.82,106.31 110.79,106.31 110.61,106.12 110.61,105.9 110.75,105.75 JMXM1.91
PEG_CRX_GTX_C_N15: length 4.2
  TOP w0.109: JMXM1.85 112.25,105.75 112.11,105.89 112.11,106.02 112.21,106.12 113.03,106.12 113.31,106.4 113.34,106.4 113.76,106.82 113.76,106.86 113.97,107.07 113.97,107.36 CC1.1
PEG_CRX_GTX_C_P0: length 3.1
  TOP w0.109: CC32.1 87.03,107.4 87.03,106.78 87.39,106.41 87.39,105.91 87.25,105.77 JMXM1.179
PEG_CRX_GTX_C_P1: length 2.9
  TOP w0.109: CC31.1 88.83,107.38 88.83,106.89 88.89,106.83 88.89,105.89 88.75,105.74 JMXM1.173
PEG_CRX_GTX_C_P2: length 3
  TOP w0.109: CC30.1 90.63,107.36 90.63,106.8 90.39,106.57 90.39,105.88 90.25,105.73 JMXM1.167
PEG_CRX_GTX_C_P3: length 3.9
  TOP w0.109: CC29.1 92.46,107.37 92.46,106.94 92.74,106.65 93.45,106.65 93.89,106.21 93.89,105.89 93.75,105.74 JMXM1.159
PEG_CRX_GTX_C_P4: length 3.7
  TOP w0.109: JMXM1.153 95.25,105.77 95.39,105.91 95.39,106.41 95.16,106.65 94.71,106.65 94.21,107.16 94.21,107.4 CC28.1
PEG_CRX_GTX_C_P5: length 3.3
  TOP w0.109: CC27.1 95.99,107.4 95.99,107.06 96.18,106.87 96.18,106.86 96.66,106.39 96.66,106.39 96.89,106.15 96.89,105.91 96.75,105.77 JMXM1.147
PEG_CRX_GTX_C_P6: length 3.2
  TOP w0.109: JMXM1.141 98.25,105.77 98.39,105.92 98.39,106.37 98.36,106.41 98.33,106.41 97.91,106.83 97.91,106.86 97.79,106.98 97.79,107.37 CC26.1
PEG_CRX_GTX_C_P7: length 3.1
  TOP w0.109: JMXM1.135 99.75,105.77 99.89,105.92 99.89,106.42 99.58,106.74 99.58,107.36 CC25.1
PEG_CRX_GTX_C_P8: length 3
  TOP w0.109: JMXM1.129 101.25,105.75 101.39,105.89 101.39,106.4 101.37,106.43 101.37,107.01 101.39,107.04 101.39,107.16 101.33,107.23 101.33,107.39 CC24.1
PEG_CRX_GTX_C_P9: length 3
  TOP w0.109: JMXM1.123 102.75,105.77 102.89,105.92 102.89,106.71 103.11,106.92 103.11,107.39 CC23.1
PEG_CRX_GTX_C_P10: length 3.1
  TOP w0.109: CC22.1 104.9,107.37 104.9,107 v3(104.59,106.69) 104.39,106.49 104.39,105.9 104.25,105.75 JMXM1.117
PEG_CRX_GTX_C_P11: length 3.2
  TOP w0.109: JMXM1.111 105.75,105.78 105.89,105.92 105.89,106.32 v3(106.26,106.69) 106.68,107.11 106.68,107.37 CC21.1
PEG_CRX_GTX_C_P12: length 3.5
  TOP w0.109: CC20.1 108.46,107.37 108.46,107.18 108.25,106.98 107.95,106.98 v3(107.69,106.72) 107.39,106.42 107.39,105.9 107.25,105.75 JMXM1.105
PEG_CRX_GTX_C_P13: length 3.7
  TOP w0.109: CC19.1 110.24,107.36 110.24,107.24 109.87,106.86 109.46,106.86 v3(109.3,106.71) 108.89,106.3 108.89,105.92 108.75,105.78 JMXM1.99
PEG_CRX_GTX_C_P14: length 3.9
  TOP w0.109: JMXM1.93 110.25,105.76 110.39,105.9 110.39,106.21 v3(110.87,106.69) 111.33,107.15 111.88,107.15 112,107.27 112,107.39 CC18.1
PEG_CRX_GTX_C_P15: length 4.2
  TOP w0.109: JMXM1.87 111.75,105.73 111.9,105.88 111.9,106.11 112.12,106.34 112.94,106.34 v3(113.39,106.78) 113.76,107.15 113.76,107.4 CC17.1
PEG_CRX_GTX_N0: length 102.4
  TOP w0.102: v1(75.11,43.76) 75.59,44.25 JCPU1.E32
  TOP w0.109: CC16.2 87.26,108.97 87.26,109.46 87.39,109.58 v1(87.54,109.58)
  IN3 w0.089: 71.89,41.4 71.93,41.36 74.36,41.36 74.54,41.55 74.54,43.04 74.84,43.33 75.03,43.33 75.11,43.41 v1(75.11,43.76)
  IN3 w0.14: v1(87.54,109.58) 87.32,109.58 87.14,109.41 87.14,109.08 87.82,108.41 87.82,105.41 85.42,103.01 84.72,103.01 82.86,101.15 80.6,101.15 78.19,98.75 75.01,98.75 74.56,98.3 74.56,97.32 73.29,96.05 73,96.05 67.92,90.96 67.92,89.73 63.58,85.39 63.15,85.39 57.81,80.05 57.81,77.4 57.44,77.04 57.44,75.38 58,74.82 58,74.17 57.54,73.72 57.54,71.39 58.45,70.47 58.45,51.34 62.8,47 62.8,45.08 66.48,41.4 69.64,41.4 69.75,41.51 70.2,41.51 70.31,41.4 70.81,41.4 70.92,41.51 71.36,41.51 71.48,41.4 71.89,41.4
PEG_CRX_GTX_N1: length 100.3
  TOP w0.102: v1(74.11,44.76) 74.59,44.28 JCPU1.E33
  TOP w0.109: CC15.2 89.04,108.97 89.04,109.46 89.16,109.58 v1(89.32,109.58)
  IN3 w0.089: v1(74.11,44.76) 74.38,44.76 74.67,44.47 74.67,44.23 74.54,44.1 74.54,43.62 74.24,43.33 73.88,43.33 72.91,42.36 71.92,42.36 71.89,42.39 71.87,42.39
  IN3 w0.14: 71.87,42.39 71.48,42.39 71.39,42.48 70.95,42.48 70.86,42.39 70.36,42.39 70.27,42.48 69.83,42.48 69.74,42.39 66.64,42.39 63.71,45.31 63.71,47.43 59.26,51.88 59.26,77.72 58.74,78.24 58.74,79.85 63.25,84.35 63.69,84.35 68.94,89.61 68.94,90.86 71.31,93.23 71.77,93.23 75.77,97.23 78.87,97.23 79.4,97.76 79.4,98.81 80.94,100.35 83.21,100.35 84.87,102.02 86.37,102.02 87.49,103.13 87.49,103.95 89.32,105.78 89.32,108.56 88.92,108.96 88.92,109.41 89.1,109.58 v1(89.32,109.58)
PEG_CRX_GTX_N2: length 97.7
  TOP w0.102: v1(73.11,43.76) 73.59,43.28 JCPU1.D34
  TOP w0.109: CC14.2 90.82,108.97 90.82,110.22 90.94,110.35 v1(91.09,110.35)
  IN3 w0.089: v1(73.11,43.76) 73.2,43.85 73.47,43.85 73.57,43.75 73.57,43.64 73.25,43.32 71.92,43.32 71.89,43.35 71.87,43.35
  IN3 w0.14: v1(91.09,110.35) 90.88,110.35 90.7,110.17 90.7,104.66 88.87,102.83 88.4,102.83 86.75,101.18 85.21,101.18 83.19,99.16 82.5,99.16 79.75,96.41 76.09,96.41 69.99,90.3 69.99,89.33 61.19,80.54 60.58,80.54 59.55,79.51 59.55,78.69 60.07,78.18 60.07,52.22 64.52,47.76 64.52,45.63 66.8,43.35 69.7,43.35 69.79,43.44 70.23,43.44 70.32,43.35 70.82,43.35 70.91,43.44 71.36,43.44 71.45,43.35 71.87,43.35
PEG_CRX_GTX_N3: length 93.9
  TOP w0.102: v1(72.11,44.76) 72.59,44.28 JCPU1.E35
  TOP w0.109: CC13.2 92.66,108.97 92.66,109.46 92.78,109.58 v1(92.93,109.58)
  IN3 w0.089: 71.23,44.26 71.25,44.26 71.28,44.23 72.53,44.23 72.65,44.35 72.65,44.62 72.5,44.76 v1(72.11,44.76)
  IN3 w0.14: 71.23,44.26 69.88,44.26 69.78,44.36 69.33,44.36 69.23,44.26 68.73,44.26 68.63,44.36 68.19,44.36 68.09,44.26 67.04,44.26 65.59,45.71 65.59,47.99 60.87,52.72 60.87,79.08 70.98,89.19 70.98,90.15 76.3,95.48 79.96,95.48 82.84,98.35 83.52,98.35 84.35,99.19 86.38,99.19 88.29,101.09 88.68,101.09 92.54,104.95 92.54,109.41 92.72,109.58 v1(92.93,109.58)
PEG_CRX_GTX_N4: length 101.9
  TOP w0.102: v1(77.11,42.76) 77.59,43.25 JCPU1.D30
  TOP w0.109: v1(94.71,110.5) 94.56,110.5 94.44,110.37 94.44,108.97 CC12.2
  IN3 w0.089: 71.97,45.39 71.99,45.39 72.02,45.36 75.31,45.36 75.71,44.96 75.71,42.6 75.96,42.35 77.29,42.35 77.52,42.58 77.52,42.92 77.12,43.32 76.97,43.32 76.89,43.24 76.89,42.97 v1(77.11,42.76)
  IN3 w0.14: v1(94.71,110.5) 94.49,110.5 94.32,110.32 94.32,105.6 89.01,100.29 88.62,100.29 86.7,98.38 84.74,98.38 84.24,97.87 84.24,97.57 80.6,93.94 75.9,93.94 72.07,90.11 72.07,89.15 61.71,78.79 61.71,53.07 69.39,45.39 69.73,45.39 69.84,45.5 70.29,45.5 70.4,45.39 70.89,45.39 71,45.5 71.45,45.5 71.56,45.39 71.97,45.39
PEG_CRX_GTX_N5: length 96.9
  TOP w0.102: v1(76.11,43.76) 76.59,44.25 JCPU1.E31
  TOP w0.109: v1(96.49,109.58) 96.34,109.58 96.21,109.46 96.21,108.97 CC11.2
  IN3 w0.089: v1(76.11,43.76) 76.31,43.97 76.47,43.97 76.68,44.17 76.68,45.03 76.36,45.36 75.92,45.36 75.68,45.6 75.68,46.03 75.36,46.35 71.97,46.35 71.94,46.38 71.92,46.38
  IN3 w0.14: v1(96.49,109.58) 96.27,109.58 96.1,109.41 96.1,107.4 95.78,107.08 95.78,104.8 92.16,101.18 91.09,101.18 89.16,99.25 88.72,99.25 87.57,98.1 87.57,97.66 86.84,96.92 84.81,96.92 80.91,93.03 76.11,93.03 73.06,89.97 73.06,88.95 62.53,78.42 62.53,53.39 69.53,46.38 69.81,46.38 69.92,46.49 70.36,46.49 70.47,46.38 70.97,46.38 71.07,46.49 71.52,46.49 71.63,46.38 71.92,46.38
PEG_CRX_GTX_N6: length 101.3
  TOP w0.102: v1(79.11,42.76) 79.59,43.25 JCPU1.D28
  TOP w0.109: CC10.2 98.01,108.63 97.91,108.74 97.91,109.17 97.65,109.43 97.65,109.77 97.77,109.89 97.93,109.89 98.08,109.74 v1(98.08,109.69)
  IN3 w0.089: 71.97,47.13 72,47.17 75.26,47.17 75.52,46.9 75.52,46.54 75.88,46.19 76.23,46.19 76.49,45.93 76.49,45.55 76.88,45.15 77.28,45.15 77.5,44.93 77.5,43.56 77.9,43.17 78.95,43.17 79.11,43.01 v1(79.11,42.76)
  IN3 w0.14: v1(98.08,109.69) 98.24,109.85 98.43,109.85 98.59,109.7 98.59,108.93 96.86,107.2 96.86,104.79 92.44,100.37 91.37,100.37 89.72,98.72 89.32,98.72 88.61,98 88.61,97.58 87.41,96.37 85.04,96.37 81.01,92.34 76.2,92.34 73.64,89.78 73.64,88.76 63.08,78.2 63.08,53.62 69.57,47.13 71.97,47.13
PEG_CRX_GTX_N7: length 99.5
  TOP w0.102: JCPU1.E29 78.59,44.25 v1(78.11,43.76)
  TOP w0.109: CC9.2 99.78,108.96 99.78,109.18 99.92,109.32 99.92,109.59 100.05,109.71 v1(100.2,109.71)
  IN3 w0.089: 71.95,48.39 71.98,48.39 72.01,48.36 76.33,48.36 76.73,47.96 76.73,47.59 76.95,47.37 77.33,47.37 77.75,46.95 77.75,46.57 77.96,46.35 78.32,46.35 78.73,45.94 78.73,44.18 78.5,43.95 78.3,43.95 v1(78.11,43.76)
  IN3 w0.14: v1(100.2,109.71) 99.98,109.71 99.81,109.54 99.81,107.55 98.66,106.41 98.66,104.94 92.92,99.2 91.78,99.2 86.98,94.4 85.76,94.4 82.97,91.6 82.97,89.19 79.05,85.28 71.66,85.28 64.14,77.77 64.14,54.25 69.19,49.2 69.33,49.2 69.71,48.83 69.71,48.69 70,48.39 71.95,48.39
PEG_CRX_GTX_N8: length 89.9
  TOP w0.102: JCPU1.L34 73.59,50.25 v1(73.11,49.76)
  TOP w0.109: v1(100.8,109.89) 100.97,109.72 101.3,109.72 101.62,109.4 101.62,108.91 CC8.2
  IN3 w0.089: 71.89,49.39 71.91,49.39 71.94,49.36 72.98,49.36 73.11,49.49 v1(73.11,49.76)
  IN3 w0.14: v1(100.8,109.89) 100.97,109.71 101.31,109.71 101.63,109.39 101.63,107.88 100.21,106.46 100.21,105.26 93.26,98.31 92.04,98.31 87.33,93.6 86.11,93.6 83.93,91.41 83.93,89.02 79.35,84.44 72.02,84.44 64.95,77.36 64.95,54.74 70.3,49.39 71.89,49.39
PEG_CRX_GTX_N9: length 88
  TOP w0.102: v1(72.11,50.77) 72.59,51.24 JCPU1.M35
  TOP w0.109: CC7.2 103.39,108.91 103.39,109.4 103.07,109.72 102.74,109.72 v1(102.57,109.89)
  IN3 w0.14: v1(72.11,50.77) 71.74,50.39 70.43,50.39 68.46,52.37 68.46,53.73 65.75,56.44 65.75,77 66.43,77.68 67.09,77.68 73.04,83.63 79.67,83.63 85,88.95 85,91.33 86.46,92.79 87.96,92.79 92.05,96.89 93.46,96.89 94.29,97.72 94.29,98.21 101.58,105.5 101.58,106.08 103.41,107.91 103.41,109.39 103.09,109.71 102.75,109.71 v1(102.57,109.89)
PEG_CRX_GTX_N10: length 89.8
  TOP w0.102: v1(75.11,49.76) 75.59,50.25 JCPU1.L32
  TOP w0.109: v1(104.43,109.92) 104.6,109.75 104.88,109.75 105.17,109.45 105.17,108.91 CC6.2
  IN3 w0.089: 71.34,51.2 71.36,51.2 71.39,51.16 71.69,51.16 71.86,51.33 72.35,51.33 72.71,50.97 72.71,50.6 72.95,50.35 73.33,50.35 73.7,49.98 73.7,49.6 73.94,49.36 74.98,49.36 75.11,49.49 v1(75.11,49.76)
  IN3 w0.14: 71.34,51.2 70.77,51.2 69.27,52.69 69.27,55.31 67.43,57.15 67.43,76.88 73.36,82.81 79.99,82.81 87.44,90.26 87.44,90.5 88.12,91.18 88.12,91.81 92.05,95.74 93.89,95.74 95.72,97.57 95.72,98.46 103.13,105.87 103.13,106.28 105.19,108.34 105.19,109.48 104.94,109.74 104.61,109.74 v1(104.43,109.92)
PEG_CRX_GTX_N11: length 87.5
  TOP w0.102: JCPU1.M33 74.59,51.25 v1(74.11,50.76)
  TOP w0.109: CC5.2 106.95,108.91 106.95,109.4 106.63,109.72 106.3,109.72 v1(106.13,109.89)
  IN3 w0.089: v1(74.11,50.76) 74.11,50.49 74.04,50.42 73.88,50.42 73.7,50.59 73.7,51.14 72.97,51.87 71.19,51.87 70.84,52.22 70.84,52.27 70.82,52.28
  IN3 w0.14: v1(106.13,109.89) 106.31,109.71 106.64,109.71 106.97,109.39 106.97,108.85 104.68,106.56 104.68,105.99 97.32,98.63 97.32,97.77 96.79,97.24 96.53,97.24 94.04,94.75 92.96,94.75 89.98,91.78 89.98,91.22 88.78,90.02 88.32,90.02 80.3,82 73.68,82 68.23,76.55 68.23,57.49 70.09,55.64 70.09,53.02 70.82,52.28
PEG_CRX_GTX_N12: length 92
  TOP w0.102: JCPU1.L30 77.59,50.25 v1(77.11,49.76)
  TOP w0.109: CC4.2 108.73,108.91 108.73,109.4 108.41,109.72 108.08,109.72 v1(107.91,109.89)
  IN3 w0.089: 71.46,52.79 71.47,52.78 71.47,52.73 71.89,52.31 73.26,52.31 73.59,51.98 73.59,51.98 74.13,51.44 74.26,51.44 74.7,51.01 74.7,50.61 74.71,50.6 74.94,50.36 74.95,50.35 75.33,50.35 75.7,49.98 75.7,49.61 75.71,49.6 75.93,49.38 76.98,49.38 77.11,49.5 v1(77.11,49.76)
  IN3 w0.14: v1(107.91,109.89) 108.09,109.71 108.42,109.71 108.75,109.39 108.75,108.39 107.73,107.37 107.73,106.15 105.85,104.28 104.81,104.28 98.92,98.38 98.92,97.87 97.47,96.43 96.86,96.43 94.37,93.94 93.28,93.94 91.91,92.56 91.91,90.8 90.22,89.11 88.55,89.11 80.63,81.19 74.89,81.19 73.11,79.41 72.23,79.41 69.03,76.21 69.03,57.84 70.9,55.97 70.9,53.35 71.46,52.79
PEG_CRX_GTX_N13: length 90.3
  TOP w0.102: v1(76.11,50.76) 76.59,51.25 JCPU1.M31
  TOP w0.109: v1(109.69,109.89) 109.81,109.76 110.14,109.76 110.51,109.4 110.51,108.91 CC3.2
  IN3 w0.089: v1(76.11,50.76) 76.11,50.4 76.06,50.35 75.96,50.35 75.7,50.61 75.7,51 74.77,51.93 74.39,51.93 73.72,52.6 73.72,53.03 73.4,53.35 71.97,53.35 71.68,53.64 71.68,53.88 71.71,53.91 71.71,53.93
  IN3 w0.14: v1(109.69,109.89) 109.81,109.76 110.22,109.76 110.52,109.46 110.52,107.91 109.08,106.46 109.08,105.5 106.92,103.34 105.57,103.34 100.36,98.13 100.36,97.82 98.16,95.62 97.19,95.62 94.7,93.13 94.32,93.13 94.09,92.9 94.09,92.77 93.81,92.49 93.81,91.42 90.61,88.22 88.8,88.22 80.34,79.77 74.61,79.77 73.44,78.6 72.55,78.6 69.83,75.88 69.83,58.18 71.71,56.3 71.71,53.93
PEG_CRX_GTX_N14: length 95.3
  TOP w0.102: JCPU1.K28 79.13,48.82 79.13,48.76 v1(79.13,48.75)
  TOP w0.109: v1(112.4,109.69) 112.22,109.51 112.22,108.97 CC2.2
  IN3 w0.089: 75.73,54.95 75.73,54.93 75.7,54.9 75.7,51.98 75.81,51.87 75.94,51.87 76.13,51.68 76.13,51.55 76.32,51.36 76.45,51.36 76.63,51.17 76.63,51.05 76.73,50.95 76.73,50.6 76.98,50.35 77.33,50.35 77.69,49.99 77.69,48.64 77.98,48.34 79.35,48.34 79.54,48.53 79.54,49.09 79.24,49.39 79.03,49.39 78.93,49.29 78.93,48.96 v1(79.13,48.75)
  IN3 w0.14: v1(112.4,109.69) 112.24,109.53 112.24,107.92 110.65,106.33 110.65,105.52 104.66,99.53 103.37,99.53 101.84,98 101.84,97.77 98.87,94.8 97.52,94.8 96.19,93.47 96.19,92.55 91,87.36 89.06,87.36 80.67,78.97 74.96,78.97 73.77,77.79 72.87,77.79 70.63,75.55 70.63,58.52 72.65,56.5 74.53,56.5 75.73,55.3 75.73,54.95
PEG_CRX_GTX_N15: length 91
  TOP w0.102: JCPU1.M29 78.59,51.25 v1(78.11,50.76)
  TOP w0.109: CC1.2 113.99,108.97 113.99,109.51 v1(114.19,109.71)
  IN3 w0.089: v1(78.11,50.76) 78.22,50.65 78.22,50.38 78.14,50.3 78,50.3 77.7,50.6 77.7,54.97 77.73,55 77.73,55.03
  IN3 w0.14: v1(114.19,109.71) 114.03,109.55 114.03,108.29 112.02,106.28 112.02,105.34 105.24,98.56 103.84,98.56 103.29,98 103.29,97.75 99.53,93.99 97.85,93.99 97.04,93.18 97.04,92.26 91.32,86.55 89.38,86.55 81.01,78.17 75.3,78.17 74.1,76.97 73.19,76.97 71.43,75.22 71.43,58.86 71.95,58.35 72.84,58.35 73.85,57.34 75.78,57.34 77.73,55.38 77.73,55.03
PEG_CRX_GTX_P0: length 102.4
  TOP w0.102: JCPU1.D32 75.59,43.25 75.11,42.76 v1(75.12,42.76)
  TOP w0.109: CC32.2 87.05,108.97 87.05,109.42 86.89,109.58 v1(86.75,109.58)
  IN3 w0.089: 71.89,41.15 71.92,41.17 74.44,41.17 74.73,41.47 74.73,42.96 74.92,43.14 75.04,43.14 75.12,43.06 v1(75.12,42.76)
  IN3 w0.14: v1(86.75,109.58) 86.89,109.44 86.89,108.98 87.57,108.3 87.57,105.52 85.31,103.26 84.62,103.26 82.76,101.4 80.49,101.4 78.09,99 74.9,99 74.31,98.4 74.31,97.43 73.18,96.3 72.9,96.3 67.66,91.07 67.66,89.83 63.47,85.64 63.04,85.64 57.55,80.16 57.55,77.51 57.19,77.14 57.19,75.27 57.74,74.72 57.74,74.28 57.29,73.82 57.29,71.28 58.2,70.37 58.2,51.24 62.54,46.9 62.54,44.98 66.37,41.15 71.89,41.15
PEG_CRX_GTX_P1: length 100.4
  TOP w0.102: v1(75.1,44.76) 74.59,45.27 JCPU1.F33
  TOP w0.109: v1(88.53,109.58) 88.67,109.58 88.83,109.42 88.83,108.97 CC31.2
  IN3 w0.089: 71.87,42.13 71.89,42.13 71.92,42.17 72.99,42.17 73.96,43.13 74.32,43.13 74.73,43.54 74.73,44.02 74.86,44.16 74.86,44.52 v1(75.1,44.76)
  IN3 w0.14: 71.87,42.13 66.53,42.13 63.46,45.21 63.46,47.33 59.01,51.78 59.01,77.61 58.49,78.13 58.49,79.95 63.14,84.6 63.58,84.6 68.69,89.71 68.69,90.96 71.21,93.48 71.67,93.48 75.66,97.48 78.76,97.48 79.15,97.87 79.15,98.91 80.84,100.6 83.1,100.6 84.77,102.27 86.26,102.27 87.23,103.24 87.23,104.05 89.07,105.89 89.07,108.45 88.67,108.85 88.67,109.44 v1(88.53,109.58)
PEG_CRX_GTX_P2: length 97.8
  TOP w0.102: JCPU1.E34 73.59,44.28 v1(74.11,43.76)
  TOP w0.109: v1(90.31,110.35) 90.45,110.35 90.61,110.19 90.61,108.97 CC30.2
  IN3 w0.089: 71.87,43.1 71.89,43.1 71.92,43.13 73.33,43.13 73.96,43.76 v1(74.11,43.76)
  IN3 w0.14: 71.87,43.1 66.7,43.1 64.27,45.53 64.27,47.66 59.81,52.12 59.81,78.07 59.29,78.59 59.29,79.62 60.47,80.79 61.08,80.79 69.73,89.44 69.73,90.41 75.98,96.66 79.64,96.66 82.39,99.41 83.08,99.41 85.11,101.43 86.64,101.43 88.3,103.08 88.77,103.08 90.45,104.76 90.45,110.21 v1(90.31,110.35)
PEG_CRX_GTX_P3: length 94
  TOP w0.102: JCPU1.F35 72.59,45.25 v1(73.07,44.77)
  TOP w0.109: v1(92.15,109.58) 92.29,109.58 92.45,109.42 92.45,108.97 CC29.2
  IN3 w0.089: v1(73.07,44.77) 73.02,44.77 72.84,44.58 72.84,44.27 72.6,44.04 71.27,44.04 71.24,44 71.23,44
  IN3 w0.14: v1(92.15,109.58) 92.29,109.44 92.29,105.06 88.57,101.34 88.18,101.34 86.28,99.44 84.25,99.44 83.41,98.61 82.73,98.61 79.86,95.73 76.2,95.73 70.72,90.26 70.72,89.3 60.61,79.19 60.61,52.61 65.34,47.89 65.34,45.6 66.94,44 71.23,44
PEG_CRX_GTX_P4: length 102
  TOP w0.102: v1(77.11,43.76) 77.59,44.25 JCPU1.E30
  TOP w0.109: v1(93.93,110.5) 94.07,110.5 94.23,110.34 94.23,108.97 CC28.2
  IN3 w0.089: 71.97,45.14 71.99,45.14 72.02,45.17 75.23,45.17 75.52,44.88 75.52,42.52 75.88,42.16 77.37,42.16 77.71,42.5 77.71,43 77.11,43.6 v1(77.11,43.76)
  IN3 w0.14: v1(93.93,110.5) 94.06,110.36 94.06,105.7 88.9,100.54 88.51,100.54 86.6,98.63 84.63,98.63 83.98,97.98 83.98,97.68 80.5,94.19 75.79,94.19 71.81,90.22 71.81,89.26 61.46,78.9 61.46,52.96 69.28,45.14 71.97,45.14
PEG_CRX_GTX_P5: length 97
  TOP w0.102: v1(76.11,44.76) 76.59,45.25 JCPU1.F31
  TOP w0.109: v1(95.7,109.58) 95.84,109.58 96,109.42 96,108.97 CC27.2
  IN3 w0.089: 71.92,46.13 71.94,46.13 71.97,46.16 75.28,46.16 75.49,45.95 75.49,45.52 75.85,45.17 76.28,45.17 76.49,44.96 76.49,44.25 76.39,44.16 76.08,44.16 75.98,44.26 75.98,44.63 v1(76.11,44.76)
  IN3 w0.14: 71.92,46.13 69.42,46.13 62.27,53.28 62.27,78.52 72.81,89.05 72.81,90.08 76.01,93.28 80.81,93.28 84.7,97.18 86.73,97.18 87.32,97.77 87.32,98.21 88.61,99.5 89.06,99.5 90.99,101.43 92.05,101.43 95.53,104.9 95.53,107.19 95.84,107.5 95.84,109.44 v1(95.7,109.58)
PEG_CRX_GTX_P6: length 101.4
  TOP w0.102: v1(79.11,43.76) 79.59,44.25 JCPU1.E28
  TOP w0.109: v1(98.08,110.27) 97.91,110.1 97.69,110.1 97.44,109.86 97.44,109.34 97.7,109.08 97.7,108.89 CC26.2
  IN3 w0.089: v1(79.11,43.76) 79.11,43.52 78.94,43.36 77.98,43.36 77.69,43.64 77.69,45.01 77.36,45.34 76.96,45.34 76.68,45.63 76.68,46.01 76.31,46.38 75.96,46.38 75.71,46.62 75.71,46.98 75.34,47.36 72,47.36 71.97,47.39
  IN3 w0.14: v1(98.08,110.27) 98.24,110.11 98.54,110.11 98.84,109.8 98.84,108.82 97.11,107.1 97.11,104.68 92.54,100.11 91.47,100.11 89.82,98.46 89.43,98.46 88.86,97.9 88.86,97.47 87.51,96.12 85.15,96.12 81.11,92.09 76.31,92.09 73.9,89.68 73.9,88.65 63.34,78.09 63.34,53.73 69.67,47.39 71.97,47.39
PEG_CRX_GTX_P7: length 99.6
  TOP w0.102: JCPU1.F29 78.59,45.25 v1(78.11,44.76)
  TOP w0.109: v1(99.41,109.71) 99.55,109.71 99.71,109.55 99.71,109.41 99.57,109.27 99.57,108.98 CC25.2
  IN3 w0.089: 71.95,48.14 71.98,48.14 72.01,48.17 76.25,48.17 76.54,47.88 76.54,47.51 76.87,47.18 77.25,47.18 77.55,46.87 77.55,46.49 77.89,46.16 78.24,46.16 78.54,45.87 78.54,44.26 78.43,44.14 78.1,44.14 78.01,44.23 78.01,44.67 v1(78.11,44.76)
  IN3 w0.14: 71.95,48.14 69.9,48.14 63.89,54.15 63.89,77.87 71.55,85.53 78.95,85.53 82.71,89.3 82.71,91.71 85.65,94.65 86.88,94.65 91.68,99.45 92.82,99.45 98.41,105.04 98.41,106.51 99.55,107.66 99.55,109.57 v1(99.41,109.71)
PEG_CRX_GTX_P8: length 89.9
  TOP w0.102: v1(73.11,48.76) 73.59,49.25 JCPU1.K34
  TOP w0.109: CC24.2 101.32,108.63 101.41,108.72 101.41,109.31 101.21,109.51 100.99,109.51 v1(100.78,109.31)
  IN3 w0.089: 71.89,49.13 71.91,49.13 71.94,49.17 73,49.17 73.11,49.06 v1(73.11,48.76)
  IN3 w0.14: 71.89,49.13 70.19,49.13 64.69,54.63 64.69,77.47 71.92,84.69 79.25,84.69 83.68,89.12 83.68,91.52 86.01,93.85 87.23,93.85 91.94,98.56 93.15,98.56 99.96,105.37 99.96,106.56 101.38,107.99 101.38,109.28 101.2,109.46 100.94,109.46 v1(100.78,109.31)
PEG_CRX_GTX_P9: length 87.9
  TOP w0.102: v1(72.11,49.77) 72.59,50.24 JCPU1.L35
  TOP w0.109: CC23.2 103.09,108.63 103.18,108.72 103.18,109.31 102.99,109.51 102.77,109.51 v1(102.56,109.31)
  IN3 w0.14: v1(72.11,49.77) 71.74,50.14 70.32,50.14 68.2,52.26 68.2,53.63 65.5,56.33 65.5,77.11 66.33,77.94 66.99,77.94 72.93,83.88 79.56,83.88 84.74,89.06 84.74,91.43 86.35,93.05 87.85,93.05 91.94,97.14 93.35,97.14 94.04,97.83 94.04,98.31 101.33,105.6 101.33,106.19 103.16,108.02 103.16,109.28 102.98,109.46 102.72,109.46 v1(102.56,109.31)
PEG_CRX_GTX_P10: length 89.7
  TOP w0.102: JCPU1.K32 75.59,49.25 v1(75.11,48.76)
  TOP w0.109: v1(104.42,109.33) 104.62,109.54 104.79,109.54 104.96,109.36 104.96,108.72 104.87,108.63 CC22.2
  IN3 w0.089: 71.34,50.94 71.36,50.94 71.39,50.97 71.77,50.97 71.94,51.14 72.27,51.14 72.52,50.89 72.52,50.52 72.87,50.16 73.25,50.16 73.51,49.9 73.51,49.52 73.87,49.17 75,49.17 75.11,49.06 v1(75.11,48.76)
  IN3 w0.14: v1(104.42,109.33) 104.57,109.48 104.83,109.48 104.94,109.38 104.94,108.44 102.88,106.39 102.88,105.98 95.46,98.56 95.46,97.68 93.78,96 91.95,96 87.87,91.91 87.87,91.29 87.18,90.6 87.18,90.37 79.88,83.07 73.26,83.07 67.17,76.98 67.17,57.05 69.02,55.2 69.02,52.58 70.66,50.94 71.34,50.94
PEG_CRX_GTX_P11: length 87.5
  TOP w0.102: JCPU1.L33 74.59,50.25 v1(74.11,49.76)
  TOP w0.109: CC21.2 106.65,108.63 106.74,108.72 106.74,109.31 106.54,109.51 106.32,109.51 v1(106.12,109.31)
  IN3 w0.089: 70.64,52.1 70.66,52.09 70.7,52.09 71.11,51.68 72.89,51.68 73.51,51.06 73.51,50.51 73.8,50.23 74.02,50.23 74.11,50.14 v1(74.11,49.76)
  IN3 w0.14: v1(106.12,109.31) 106.27,109.46 106.54,109.46 106.71,109.28 106.71,108.95 104.43,106.67 104.43,106.1 97.06,98.73 97.06,97.88 96.68,97.5 96.42,97.5 93.93,95.01 92.85,95.01 89.73,91.88 89.73,91.32 88.68,90.27 88.22,90.27 80.2,82.25 73.57,82.25 67.97,76.65 67.97,57.39 69.83,55.53 69.83,52.92 70.64,52.1
PEG_CRX_GTX_P12: length 92
  TOP w0.102: JCPU1.K30 77.59,49.25 v1(77.11,48.76)
  TOP w0.109: v1(107.9,109.31) 108.1,109.51 108.32,109.51 108.52,109.31 108.52,108.72 108.43,108.63 CC20.2
  IN3 w0.089: 71.28,52.61 71.29,52.6 71.34,52.6 71.81,52.12 73.18,52.12 73.4,51.9 74.05,51.25 74.18,51.25 74.51,50.93 74.51,50.53 74.52,50.52 74.87,50.16 75.25,50.16 75.51,49.9 75.51,49.53 75.52,49.52 75.85,49.19 77.02,49.19 77.11,49.1 v1(77.11,48.76)
  IN3 w0.14: v1(107.9,109.31) 108.05,109.46 108.31,109.46 108.49,109.28 108.49,108.49 107.48,107.48 107.48,106.26 105.75,104.53 104.71,104.53 98.66,98.49 98.66,97.98 97.37,96.68 96.76,96.68 94.27,94.19 93.18,94.19 91.65,92.67 91.65,90.91 90.11,89.37 88.45,89.37 80.52,81.45 74.78,81.45 73,79.67 72.12,79.67 68.78,76.32 68.78,57.73 70.65,55.86 70.65,53.25 71.28,52.61
PEG_CRX_GTX_P13: length 90.1
  TOP w0.102: v1(76.11,49.76) 76.59,50.25 JCPU1.L31
  TOP w0.109: CC19.2 110.21,108.63 110.3,108.72 110.3,109.31 110.06,109.55 109.92,109.55 v1(109.67,109.31)
  IN3 w0.089: v1(76.11,49.76) 76.11,50.07 76.02,50.16 75.88,50.16 75.51,50.53 75.51,50.92 74.69,51.74 74.31,51.74 73.53,52.52 73.53,52.95 73.33,53.16 71.9,53.16 71.49,53.56 71.49,53.88 71.46,53.91 71.46,53.93
  IN3 w0.14: v1(109.67,109.31) 109.88,109.51 110.12,109.51 110.27,109.36 110.27,108.01 108.82,106.56 108.82,105.6 106.81,103.59 105.47,103.59 100.11,98.23 100.11,97.93 98.05,95.87 97.09,95.87 94.6,93.38 94.21,93.38 93.84,93 93.84,92.88 93.56,92.6 93.56,91.53 90.51,88.48 88.69,88.48 80.24,80.03 74.51,80.03 73.33,78.85 72.44,78.85 69.58,75.99 69.58,58.07 71.46,56.19 71.46,53.93
PEG_CRX_GTX_P14: length 95.3
  TOP w0.102: v1(79.13,49.77) 79.13,49.82 JCPU1.L28
  TOP w0.109: v1(111.82,109.69) 112.01,109.51 112.01,108.97 CC18.2
  IN3 w0.089: v1(79.13,49.77) 79.73,49.17 79.73,48.45 79.43,48.15 77.9,48.15 77.5,48.56 77.5,49.91 77.25,50.16 76.9,50.16 76.54,50.52 76.54,50.87 75.51,51.9 75.51,54.9 75.48,54.93 75.48,54.95
  IN3 w0.14: v1(111.82,109.69) 111.98,109.53 111.98,108.02 110.4,106.44 110.4,105.63 104.55,99.78 103.26,99.78 101.58,98.11 101.58,97.88 98.76,95.06 97.41,95.06 95.93,93.58 95.93,92.65 90.89,87.62 88.96,87.62 80.57,79.23 74.85,79.23 73.66,78.04 72.76,78.04 70.38,75.66 70.38,58.42 72.55,56.25 74.43,56.25 75.48,55.19 75.48,54.95
PEG_CRX_GTX_P15: length 91
  TOP w0.102: JCPU1.L29 78.59,50.25 v1(78.11,49.76)
  TOP w0.109: v1(113.61,109.71) 113.78,109.54 113.78,108.97 CC17.2
  IN3 w0.089: 77.48,55.03 77.48,55 77.51,54.97 77.51,50.52 77.69,50.35 77.98,50.06 78.11,49.93 v1(78.11,49.76)
  IN3 w0.14: v1(113.61,109.71) 113.78,109.55 113.78,108.39 111.77,106.39 111.77,105.45 105.14,98.82 103.74,98.82 103.03,98.11 103.03,97.85 99.42,94.24 97.74,94.24 96.78,93.28 96.78,92.37 91.22,86.8 89.28,86.8 80.9,78.43 75.2,78.43 74,77.23 73.08,77.23 71.18,75.32 71.18,58.76 71.84,58.09 72.73,58.09 73.74,57.08 75.67,57.08 77.48,55.28 77.48,55.03
PEG_CTX_GRX_C_N0: length 120.9
  TOP w0.102: v1(83.11,39.76) 83.59,40.25 JCPU1.A24
  TOP w0.109: v1(87.28,92.37) 87.06,92.59 87.06,92.73 87.19,92.87 87.45,92.87 87.71,93.12 87.71,93.35 CC50.2
  IN4 w0.089: v1(83.11,39.76) 82.93,39.93 82.38,39.93 82.22,39.77 82.22,39.31 82.32,39.2 82.32,38.96 82.33,38.95 82.33,38.88 82.35,38.86 82.35,38.85
  IN4 w0.135: 82.35,38.85 82.35,37.09 79.59,34.33 79.59,29.69 76.55,26.66 72.37,26.66 69.33,29.7 69.33,31.1 59.01,41.41 59.01,52.76 58.17,53.6 58.17,72.07 58.43,72.33 58.43,73.62 59.01,74.21 59.01,77.9 58.5,78.41 58.5,80.84 70.95,93.28 71.92,93.28 74.16,95.52 80.45,95.52 82.03,93.94 86.71,93.94 87.26,93.39 87.26,92.39 v1(87.28,92.37)
PEG_CTX_GRX_C_N1: length 123.2
  TOP w0.102: v1(82.11,40.76) 82.59,41.25 JCPU1.B25
  TOP w0.109: CC77.2 89.48,93.35 89.48,93.1 88.97,92.58 88.97,91.82 v1(89.19,91.6)
  IN4 w0.089: v1(82.11,40.76) 82.11,41.21 82,41.32 81.79,41.32 81.68,41.21 81.68,39.49 81.52,39.33 81.52,39.1 81.55,39.07 81.55,39.05
  IN4 w0.135: v1(89.19,91.6) 88.98,91.81 88.98,92.03 89.18,92.23 89.57,92.23 89.77,92.02 89.77,91.37 89.01,90.61 84.16,90.61 80.06,94.71 74.51,94.71 70.97,91.17 70.45,91.17 59.3,80.02 59.3,78.8 59.81,78.29 59.81,73.86 59.24,73.29 59.24,72 58.99,71.74 58.99,53.96 59.83,53.12 59.83,41.74 70.14,31.43 70.14,30.03 72.7,27.47 76.22,27.47 78.77,30.02 78.77,34.66 81.55,37.43 81.55,39.05
PEG_CTX_GRX_C_N2: length 121.1
  TOP w0.102: v1(81.11,39.76) 81.59,40.25 JCPU1.A26
  TOP w0.109: CC62.2 91.39,93.35 91.39,93.1 91,92.71 91,91.82 v1(91.22,91.6)
  IN4 w0.089: 80.74,39.41 80.74,39.43 80.7,39.46 80.7,40.26 80.79,40.34 81,40.34 81.11,40.24 v1(81.11,39.76)
  IN4 w0.135: 80.74,39.41 80.74,38.55 77.96,35.77 77.96,30.35 75.89,28.28 73.03,28.28 70.95,30.36 70.95,31.76 60.64,42.07 60.64,53.47 59.8,54.31 59.8,71.39 60.05,71.64 60.05,72.96 60.61,73.52 60.61,80.19 70.55,90.13 71.26,90.13 75.04,93.91 79.72,93.91 84.28,89.36 90.95,89.36 91.91,90.31 91.91,91.9 91.65,92.16 91.2,92.16 91.04,92.01 91.04,91.78 v1(91.22,91.6)
PEG_CTX_GRX_C_N3: length 109.9
  TOP w0.102: v1(80.11,40.76) 80.59,41.25 JCPU1.B27
  TOP w0.109: CC49.2 93.18,93.36 93.18,93.09 92.91,92.82 92.91,92.7 v1(93.13,92.49)
  IN4 w0.089: 79.74,39.62 79.74,39.64 79.7,39.68 79.7,41.26 79.79,41.34 80,41.34 80.11,41.24 v1(80.11,40.76)
  IN4 w0.135: v1(93.13,92.49) 92.95,92.67 92.95,92.89 93.15,93.1 93.53,93.1 93.68,92.95 93.68,90.95 91.29,88.56 83.94,88.56 79.39,93.11 75.57,93.11 71.49,89.04 70.59,89.04 61.43,79.87 61.43,73.19 60.87,72.63 60.87,71.31 60.61,71.06 60.61,54.64 61.45,53.8 61.45,42.87 64.22,40.1 68.55,35.77 76.82,35.77 79.74,38.68 79.74,39.62
PEG_CTX_GRX_C_N4: length 107
  TOP w0.102: v1(79.11,39.76) 79.59,40.25 JCPU1.A28
  TOP w0.109: CC76.2 94.94,93.35 94.94,92.88 v1(95.18,92.64)
  IN4 w0.089: 78.71,39.41 78.71,39.43 78.68,39.46 78.68,40.23 78.79,40.34 79,40.34 79.11,40.24 v1(79.11,39.76)
  IN4 w0.135: v1(95.18,92.64) 94.97,92.86 94.97,93.19 95.13,93.36 95.67,93.36 95.89,93.13 95.89,92.01 91.63,87.74 83.62,87.74 79.06,92.3 76.09,92.3 71.94,88.15 70.84,88.15 62.24,79.55 62.24,72.86 61.68,72.3 61.68,70.98 61.43,70.73 61.43,54.97 62.26,54.13 62.26,43.19 68.88,36.58 76.49,36.58 78.71,38.81 78.71,39.41
PEG_CTX_GRX_C_N5: length 100.9
  TOP w0.102: JCPU1.B29 78.59,41.25 v1(78.11,40.76)
  TOP w0.109: CC59.2 96.46,91.56 96.46,91.31 96.21,91.07 96.21,90.62 v1(96.43,90.41)
  IN4 w0.089: v1(78.11,40.76) 78.11,41.24 78,41.34 77.79,41.34 77.68,41.23 77.68,39.31 77.71,39.28 77.71,39.25
  IN4 w0.135: 77.71,39.25 77.71,38.98 76.12,37.39 69.21,37.39 63.08,43.52 63.08,54.46 62.24,55.3 62.24,70.37 62.49,70.63 62.49,71.97 63.05,72.53 63.05,79.22 69.38,85.55 92.63,85.55 97.21,90.13 97.21,90.71 96.99,90.94 96.38,90.94 96.27,90.84 96.27,90.56 v1(96.43,90.41)
PEG_CTX_GRX_C_N6: length 97.8
  TOP w0.102: JCPU1.A30 77.59,40.25 v1(77.11,39.76)
  TOP w0.109: v1(97.47,92.01) 97.69,92.23 97.99,92.23 98.21,92.45 98.21,93.02 97.99,93.23 97.99,93.35 CC48.2
  IN4 w0.089: v1(77.11,39.76) 77.11,40.01 77,40.12 76.79,40.12 76.68,40 76.68,39.49 76.71,39.46 76.71,39.43
  IN4 w0.135: v1(97.47,92.01) 97.72,92.26 97.9,92.26 98.03,92.13 98.03,89.8 92.97,84.75 69.72,84.75 63.86,78.9 63.86,72.2 63.36,71.69 63.36,70.28 63.05,69.97 63.05,55.63 63.89,54.79 63.89,43.84 69.54,38.19 75.78,38.19 76.71,39.12 76.71,39.43
PEG_CTX_GRX_C_N7: length 96.4
  TOP w0.102: JCPU1.B31 76.59,41.25 v1(76.11,40.76)
  TOP w0.109: CC75.2 99.77,93.35 99.77,93.23 99.98,93.02 99.98,92.45 99.77,92.23 99.47,92.23 v1(99.25,92.01)
  IN4 w0.089: 74.91,38.99 74.94,38.99 74.96,39.01 75.35,39.01 75.73,39.39 75.73,41.08 75.81,41.17 75.97,41.17 76.11,41.03 v1(76.11,40.76)
  IN4 w0.135: v1(99.25,92.01) 99.5,92.26 99.67,92.26 99.81,92.13 99.81,90.44 93.31,83.94 70.05,83.94 64.68,78.57 64.68,71.87 64.16,71.35 64.16,69.95 63.86,69.66 63.86,55.99 64.7,55.15 64.7,44.27 69.98,38.99 74.91,38.99
PEG_CTX_GRX_C_N8: length 91.2
  TOP w0.102: v1(75.11,40.76) 75.59,41.25 JCPU1.B32
  TOP w0.109: CC56.2 101.55,93.35 101.55,92.86 101.66,92.75 v1(101.86,92.75)
  IN4 w0.089: v1(75.11,40.76) 75.11,40.46 74.99,40.35 71.97,40.35 71.94,40.37
  IN4 w0.135: 71.94,40.37 71.1,40.37 71,40.47 70.56,40.47 70.46,40.37 70.09,40.37 69.82,40.65 69.82,40.79 69.5,41.11 69.36,41.11 65.77,44.7 65.77,55.61 64.93,56.45 64.93,69.23 65.21,69.51 65.21,70.9 65.74,71.44 65.74,78.15 70.47,82.88 93.74,82.88 101.46,90.59 101.46,92.59 101.61,92.75 v1(101.86,92.75)
PEG_CTX_GRX_C_N9: length 88.8
  TOP w0.102: v1(74.11,41.76) 74.59,42.25 JCPU1.C33
  TOP w0.109: CC47.2 103.33,93.35 103.33,92.86 103.44,92.75 v1(103.64,92.75)
  IN4 w0.089: 71.89,41.39 71.93,41.35 73.94,41.35 74.11,41.52 v1(74.11,41.76)
  IN4 w0.135: v1(103.64,92.75) 103.39,92.75 103.23,92.59 103.23,91.2 94.1,82.06 71.22,82.06 66.91,77.76 66.91,71.46 66.01,70.56 66.01,69.18 65.74,68.92 65.74,56.78 66.91,55.62 66.91,44.84 69.63,42.12 69.78,42.12 70.08,41.82 70.08,41.67 70.37,41.39 70.75,41.39 70.85,41.49 71.27,41.49 71.37,41.39 71.89,41.39
PEG_CTX_GRX_C_N10: length 95.2
  TOP w0.102: JCPU1.G30 77.59,46.25 v1(77.11,45.76)
  TOP w0.109: CC74.2 105.1,93.35 105.1,93.23 105.32,93.02 105.32,92.45 105.1,92.23 104.8,92.23 v1(104.58,92.01)
  IN4 w0.089: v1(77.11,45.76) 77.11,46.06 77.02,46.15 76.8,46.15 76.72,46.07 76.72,42.49 76.39,42.16 72.01,42.16 72.01,42.16 71.95,42.16 71.93,42.14 71.92,42.14
  IN4 w0.135: v1(104.58,92.01) 104.83,92.26 105.01,92.26 105.14,92.13 105.14,91.4 102.85,89.11 101.94,89.11 94.32,81.49 71.42,81.49 67.45,77.53 67.45,71.22 67.16,70.92 67.16,56.47 67.45,56.17 67.45,45.84 71.16,42.14 71.92,42.14
PEG_CTX_GRX_C_N11: length 97.8
  TOP w0.102: JCPU1.J31 76.59,48.25 v1(76.11,47.76)
  TOP w0.109: v1(107.37,92.9) 107.45,92.82 107.45,92.64 107.37,92.57 106.99,92.57 106.88,92.68 106.88,93.35 CC46.2
  IN4 w0.089: v1(76.11,47.76) 76.11,47.46 76.01,47.37 75.71,47.37 75.49,47.15 75.49,43.55 75.29,43.36 72.85,43.36 72.79,43.41 72.78,43.41
  IN4 w0.135: 72.78,43.41 71.38,43.41 68.51,46.28 68.51,56.61 68.21,56.91 68.21,70.47 68.51,70.77 68.51,77.1 71.45,80.05 102.8,80.05 108.14,85.38 108.14,92.32 107.86,92.59 107.68,92.59 v1(107.37,92.9)
PEG_CTX_GRX_C_N12: length 93.7
  TOP w0.102: v1(75.11,46.76) 75.59,47.25 JCPU1.H32
  TOP w0.109: CC73.2 108.66,93.33 108.66,92.68 108.77,92.57 109.15,92.57 109.23,92.64 109.23,92.82 v1(109.15,92.9)
  IN4 w0.089: v1(75.11,46.76) 75.11,46.45 75.02,46.36 74.76,46.36 74.5,46.11 74.5,44.52 74.34,44.36 72,44.36 71.98,44.38 71.97,44.38
  IN4 w0.135: 71.97,44.38 71.54,44.38 69.31,46.61 69.31,56.95 69,57.26 69,70.13 69.31,70.44 69.31,76.78 71.78,79.24 103.14,79.24 109.86,85.96 109.86,92.37 109.64,92.59 109.46,92.59 v1(109.15,92.9)
PEG_CTX_GRX_C_N13: length 92.7
  TOP w0.102: v1(74.11,47.76) 74.59,48.25 JCPU1.J33
  TOP w0.109: CC53.2 110.44,93.35 110.44,93.12 110.22,92.91 110.22,92.41 110.42,92.21 110.69,92.21 110.77,92.29 110.77,92.47 v1(110.69,92.54)
  IN4 w0.089: v1(74.11,47.76) 74.11,47.49 73.97,47.36 73.73,47.36 73.51,47.14 73.51,45.62 73.24,45.36 72,45.36 71.97,45.39 71.95,45.39
  IN4 w0.135: v1(110.69,92.54) 110.99,92.24 111.24,92.24 111.41,92.06 111.41,85.86 107.73,82.18 107.73,80.86 105.31,78.44 72.1,78.44 70.11,76.45 70.11,70.11 69.8,69.8 69.8,57.63 70.11,57.32 70.11,46.95 71.67,45.39 71.95,45.39
PEG_CTX_GRX_C_N14: length 87.9
  TOP w0.102: v1(73.11,46.76) 73.59,47.25 JCPU1.H34
  TOP w0.109: v1(112.43,92.62) 112.22,92.83 112.22,93.35 CC45.2
  IN4 w0.089: v1(73.11,46.76) 73.11,46.29 73.02,46.2 72.53,46.2 72.36,46.37 71.8,46.37 71.58,46.59 71.58,46.63 71.56,46.65
  IN4 w0.135: 71.56,46.65 70.91,47.3 70.91,57.66 70.59,57.98 70.59,69.46 70.91,69.78 70.91,76.13 72.41,77.63 105.92,77.63 112.61,84.31 112.61,91.94 112.23,92.32 112.23,92.42 v1(112.43,92.62)
PEG_CTX_GRX_C_N15: length 86.3
  TOP w0.102: v1(72.13,46.76) 72.13,46.81 JCPU1.H35
  TOP w0.109: v1(114.21,92.62) 113.99,92.83 113.99,93.35 CC44.2
  IN4 w0.089: 72.75,50.99 72.75,50.96 72.72,50.93 72.72,47.25 72.48,47.02 72.24,47.02 72.13,46.91 v1(72.13,46.76)
  IN4 w0.135: 72.75,50.99 72.75,51.53 71.71,52.56 71.71,58 71.41,58.31 71.41,69.12 71.71,69.43 71.71,75.8 72.73,76.83 106.44,76.83 114.02,84.4 114.02,92.43 v1(114.21,92.62)
PEG_CTX_GRX_C_P0: length 120.8
  TOP w0.102: v1(83.11,40.76) 83.59,41.25 JCPU1.B24
  TOP w0.109: CC64.2 87.5,93.35 87.5,93.21 87.37,93.08 87.11,93.08 86.85,92.82 86.85,92.57 v1(86.65,92.37)
  IN4 w0.089: v1(83.11,40.76) 83.37,40.76 83.5,40.64 83.5,40.3 83.35,40.14 82.29,40.14 82.01,39.86 82.01,39.22 82.11,39.11 82.11,38.88 82.1,38.86 82.1,38.85
  IN4 w0.135: v1(86.65,92.37) 87,92.72 87,93.29 86.61,93.69 81.92,93.69 80.34,95.27 74.27,95.27 72.02,93.03 71.05,93.03 58.76,80.73 58.76,78.52 59.27,78.01 59.27,74.1 58.68,73.52 58.68,72.22 58.43,71.97 58.43,53.71 59.27,52.87 59.27,41.51 69.58,31.2 69.58,29.8 72.47,26.91 76.45,26.91 79.33,29.79 79.33,34.43 82.1,37.2 82.1,38.85
PEG_CTX_GRX_C_P1: length 123.2
  TOP w0.102: v1(82.11,41.76) 82.59,42.25 JCPU1.C25
  TOP w0.109: v1(88.55,91.6) 88.76,91.81 88.76,92.67 89.27,93.19 89.27,93.35 CC63.2
  IN4 w0.089: 81.29,39.05 81.29,39.07 81.33,39.1 81.33,39.41 81.49,39.57 81.49,41.29 81.71,41.51 81.98,41.51 82.11,41.63 v1(82.11,41.76)
  IN4 w0.135: v1(88.55,91.6) 88.73,91.78 88.73,92.14 89.07,92.48 89.67,92.48 90.03,92.12 90.03,91.27 89.12,90.36 84.05,90.36 79.95,94.46 74.62,94.46 71.08,90.92 70.56,90.92 59.55,79.91 59.55,78.91 60.06,78.4 60.06,73.75 59.5,73.19 59.5,71.89 59.24,71.64 59.24,54.06 60.08,53.22 60.08,41.84 70.39,31.53 70.39,30.14 72.81,27.72 76.12,27.72 78.52,30.12 78.52,34.76 81.29,37.54 81.29,39.05
PEG_CTX_GRX_C_P2: length 121.1
  TOP w0.102: v1(81.11,40.76) 81.59,41.25 JCPU1.B26
  TOP w0.109: v1(90.59,91.6) 90.79,91.81 90.79,92.8 91.18,93.19 91.18,93.35 CC72.2
  IN4 w0.089: 80.48,39.41 80.48,39.43 80.51,39.46 80.51,40.34 80.71,40.53 80.98,40.53 81.11,40.66 v1(81.11,40.76)
  IN4 w0.135: v1(90.59,91.6) 90.79,91.81 90.79,92.11 91.09,92.42 91.75,92.42 92.16,92.01 92.16,90.21 91.05,89.1 84.17,89.1 79.62,93.66 75.14,93.66 71.36,89.88 70.65,89.88 60.87,80.09 60.87,73.42 60.31,72.86 60.31,71.54 60.05,71.28 60.05,54.42 60.89,53.58 60.89,42.17 71.2,31.86 71.2,30.47 73.14,28.53 75.78,28.53 77.71,30.46 77.71,35.88 80.48,38.65 80.48,39.41
PEG_CTX_GRX_C_P3: length 109.9
  TOP w0.102: JCPU1.C27 80.59,42.25 v1(80.11,41.76)
  TOP w0.109: CC61.2 92.97,93.33 92.97,93.18 92.7,92.91 92.7,92.7 v1(92.49,92.49)
  IN4 w0.089: 79.48,39.62 79.48,39.64 79.51,39.68 79.51,41.34 79.71,41.53 79.98,41.53 80.11,41.66 v1(80.11,41.76)
  IN4 w0.135: v1(92.49,92.49) 92.69,92.7 92.69,93 93.05,93.36 93.63,93.36 93.94,93.05 93.94,90.84 91.4,88.3 83.84,88.3 79.29,92.85 75.67,92.85 71.6,88.78 70.7,88.78 61.68,79.77 61.68,73.09 61.12,72.53 61.12,71.21 60.87,70.95 60.87,54.75 61.71,53.91 61.71,42.97 68.66,36.02 76.72,36.02 79.48,38.79 79.48,39.62
PEG_CTX_GRX_C_P4: length 107
  TOP w0.102: JCPU1.B28 79.59,41.25 v1(79.11,40.76)
  TOP w0.109: v1(94.5,92.64) 94.73,92.88 94.73,93.35 CC60.2
  IN4 w0.089: 78.46,39.41 78.46,39.43 78.49,39.46 78.49,40.31 78.71,40.53 78.98,40.53 79.11,40.66 v1(79.11,40.76)
  IN4 w0.135: 78.46,39.41 78.46,38.91 76.38,36.84 68.98,36.84 62.52,43.3 62.52,54.24 61.68,55.08 61.68,70.62 61.93,70.88 61.93,72.2 62.49,72.76 62.49,79.45 70.94,87.89 72.04,87.89 76.2,92.05 78.96,92.05 83.52,87.49 91.73,87.49 96.15,91.9 96.15,93.23 95.77,93.61 95.03,93.61 94.71,93.3 94.71,92.86 v1(94.5,92.64)
PEG_CTX_GRX_C_P5: length 100.8
  TOP w0.102: v1(78.11,41.76) 78.59,42.25 JCPU1.C29
  TOP w0.109: v1(95.79,90.41) 96,90.62 96,91.15 96.25,91.4 96.25,91.58 CC71.2
  IN4 w0.089: v1(78.11,41.76) 78.11,41.66 77.98,41.53 77.71,41.53 77.49,41.31 77.49,39.31 77.46,39.28 77.46,39.25
  IN4 w0.135: 77.46,39.25 77.46,39.08 76.01,37.64 69.32,37.64 63.33,43.63 63.33,54.57 62.49,55.41 62.49,70.27 62.75,70.52 62.75,71.87 63.31,72.43 63.31,79.12 69.49,85.3 92.74,85.3 97.47,90.03 97.47,90.82 97.09,91.2 96.27,91.2 96.02,90.94 96.02,90.64 v1(95.79,90.41)
PEG_CTX_GRX_C_P6: length 97.7
  TOP w0.102: JCPU1.B30 77.59,41.25 v1(77.11,40.76)
  TOP w0.109: v1(97.47,92.77) 97.37,92.67 97.37,92.54 97.47,92.44 97.9,92.44 97.99,92.54 97.99,92.93 97.78,93.14 97.78,93.35 CC58.2
  IN4 w0.089: v1(77.11,40.76) 77.11,40.43 76.98,40.31 76.71,40.31 76.49,40.08 76.49,39.49 76.46,39.46 76.46,39.43
  IN4 w0.135: 76.46,39.43 76.46,39.23 75.68,38.44 69.65,38.44 64.14,43.95 64.14,54.9 63.31,55.74 63.31,69.87 63.61,70.17 63.61,71.59 64.12,72.1 64.12,78.79 69.82,84.49 93.08,84.49 98.28,89.7 98.28,92.24 98,92.52 97.72,92.52 v1(97.47,92.77)
PEG_CTX_GRX_C_P7: length 96.3
  TOP w0.102: JCPU1.C31 76.59,42.25 v1(76.11,41.76)
  TOP w0.109: CC57.2 99.56,93.35 99.56,93.14 99.77,92.93 99.77,92.54 99.68,92.44 99.25,92.44 99.14,92.54 99.14,92.67 v1(99.25,92.77)
  IN4 w0.089: 74.91,39.24 74.95,39.2 75.27,39.2 75.54,39.47 75.54,41.16 75.74,41.36 75.95,41.36 76.11,41.51 v1(76.11,41.76)
  IN4 w0.135: 74.91,39.24 70.09,39.24 64.96,44.37 64.96,55.26 64.12,56.09 64.12,69.55 64.41,69.84 64.41,71.24 64.93,71.77 64.93,78.46 70.15,83.68 93.41,83.68 100.06,90.33 100.06,92.24 99.78,92.52 99.5,92.52 v1(99.25,92.77)
PEG_CTX_GRX_C_P8: length 91.1
  TOP w0.102: v1(75.11,39.76) 75.59,40.25 JCPU1.A32
  TOP w0.109: v1(101.05,92.75) 101.23,92.75 101.34,92.86 101.34,93.35 CC70.2
  IN4 w0.089: 71.94,40.12 71.97,40.14 75.01,40.14 75.11,40.05 v1(75.11,39.76)
  IN4 w0.135: v1(101.05,92.75) 101.2,92.59 101.2,90.69 93.64,83.13 70.36,83.13 65.49,78.26 65.49,71.54 64.96,71.01 64.96,69.62 64.68,69.34 64.68,56.34 65.52,55.51 65.52,44.59 69.99,40.12 71.94,40.12
PEG_CTX_GRX_C_P9: length 88.8
  TOP w0.102: v1(74.11,40.75) 74.11,40.76 74.59,41.25 JCPU1.B33
  TOP w0.109: v1(102.83,92.75) 103.01,92.75 103.12,92.86 103.12,93.35 CC55.2
  IN4 w0.089: 71.89,41.13 71.9,41.13 71.93,41.16 73.95,41.16 74.11,41 v1(74.11,40.75)
  IN4 w0.135: v1(102.83,92.75) 102.98,92.59 102.98,91.3 93.99,82.32 71.11,82.32 66.66,77.86 66.66,71.56 65.76,70.66 65.76,69.29 65.49,69.02 65.49,56.68 66.66,55.51 66.66,44.74 70.26,41.13 71.89,41.13
PEG_CTX_GRX_C_P10: length 95.2
  TOP w0.102: JCPU1.H30 77.59,47.25 v1(77.11,46.76)
  TOP w0.109: v1(104.58,92.77) 104.48,92.67 104.48,92.54 104.58,92.44 105.01,92.44 105.11,92.54 105.11,92.93 104.89,93.14 104.89,93.35 CC54.2
  IN4 w0.089: 71.92,42.39 71.93,42.39 71.95,42.37 76.3,42.37 76.51,42.58 76.51,46.16 76.71,46.36 76.98,46.36 77.11,46.48 v1(77.11,46.76)
  IN4 w0.135: 71.92,42.39 71.26,42.39 67.71,45.95 67.71,56.28 67.41,56.57 67.41,70.81 67.71,71.11 67.71,77.43 71.52,81.24 94.42,81.24 102.04,88.86 102.96,88.86 105.39,91.29 105.39,92.24 105.11,92.52 104.83,92.52 v1(104.58,92.77)
PEG_CTX_GRX_C_P11: length 97.8
  TOP w0.102: v1(76.11,46.76) 76.59,47.25 JCPU1.H31
  TOP w0.109: CC69.2 106.67,93.35 106.67,92.59 106.91,92.36 107.15,92.36 v1(107.37,92.14)
  IN4 w0.089: v1(76.11,46.76) 76.11,47.08 76.03,47.16 75.79,47.16 75.7,47.06 75.7,43.47 75.38,43.15 72.77,43.15 72.76,43.16 72.75,43.16
  IN4 w0.135: 72.75,43.16 71.28,43.16 68.25,46.18 68.25,56.5 67.95,56.8 67.95,70.57 68.25,70.87 68.25,77.21 71.35,80.3 102.7,80.3 107.88,85.49 107.88,92.21 107.76,92.34 107.58,92.34 v1(107.37,92.14)
PEG_CTX_GRX_C_P12: length 93.8
  TOP w0.102: v1(75.11,45.76) 75.59,46.25 JCPU1.G32
  TOP w0.109: CC52.2 108.45,93.35 108.45,92.59 108.68,92.36 108.93,92.36 v1(109.15,92.14)
  IN4 w0.089: v1(75.11,45.76) 75.11,46.08 75.03,46.15 74.84,46.15 74.71,46.02 74.71,44.43 74.43,44.15 72.07,44.15 72.07,44.15 72,44.15 71.98,44.12 71.97,44.12
  IN4 w0.135: 71.97,44.12 71.44,44.12 69.06,46.5 69.06,56.84 68.75,57.15 68.75,70.24 69.06,70.55 69.06,76.88 71.67,79.5 103.04,79.5 109.61,86.07 109.61,92.26 109.53,92.34 109.36,92.34 v1(109.15,92.14)
PEG_CTX_GRX_C_P13: length 92.7
  TOP w0.102: v1(74.11,46.76) 74.59,47.25 JCPU1.H33
  TOP w0.109: v1(110.69,91.78) 110.47,92 110.33,92 110.01,92.32 110.01,92.99 110.23,93.21 110.23,93.35 CC51.2
  IN4 w0.089: v1(74.11,46.76) 74.11,47.05 73.99,47.17 73.81,47.17 73.7,47.06 73.7,45.54 73.32,45.17 72,45.17 71.97,45.14 71.95,45.14
  IN4 w0.135: 71.95,45.14 71.57,45.14 69.86,46.85 69.86,57.21 69.55,57.52 69.55,69.9 69.86,70.21 69.86,76.56 71.99,78.69 105.2,78.69 107.48,80.96 107.48,82.29 111.16,85.97 111.16,91.85 111.03,91.98 110.89,91.98 v1(110.69,91.78)
PEG_CTX_GRX_C_P14: length 88
  TOP w0.102: v1(73.11,45.76) 73.59,46.25 JCPU1.G34
  TOP w0.109: CC68.2 112.01,93.35 112.01,92.83 v1(111.79,92.62)
  IN4 w0.089: v1(73.11,45.76) 73.11,45.91 73.01,46.01 72.45,46.01 72.28,46.17 71.72,46.17 71.61,46.29 71.44,46.45 71.4,46.45 71.38,46.47
  IN4 w0.135: v1(111.79,92.62) 111.97,92.44 111.97,92.21 112.35,91.83 112.35,84.42 105.82,77.89 72.31,77.89 70.66,76.23 70.66,69.89 70.34,69.57 70.34,57.87 70.66,57.56 70.66,47.19 71.38,46.47
PEG_CTX_GRX_C_P15: length 86.3
  TOP w0.102: v1(72.13,47.76) 72.13,47.81 JCPU1.J35
  TOP w0.109: v1(113.57,92.62) 113.78,92.83 113.78,93.35 CC67.2
  IN4 w0.089: 72.49,50.99 72.49,50.96 72.53,50.93 72.53,47.33 72.4,47.21 72.19,47.21 72.13,47.27 v1(72.13,47.76)
  IN4 w0.135: 72.49,50.99 72.49,51.42 71.46,52.46 71.46,57.9 71.15,58.2 71.15,69.23 71.46,69.53 71.46,75.91 72.63,77.08 106.33,77.08 113.76,84.51 113.76,92.43 v1(113.57,92.62)
PEG_CTX_GRX_N0: length 2.6
  TOP w0.109: JMXM1.176 87.5,96.09 87.35,95.93 87.35,95.72 87.69,95.38 87.69,94.96 CC50.1
PEG_CTX_GRX_N1: length 2.8
  TOP w0.109: CC77.1 89.49,94.93 89.49,95.26 89.21,95.54 89.01,95.54 88.83,95.72 88.83,95.9 89,96.06 JMXM1.170
PEG_CTX_GRX_N2: length 3.2
  TOP w0.109: JMXM1.164 90.5,96.07 90.36,95.92 90.36,95.74 90.48,95.62 91.12,95.62 91.4,95.34 91.4,94.93 CC62.1
PEG_CTX_GRX_N3: length 3.2
  TOP w0.109: CC49.1 93.18,94.93 93.18,95.14 93.44,95.41 94.06,95.41 94.36,95.7 94.36,95.93 94.5,96.08 JMXM1.156
PEG_CTX_GRX_N4: length 3
  TOP w0.109: CC76.1 94.95,94.93 94.95,95.11 95.22,95.38 95.6,95.38 95.86,95.64 95.86,95.88 96,96.03 JMXM1.150
PEG_CTX_GRX_N5: length 4.6
  TOP w0.109: JMXM1.144 97.5,96.08 97.36,95.94 97.36,95.68 96.46,94.79 96.46,94.64 96.47,94.63 v3(96.47,94.19) 96.47,93.17 CC59.1
PEG_CTX_GRX_N6: length 3
  TOP w0.109: CC48.1 97.98,94.96 97.98,95.11 98.15,95.29 98.52,95.29 98.86,95.63 98.86,95.89 99,96.03 JMXM1.138
PEG_CTX_GRX_N7: length 2.6
  TOP w0.109: CC75.1 99.78,94.93 99.78,95.11 100.36,95.68 100.36,95.91 100.5,96.06 JMXM1.132
PEG_CTX_GRX_N8: length 2.5
  TOP w0.109: CC56.1 101.55,94.94 101.55,95.22 101.87,95.54 101.87,95.9 102,96.03 JMXM1.126
PEG_CTX_GRX_N9: length 2.4
  TOP w0.109: CC47.1 103.36,94.91 103.36,95.9 103.5,96.05 JMXM1.120
PEG_CTX_GRX_N10: length 2.5
  TOP w0.109: JMXM1.114 105,96.05 104.86,95.9 104.86,95.57 105.11,95.31 105.11,94.93 CC74.1
PEG_CTX_GRX_N11: length 2.6
  TOP w0.109: CC46.1 106.87,94.95 106.87,95.19 106.36,95.71 106.36,95.89 106.5,96.04 JMXM1.108
PEG_CTX_GRX_N12: length 2.9
  TOP w0.109: CC73.1 108.64,94.94 108.64,95.24 108.29,95.59 107.98,95.59 107.86,95.72 107.86,95.89 108,96.04 JMXM1.102
PEG_CTX_GRX_N13: length 3.1
  TOP w0.109: CC53.1 110.43,94.95 110.43,95.15 110.04,95.54 109.51,95.54 109.38,95.67 109.38,95.92 109.5,96.04 JMXM1.96
PEG_CTX_GRX_N14: length 3.3
  TOP w0.109: JMXM1.90 111,96.17 110.86,96.03 110.86,95.91 111.32,95.45 111.89,95.45 112.2,95.13 112.2,94.96 CC45.1
PEG_CTX_GRX_N15: length 3.3
  TOP w0.109: JMXM1.84 112.5,96.03 113.22,95.31 113.67,95.31 113.94,95.05 113.94,94.9 114.23,94.6 CC44.1
PEG_CTX_GRX_P0: length 2.5
  TOP w0.109: CC64.1 87.48,94.92 87.48,95.29 87.14,95.64 87.14,95.94 87,96.08 JMXM1.178
PEG_CTX_GRX_P1: length 2.8
  TOP w0.109: JMXM1.172 88.5,96.05 88.62,95.93 88.62,95.63 88.92,95.33 89.13,95.33 89.28,95.17 89.28,94.95 CC63.1
PEG_CTX_GRX_P2: length 3.2
  TOP w0.109: CC72.1 91.19,94.95 91.19,95.25 91.03,95.41 90.4,95.41 90.14,95.66 90.14,95.92 90,96.07 JMXM1.166
PEG_CTX_GRX_P3: length 3.3
  TOP w0.109: JMXM1.158 94,96.06 94.14,95.92 94.14,95.79 93.97,95.62 93.35,95.62 92.97,95.23 92.97,94.95 CC61.1
PEG_CTX_GRX_P4: length 3
  TOP w0.109: JMXM1.152 95.5,96.04 95.64,95.89 95.64,95.73 95.51,95.59 95.13,95.59 94.74,95.2 94.74,94.95 CC60.1
PEG_CTX_GRX_P5: length 4.6
  TOP w0.109: JMXM1.146 97,96.08 97.14,95.94 97.14,95.77 96.25,94.87 96.25,94.5 96.22,94.47 96.22,93.93 96.25,93.9 96.25,93.15 CC71.1
PEG_CTX_GRX_P6: length 3
  TOP w0.109: CC58.1 97.77,94.92 97.77,95.2 98.07,95.5 98.43,95.5 98.64,95.71 98.64,95.9 98.5,96.04 JMXM1.140
PEG_CTX_GRX_P7: length 2.6
  TOP w0.109: JMXM1.134 100,96.07 100.14,95.92 100.14,95.77 99.57,95.2 99.57,94.95 CC57.1
PEG_CTX_GRX_P8: length 2.5
  TOP w0.109: JMXM1.128 101.5,96.05 101.66,95.9 101.66,95.63 101.33,95.3 101.33,94.94 CC70.1
PEG_CTX_GRX_P9: length 2.4
  TOP w0.109: JMXM1.122 103,96.05 103.14,95.91 103.14,94.97 CC55.1
PEG_CTX_GRX_P10: length 2.5
  TOP w0.109: CC54.1 104.9,94.95 104.9,95.22 104.64,95.48 104.64,95.91 104.5,96.05 JMXM1.116
PEG_CTX_GRX_P11: length 2.6
  TOP w0.109: CC69.1 106.66,94.93 106.66,95.1 106.14,95.62 106.14,95.91 106,96.05 JMXM1.110
PEG_CTX_GRX_P12: length 2.9
  TOP w0.109: JMXM1.104 107.5,96.05 107.64,95.9 107.64,95.63 107.9,95.38 108.2,95.38 108.43,95.15 108.43,94.92 CC52.1
PEG_CTX_GRX_P13: length 3.2
  TOP w0.109: JMXM1.98 109,96.1 109.17,95.93 109.17,95.58 109.42,95.33 109.95,95.33 110.22,95.06 110.22,94.93 CC51.1
