# Allegro board LA-9771PR10-0624.brd (continued)
## Nets (continued)
N20207345: C555.1 R709.2 U62.4
N20966390: PL3.1 PQ2.1 PR7.1 PR10.2
N20966408: PQ3.2 PR10.1 PR12.2
N20966410: PQ2.2 PQ3.1 PR11.2 PR13.1
N21631508: PQ1004.4 PR1009.1
N21765641: C554.1 U63.12
N21766116: R717.1 R815.2 R844.2 U63.5
N21766341: C545.1 U63.10
N21774776: C436.1 U35.12
N21775970: C543.1 U35.10
N21777187: C435.1 U34.12
N21777255: C548.1 U34.10
N21778289: C549.1 U57.12
N21778337: C544.1 U57.10
N22506578: PR1008.1 PU1001.28
N22841899: Q87.1 R944.2
N22890234: RH195.2 UH1.AT8
N23248496: R802.2 U46.B18
N24484285: C546.1 U43.6
N24485569: C547.1 U56.6
N24487647: C541.1 U37.6
N24489474: C542.1 U38.6
N25846218: C16.1 R15.2 U38.3
N32810427: CE3.1 RE5.2
N32854162: C704.1 R756.2
N32854418: CE8.1 RE11.2
N32854492: CE9.1 RE12.2
N32916170: R804.1 U46.B19
N32917691: C713.1 R795.2
N32917710: C712.1 R794.2
N33080426: Q22.1 R423.2
N34391004: Q29.5 Q29.6 R513.2
N38606908: R783.1 U48.7
N48711348: PC521.1 PR534.1
N51290432: PC501.1 PR502.1
N51302473: PC500.1 PR501.1 PU501.6 PU501.7
N53085144: PC206.2 PR200.1
N53085275: PR205.2 PU200.9
N53866851: C747.1 R885.2
N63746311: R884.1 U51.B2
N63746359: R1984.1 U51.B8
N72304780: T126.1(TP-1) UH1.AY1
N85751870: PC306.2 PR301.2
N85751893: PC309.1 PR304.2
N88960285: Q344.3 R955.1
N90453843: R101.2 U23.12
N94639990: D68.2 U3.4
N106386290: CE1.1 RE1.2
N106390602: CE2.1 RE2.2
N109035766: Q340.3 R2190.2
N109035794: Q339.5 Q339.6 R2192.2
N109035808: Q340.6 R2191.2
N111311136: JCPU1.AC7 T60.1(TP-1)
N111311586: JCPU1.AG8 T64.1(TP-1)
N111316295: JCPU1.R27 T69.1(TP-1)
N111321501: JCPU1.AR1 T99.1(TP-1)
N111321503: JCPU1.A2 T100.1(TP-1)
N111321505: JCPU1.K6 T94.1(TP-1)
N111321507: JCPU1.F5 T93.1(TP-1)
N111321509: JCPU1.AM2 T95.1(TP-1)
N111321511: JCPU1.C35 T82.1(TP-1)
N111321513: JCPU1.B35 T81.1(TP-1)
N111321515: JCPU1.A34 T73.1(TP-1)
N111321517: JCPU1.A35 T74.1(TP-1)
N111321521: JCPU1.AT2 T71.1(TP-1)
N111321546: JCPU1.E20 T101.1(TP-1)
N111321548: JCPU1.E21 T102.1(TP-1)
N111321550: JCPU1.E18 T96.1(TP-1)
N111321552: JCPU1.D23 T88.1(TP-1)
N111321596: JCPU1.W30 T84.1(TP-1)
N111321598: JCPU1.W31 T83.1(TP-1)
N111321602: JCPU1.W29 T75.1(TP-1)
N111321604: JCPU1.W28 T76.1(TP-1)
N111321610: JCPU1.P10 T97.1(TP-1)
N111321612: JCPU1.U10 T98.1(TP-1)
N111321642: JCPU1.AL25 T85.1(TP-1)
N111321646: JCPU1.AT1 T70.1(TP-1)
N111321650: JCPU1.AM26 T89.1(TP-1)
N111321654: JCPU1.AR33 T91.1(TP-1)
N111321656: JCPU1.AM27 T92.1(TP-1)
N111321658: JCPU1.B23 T78.1(TP-1)
N111321660: JCPU1.C23 T86.1(TP-1)
N111321662: JCPU1.D24 T87.1(TP-1)
N111321667: JCPU1.AL30 T79.1(TP-1)
N111321671: JCPU1.AD10 T72.1(TP-1)
N111327495: JCPU1.V27 T113.1(TP-1)
N111327547: JCPU1.AT35 T157.1(TP-1)
N111327958: JCPU1.AL27 T151.1(TP-1)
N111328199: JCPU1.AR35 T158.1(TP-1)
N111328255: JCPU1.AK27 T152.1(TP-1)
N111328259: JCPU1.AL13 T154.1(TP-1)
N111329001: JCPU1.L27 T77.1(TP-1)
N111329005: JCPU1.K27 T110.1(TP-1)
N111329010: JCPU1.T27 T112.1(TP-1)
N111329086: JCPU1.E17 T153.1(TP-1)
N111329153: JCPU1.W32 T160.1(TP-1)
N111329155: JCPU1.AL16 T159.1(TP-1)
N111329157: JCPU1.N26 T115.1(TP-1)
N111337107: JCPU1.AK33 T114.1(TP-1)
N111857606: JCPU1.AL29 T80.1(TP-1)
N113061370: JMXM1.55 R1970.2
N116160023: D67.2 U54.4
N116282053: CD89.2 RC109.1
N116282133: CD90.2 RC110.1
N116406009: CD91.2 RC111.1
N116905454: Q110.3 Q113.2 Q113.5 R1537.2
N116905461: Q113.3 R1530.2
N116905506: Q113.6 R1539.2
N116909867: Q335.3 R2157.2
N116909894: Q336.5 Q336.6 R2152.2
N116909908: Q335.6 R2151.2
N116909947: Q337.3 R2161.2
N116909973: Q337.6 R2154.2
N117170853: JLOM1.13 R1171.2
N117170855: JLOM1.11 R1167.2
N117171278: JLOM1.10 R1170.2
N117983692: R818.2 U29.17
N117984013: R420.1 U29.11
N117984029: R418.1 U29.14
N118331047: Q79.1 R939.1
N118331054: Q78.1 Q79.2
N118331059: Q75.1 R934.1
N118331066: D59.1 Q74.3
N118331070: D59.2 D62.2 Q74.1 Q328.3 R932.2
N118331074: Q74.6 Q75.2
N118331095: Q318.1 R941.1
N118331099: Q80.1 R942.1
N118331106: Q86.1 R943.1
N118331109: Q86.2 Q328.1
N118535661: R656.1 U39.9
N118640218: RH144.1 UH1.AA2
N118640221: RH145.1 UH1.Y3
N119148113: JCPU1.J27 T164.1(TP-1)
N119362006: R747.1 U45.7
N119363129: R2141.2 U638.30
N119556938: Q28.2 R399.2
N260222010: PQ1083.5 PR1033.1

Pads without a net: D88 3; D91 3; FD1 1; FD2 1; FD3 1; FD4 1; JAPS1 15 16; JCPU1 B1 T28 T30 T32 T34 U28 U29 U30 U31 U32 U33 U34 U35 V29 V31 V33 V35; JDIMM1 77 122 125 198; JDIMM2 77 122 125 198; JDIMM3 77 122 125 198; JDIMM4 77 122 125 198; JDOCK1 146 147 148; JHDMI1 14; JMINI2 3 5 17 19 40 44 45 46 47 49; JMINI3 3 5 6 8 10 12 20 28 30 32 36 37 38 40 42 44 45 46 47 48 49 51; JMINI4 3 5 6 28 30 48; JMXM1 46 48 50 52 57 60 62 64 65 66 67 74 75 76 77 78 79 80 81 189 191 193 195 197 205 207 210 212 257 259 261 263 265 266 267 269 271 273 275 277 279; JPB1 3; JSATA1 20 21 22; JSIM1 4 8 9; JUSH1 11 12; JWL1 2; JXDP1 55; JXDP2 3 5 21 22 23 24 42 45 47 55; PJPDC1 1; PR3 1 8; PU101 19; PU400 1 7; PU700 3; PU1001 31 35 36; RP2 4 5; RP8 4 5; RPH9 4 5; U9 46; U11 32 33 34; U13 4 5 6 12 13 14 32 33 34; U19 12; U22 8 15 21 26 37 43 46; U23 2 23 24 33 34; U29 4 5 18 22 29 30; U32 5; U39 6 7 12 14; U88 2 3; U629 50; U637 16; U638 12; UH1 A28 AE42 AE44 AJ10 AJ42 AJ44 AP15 AR15 AR33 AT33 AV36 AW36 BB37 BC14 BC36 BD37 BE14 BE36 C28 D21 F22 F41 G22 H43 H45 K22 K38 K40 K43 K45 R35 R36 R39 R40 Y38 Y39

## Via types
v1: diameter 0.457, hole 0.203, TOP to BOTTOM, 5309 vias
v2: diameter 0.305, hole 0.152, TOP to BOTTOM, 891 vias
v3: diameter 0.508, hole 0.254, TOP to BOTTOM, 1577 vias
v4: diameter 0.406, hole 0.203, TOP to BOTTOM, 127 vias
v5: diameter 0.508, hole 0.229, TOP to BOTTOM, 9 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.75V_DDR_VTT_ON: length 70.4
  TOP w0.102: v1(228.25,73.19) 228.25,74.86 224.12,79 v1(224.12,79.52)
  IN3 w0.127: v1(177.73,84.26) 177.73,84.31 178.39,84.97 183.32,84.97 187.84,80.45 202.68,80.45 204.56,78.57 208.52,78.57 209.61,77.49 209.61,76.59 209.86,76.34 210.76,76.34 210.94,76.16 217.36,76.16 219.44,74.08 221.04,74.08 223.6,76.65 223.6,79.01 v1(224.12,79.52)
  BOTTOM w0.102: RP4.3 v2(228.76,72.27) 228.76,72.68 v1(228.25,73.19) ; v1(177.73,84.26) 177.73,84.16 175.93,82.36 PR208.1 ; U46.A60 v1(224.12,79.52)
1.05V_0.8V_PWROK: length 235.9
  TOP w0.102: v1(53.65,8.01) 53.65,8.13 54.92,9.4 v2(54.92,9.87) 54.92,16.42 51.8,19.54 51.58,19.54 51.32,19.8 50.91,19.8 50.66,19.54 48.14,19.54 PR517.1
  IN1 w0.109: v1(90.13,92.95) 90.13,95.84 91.75,97.47 91.75,107.1 93.35,108.7 93.35,109.76 93,110.12 93,111.87 94.35,113.23 94.35,114.9 93.67,115.57 93.67,122.12 92.66,123.14 92.66,125.06 94.44,126.84 94.44,129.9 94.27,130.08 94.27,132.5 94.32,132.55 94.32,139.56 93.18,140.69 93.18,142.95 92.64,143.5 92.64,148.75 v1(91.63,149.77)
  IN4 w0.109: v1(53.65,8.01) 54.14,8.5 72.99,8.5 74.97,10.48 74.97,11.6 86.27,22.89 86.27,24.14 92.65,30.52 92.65,33.47 96.06,36.88 106.75,36.88 113.01,43.15 113.01,67.89 115.71,70.58 115.71,79.21 115.22,79.69 115.22,92.52 114.13,93.61 97.49,93.61 96.86,94.24 91.42,94.24 v1(90.13,92.95)
  BOTTOM w0.102: v1(91.63,149.77) 91.52,149.67 R883.2 91.59,148.95 U50.4
1.05V_A_PWRGD: length 116.3
  TOP w0.102: v2(18.3,148.49) 18.66,148.12 v1(18.83,148.12)
  IN2 w0.127: v1(103.21,153.4) 103.11,153.5 103.11,155.79 101.18,157.72 98.28,157.72 97.38,156.82 96.19,156.82 94.43,155.05 93.02,155.05 91.17,153.2 91.17,147.88 90.59,147.3 90.59,146.81 87.03,143.25 86.56,143.25 85.33,142.02 78.33,142.02 77.11,140.8 74.2,140.8 65.85,132.46 48.31,132.46 v1(47.9,132.05)
  IN3 w0.127: v1(47.9,132.05) 47.81,132.14 42.69,132.14 42.41,131.86 35.93,131.86 34.53,133.26 33.37,133.26 32.67,133.96 32.67,135.69 30.92,137.44 30.12,137.44 28.76,138.8 28.76,142.02 23.91,146.87 20.07,146.87 v1(18.83,148.12)
  BOTTOM w0.102: U51.B28 102.75,152.18 102.8,152.23 102.8,152.99 v1(103.21,153.4) ; PU300.1 20.47,147.18 PR300.1 v1(18.83,148.12)
1.05V_RUN_ENABLE: length 25.9
  TOP w0.406: 55.86,133.77 57.55,133.77 57.9,133.42 57.9,132.85 Q304.3
  TOP w0.508: 55.86,133.77 54.66,133.77 v2(53.83,132.94) 52.33,131.44 47.43,131.44 47.29,131.58 42.91,131.58 41.69,132.8 40,132.8 37.68,130.48 37.68,129.14
  BOTTOM w0.508: R933.2 37.3,128.31 v1(37.32,128.33)
1.5V_RUN_PWRGD: length 298.6
  TOP w0.102: v1(97.09,162.32) 96.44,162.32 v2(96.43,162.3)
  IN3 w0.127: v1(97.09,162.32) 97.54,161.86 102.04,161.86 102.95,162.77 102.95,163.54 103.36,163.94 111.23,163.94 112.59,162.58 115.26,162.58 117.05,164.37 123.43,164.37 125.61,162.2 128.5,162.2 129.04,161.66 136.16,161.66 140.44,157.38 143.34,157.38 153.03,147.68 153.03,147.1 154.22,145.91 154.22,144.3 155.28,143.24 155.28,142.39 158.3,139.37 158.3,132.6 161.1,129.8 164.21,129.8 166.51,127.5 166.51,124.89 174,117.4 174,108.61 175.62,106.98 175.62,106.07 181.17,100.52 197.24,100.52 203.19,94.57 208.92,94.57 210.85,92.64 216.01,92.64 216.8,91.86 223.43,91.86 225.94,89.34 228.38,89.34 229.65,88.07 233.51,88.07 234.02,88.58 235.9,88.58 236.61,89.29 236.61,90.41 237.65,91.45 249.34,91.45 272.02,68.77 272.02,45.1 262.56,35.65 259.62,35.65 v1(259.11,35.14)
  IN4 w0.109: v1(92.11,146.77) 92.11,147.51 91.17,148.45 91.17,154.04 92.08,154.95 92.08,156.93 91.71,157.31 91.71,157.89 96.13,162.32 v1(97.09,162.32)
  BOTTOM w0.102: v1(259.11,35.14) 259.11,35.27 PR400.2 259.57,35.01 259.19,34.63 259.19,34.2 259.45,33.94 PU400.4 ; U50.1 92.89,146.22 92.31,146.8 92.13,146.8 v1(92.11,146.77)
1.5VSP_FB: length 5.5
  BOTTOM w0.102: v2(265.58,32.38) 265.21,32.01 264.04,32.01 PC402.2
  BOTTOM w0.254: PU400.6 263.51,34.44 PR405.1 263.58,33.42 PR402.2 263.56,32.5 PC402.2
1.5VSP_LX:
  vias: v2(258.23,29.59)
1.5VSP_VIN: length 1.3
  BOTTOM w0.102: v2(263.8,30.81) 263.76,30.77 PC400.1
1.35V_B+: length 61.9
  IN1 w0.635: v3(201.39,64.98) 201.39,62.96 200.57,62.14 180.63,62.14 180.12,62.65 v3(180.12,65.06)
  BOTTOM w0.635: v3(201.39,64.98) 201.39,70.36 199.83,71.92 199.83,73.29 197.38,75.74 v2(193.14,75.74) 191.66,75.74 190.79,76.62 189.34,76.62 181.72,84.24 179.99,84.24 179.1,83.35 PR205.1
1.35V_FB: length 11
  BOTTOM w0.203: PU200.6 177.09,79 176.81,79.28 175.55,79.28 175.42,79.41 174.2,79.41 PR211.2 ; PR204.2 PR211.2 ; PR211.2 173.62,78.98 PC211.1 PR207.2 171.87,80.43 171.59,80.71 170.79,80.71 v2(170.49,80.41) 170.11,80.03 PR218.1
1.35V_SUS_PWRGD: length 167.3
  IN1 w0.109: v1(180.9,82.43) 180.86,82.43 180.51,82.09 177.3,82.09 165.76,93.64 159.01,93.64 158.57,94.08 124.9,94.08 122.91,92.09 118.96,92.09 118.15,92.9 v1(117.2,92.9) 117.1,93 116.67,93 112.05,97.62 112.05,104.48 110.39,106.14 110.39,110.17 107.67,112.9 107.67,117.4 106.11,118.96 106.11,119.92 105.24,120.79 105.24,123.38 108.67,126.81 108.67,130.39 107.56,131.5 107.56,133.56 105.4,135.72 105.4,136.58 104.48,137.5 104.48,142.5 105.93,143.95 105.93,146.75 106.36,147.18 106.36,147.71 107.6,148.96 108.44,148.96 111.49,152.01 111.49,154.44 110.84,155.1 108.95,155.1 v1(107.68,156.37)
  BOTTOM w0.102: v1(107.68,156.37) 107.83,156.52 U51.B9 ; v1(117.2,92.9) 117.2,89.44 CC138.1 112.63,84.87 v2(112.63,84.19) 111.53,83.08 UC2.1 ; v1(180.9,82.43) 180.9,81.95 180.32,81.37 PR209.2 180.25,80.58 178.69,79.02 PU200.10
3.3V_RUN_GFX_ON: length 229.3
  TOP w0.102: QH3.2 50.14,94.48 50.71,95.05 50.71,96.71 52.69,98.69 53.72,98.69 54.54,99.5 54.54,99.74 55.15,100.36 v1(55.15,101) ; Q87.2 152.23,109.25 152.67,108.82 v1(152.67,107.48)
  IN2 w0.127: v1(226.37,78.27) 226.37,78.24 228.23,80.1 228.23,81.98 226.86,83.35 222.89,83.35 222.82,83.27 221.04,83.27 219.85,84.47 219.85,85.68 219.36,86.17 212.91,86.17 206.69,92.39 205.03,92.39 199.9,97.52 198.66,97.52 195.97,100.21 188.44,100.21 182.15,106.5 177.76,106.5 175.69,108.57 158.12,108.57 157.03,107.48 v1(152.67,107.48) 152.14,106.94 127.64,106.94 126.92,107.67 119.15,107.67 v1(118.45,108.36) 118.32,108.36 117.56,107.61 84.36,107.61 83.21,106.45 80.73,106.45 80.03,105.75 77.94,105.75 76.89,106.79 73.49,106.79 71.61,104.92 71.61,103.67 68.43,100.49 67.28,100.49 66.82,100.04 60.76,100.04 59.8,101 v1(55.15,101)
  BOTTOM w0.102: v1(55.15,101) 55.15,102.68 56.65,104.18 56.65,106.89 58.03,108.28 v2(58.03,108.79) R301.1 57.94,110.24 U34.3 ; U35.3 118.54,108.27 v1(118.45,108.36) ; v1(226.37,78.27) 225.56,79.08 225.56,80.68 225.21,81.04 225.21,81.11 224.29,82.02 U46.A55
3V_5V_EN: length 15.9
  IN4 w0.254: v3(248.83,60.87) 247.81,61.89 245.53,61.89 243.54,63.87 242.78,63.87 v3(242.35,64.3)
  BOTTOM w0.102: v3(242.35,64.3) 242.35,65.2 v2(242.34,65.21)
  BOTTOM w0.203: PU101.6 248.46,60.25 248.83,60.62 v3(248.83,60.87) ; PC120.1 242.99,61 243.87,61 244.62,60.25 PU101.20
  BOTTOM w0.254: PC120.1 242.34,62.67 PR111.2 242.35,63.55 ; 242.35,63.55 v3(242.35,64.3) ; 242.35,63.55 PR112.2
3V_PWROK#: length 4.1
  TOP w0.102: v2(163.34,135.16) 163.94,135.16 164.7,134.4 R410.2
  TOP w0.254: U29.12 165.44,133.51 164.8,134.15 R410.2
+0.9V_LAN: length 6.9
  BOTTOM w0.203: U31.16 v1(126.2,152.04) ; U31.11 v1(124.14,154.9) ; U31.37 v1(118.44,148.84) ; U31.43 v1(118.45,151.24) ; U31.40 v1(118.4,150.04) ; U31.8 122.94,154.59 123.02,154.67 123.02,155.31 v1(123.05,155.33) ; v1(126.25,149.64) U31.22
  vias: v1(117.64,153.48) v1(118.27,153.48) v4(117.97,152.99)
+0.675V_DDR_VTT: length 102.3
  TOP w0.356: 144.66,27.25 JDIMM1.204
  IN3 w1.016: 168.69,73.44 168.69,69.3 164.75,65.36 164.75,51.9 165.67,50.99 165.67,45.02 164.22,43.57 164.22,35.75 165.16,34.81 165.16,29.6 165.39,29.37 ; 166.91,29.37 166.91,30.9 167.55,31.53 167.55,32.42 166.79,33.18 166.79,35.47 166.28,35.98 166.28,40.8 167.57,42.1 167.57,45.15 166.94,45.78 166.94,47.43 168.82,49.31 168.82,54.01 168.56,54.27 168.56,61.33 170.81,63.57 170.81,73.19 169.92,74.08 169.71,74.08
  BOTTOM w0.356: JDIMM2.203 145.79,27.55 144.67,27.55 144.22,27.1 v1(144.22,25.99) ; v1(138.95,25.99) 138.95,26.99 138.68,27.25 137.6,27.25 JDIMM2.204
  vias: v1(153.31,26.03) v1(160.82,27.55) v1(165.21,28.31) v1(165.79,28.31) v1(166.38,28.31) v1(166.96,28.31) v2(167.86,74.62) v3(168.94,76.49) v3(168.94,75.86) v3(168.94,75.22) v3(168.94,74.59)
+0.675V_P: length 2.1
  BOTTOM w0.203: PU200.2 175.53,76.7 175.09,76.26 175.09,75.55
  vias: v4(175.89,73.8)
+1.05V_M: length 2.5
  TOP w0.305: UH1.L17 28.64,96.53 v1(28.64,96.25)
  BOTTOM w0.381: v1(28.64,96.25) 28.64,96.42 29.08,96.86 CH30.1
  BOTTOM w0.508: v1(32.47,98.96) 32.56,99.05 CH29.1
  vias: v1(31.15,97.32) v1(31.81,98.97) v1(31.81,97.33) v1(32.47,97.33) v3(28.1,115.48) v3(28.1,114.84) v3(28.69,127.77) v3(28.69,127.14) v3(28.69,126.5) v4(29.32,116.33)
+1.05V_MP: length 24.4
  TOP w0.254: PR306.1 23.25,146.29 24.98,146.29 25.18,146.09 25.18,144.52 25.79,143.91 v1(26.23,143.91) ; v1(21.88,129.2) 21.92,129.23 PC301.1
  IN3 w0.254: v1(21.88,129.2) 27.24,134.55 27.24,142.91 v1(26.23,143.91)
  vias: v2(26.69,137.73)
+1.05V_RUN: length 367.3
  TOP w0.127: v1(32.47,102.21) 32.47,101.32 UH1.V28 31.8,101.33 v1(31.8,102.21)
  TOP w0.203: UH1.U35 31.63,104.09 31.39,103.85 31.36,103.85 31.2,103.69 v1(31.19,103.69)
  TOP w0.254: v1(37.98,97.32) 37.59,96.92 UH1.AM18 37.42,96.98 v1(37.06,97.33) ; UH1.U30 31.48,101.88 v1(31.8,102.21) 32.14,101.87 ; 32.14,101.87 UH1.V30 ; 32.14,101.87 32.14,101.88 v1(32.47,102.21) 32.8,101.88 UH1.Y30 ; v1(36.4,98.96) 36.76,98.6 UH1.AK22 ; v1(35.11,98.96) 35.11,98.9 34.78,98.57 UH1.AE22 UH1.AE20 34.78,97.66 v1(35.11,97.33) ; v1(35.11,98.96) 35.44,98.63 UH1.AG22 UH1.AG20 35.44,97.66 v1(35.11,97.33) ; v1(35.11,98.96) 34.78,99.29 UH1.AE24 UH1.AE26 34.78,100.24 v1(34.45,100.57) 34.12,100.9 UH1.AD28 ; v1(35.11,98.96) 35.44,99.29 UH1.AG24 ; v1(39.22,98.36) 39.22,98.48 39.53,98.79 ; 38.61,98.47 UH1.AR22 ; 38.61,98.47 38.61,98.52 UH1.AP22 ; 38.61,98.47 v1(38.61,98.35) ; UH1.AG18 35.44,97 v1(35.11,97.33) ; v1(35.11,97.33) 34.78,97 ; v1(31.19,104.34) 31.34,104.34 UH1.U36 ; UH1.Y26 32.8,100.25 v1(33.13,100.58) 33.46,100.25 UH1.AA26 UH1.AA24 33.87,98.95 v1(34.46,98.95) ; UH1.AK18 37.06,97.23 v1(37.06,97.33) ; RC32.1 80.43,80.55 v1(80.22,80.76) 80.22,81.14 79.33,82.03 74.46,82.03 RC27.1 ; v1(34.46,98.95) 34.12,98.61 UH1.AD22 UH1.AD20 34.12,97.66 v1(34.45,97.33) 34.78,97 ; v1(34.46,98.95) 34.12,99.29 UH1.AD24 UH1.AD26 ; v1(37.98,98.36) 37.79,98.55 UH1.AM22 ; RH206.1 48.32,87.03 49.08,86.27 v1(49.08,86.14) ; v1(37.06,97.33) 37.42,97.69 UH1.AM20 ; v1(37.06,97.33) 37.06,97.43 UH1.AK20 ; UH1.AN34 38.16,103.46 38.18,103.48 38.18,103.9 38.16,103.92 UH1.AN35 38.2,104.09 38.64,104.53 v1(38.65,104.53) ; v1(58.15,76.59) 59.32,75.42 RC126.1 59.98,76.06 61.4,76.06 RC35.1 ; 34.78,97 UH1.AE18
  TOP w0.279: v1(22.16,119.24) 22.8,118.59 JXDP2.40
  TOP w0.508: v1(97.44,165.87) 95.39,167.93 92.31,167.93 91.65,167.27 91.65,161.35 92.19,160.82 v1(92.19,157.57) ; v1(83.96,30.52) 83.83,30.39 81.44,30.39 77.53,26.48 72.14,26.48 64.2,34.42 v1(64.2,35.4) ; RH241.1 47.34,114.46 v3(47.67,114.79)
  IN1 w0.508: v3(62.49,94.32) 62.49,94.87 61.41,95.95 58.58,95.95 56.84,97.69 56.84,99.36 56.52,99.68 56.52,102.33 54.22,104.63 54.22,106.73 52.35,108.61 52.35,109.9 50.73,111.52 47.79,111.52 v3(47.63,111.36)
  IN2 w0.508: v3(47.67,114.79) 52.78,114.79 56.6,118.62 56.6,123.68 64.27,131.35 65.73,131.35 74.49,140.1 78.71,140.1 79.58,140.97 87.22,140.97 92.76,146.51 92.76,147.47 93.48,148.2 93.48,153.83 v3(93,154.32) ; v1(80.22,80.76) 77.3,77.84 73.21,77.84 71.78,76.4 v1(66.18,76.4) 65.83,76.74 58.3,76.74 v1(58.15,76.59) 58.15,76.48 59.24,75.39 59.24,74.66 58.63,74.05 57.92,74.05 57.17,73.3 57.17,47.85 64.2,40.82 v1(64.2,35.4)
  IN3 w0.254: v1(31.19,103.69) 29.92,103.69 29.64,103.4 29.05,103.4 29.03,103.38 26.64,103.38 26.53,103.26 25.87,103.26 25.32,103.81 25.32,104.44 25.71,104.84 26.21,104.34 v1(31.19,104.34)
  IN3 w0.508: v1(22.16,119.24) 31.18,119.24 32.3,118.12 34.45,118.12 34.63,118.3 36.9,118.3 37.57,117.63 39.04,117.63 39.66,118.25 v1(39.66,118.53) ; 25.71,104.84 24.37,106.18 20.4,106.18 20,106.59 18.3,106.59 17.64,105.93 17.64,104.18 16.9,103.44 16.32,103.44 15.99,103.77 15.99,104.28 15.18,105.08 14.25,105.08 13.7,104.53 13.7,103.01 14.05,102.65 14.64,102.65 v3(14.72,102.73) ; v3(93,154.32) 93,156.75 v1(92.19,157.57)
  IN4 w0.508: v3(62.49,94.32) 62.49,93.25 60.37,91.12 55.36,91.12 54.59,90.36 54.59,89.47 53.88,88.76 52.89,88.76 52.43,89.22 51.55,89.22 51.01,88.68 50.25,88.68 49.84,88.28 49.84,86.9 v1(49.08,86.14) 49.08,85.81 47.48,84.21 47.48,80.5 48.12,79.87 54.29,79.87 54.75,79.41 56.32,79.41 57.97,77.76 57.97,76.77 v1(58.15,76.59)
  BOTTOM w0.254: CH25.1 38.74,104.44 v1(38.65,104.53)
  BOTTOM w0.381: v1(38.61,98.35) 38.61,98.76 CH36.1 39.22,98.7 v1(39.22,98.36)
  BOTTOM w0.508: v1(58.15,76.59) 58.53,76.21 59.04,76.21 RC29.1 ; v1(31.19,104.34) 31.01,104.34 30.51,104.84 CH23.1 ; CH47.1 37.17,96.71 37.17,97.23 v1(37.06,97.33) ; R105.1 82.9,30.12 RC69.1 83.63,30.19 v1(83.96,30.52) ; CH50.1 22.18,119.21 v1(22.16,119.24) ; v1(32.47,102.21) 32.47,101.64 CH34.1 32.6,101.38 33.13,100.85 v1(33.13,100.58) ; RC99.2 65.87,75.11 65.87,76.1 v1(66.18,76.4) ; v1(37.98,98.36) 37.96,98.38 37.96,98.4 38.02,98.46 CH37.1 ; v1(34.45,97.33) 34.5,97.38 CH35.1 34.5,98.91 v1(34.46,98.95) ; R866.2 v1(97.44,165.87) ; v1(40.42,113.57) 40.7,113.3 CH93.1 40.42,111.52 v1(40.42,110.02) ; CH22.1 37.35,98.08 37.98,97.44 v1(37.98,97.32)
  vias: v1(39.66,121.07) v1(39.66,120.43) v1(39.66,119.8) v1(39.66,119.16) v3(38.92,126.66) v3(38.92,126.02) v3(38.92,125.39) v3(38.92,124.75) v3(38.92,124.12) v3(39.56,126.66) v3(39.56,126.02) v3(39.56,125.39) v3(39.56,124.75) v3(39.56,124.12) v3(39.56,123.48) v3(47.18,110.91) v4(37.55,122.35)
+1.5V_RUN: length 407.7
  TOP w0.254: 47.94,103.24 47.6,102.89 47.6,102.45 47.37,102.22 44.05,102.22 43.77,101.94 UH1.BE30 ; UH1.AT45 39.23,108.93 v1(39.49,109.19) ; v1(46.85,99.3) 46.85,99.2 46.44,98.79 43.36,98.79 UH1.BE22 ; UH1.BD4 42.62,91.46 v1(42.41,91.67) ; UH1.AM45 37.6,108.89 37.61,108.9 v1(37.61,108.93) ; v1(47.66,95.82) 47.6,95.88 45.73,95.88 45.64,95.79 43.71,95.79 UH1.BE16
  TOP w0.305: UH1.AN11 38.35,94.1 v1(38.62,94.37) ; UH1.BB44 41.41,107.77 v1(41.33,107.84) ; v1(35.72,103.17) 35.54,103.17 UH1.AF34 ; UH1.AK28 UH1.AK26 36.76,100.14 v1(37.12,99.78) ; v1(40.34,107.07) 40.51,106.91 UH1.AW40
  TOP w0.356: JIO1.82 16.31,87 C724.1 15.77,87.6 JIO1.80
  TOP w0.508: 49.78,104.73 49.78,107.64 48.7,108.72 v1(48.7,109.27) ; 49.78,104.73 48.95,103.91 48.62,103.91 47.94,103.24 ; 49.78,104.73 51.62,104.73 52.63,103.73 v3(52.63,100.98)
  IN1 w0.254: v1(38.62,94.37) 38.62,94.57 37.96,95.24 36.23,95.24 35.95,95.51 35.95,95.95 36.64,96.63 37.04,96.63 37.52,97.11 37.52,99.35 37.12,99.76 v1(37.12,99.78)
  IN1 w0.508: 171.61,93.3 171.79,93.12 171.79,92.06 177.33,86.52 177.71,86.52 178.16,86.07
  IN1 w1.016: 178.85,86.94 178.85,87.63 175.1,91.38 175.1,91.74 173.54,93.3 171.61,93.3
  IN1 w1.524: 171.61,93.3 160.92,103.99 159.4,103.99 154.62,108.76 154.62,112.63 152.99,114.26 152.99,115.28 152.98,115.29
  IN2 w0.508: v3(28.61,109.08) 28.61,110.91 31.05,113.35 31.05,114.36 30.04,115.36 30.04,117.27 v3(33.97,121.19)
  IN2 w1.016: 95.74,142.35 91.66,142.35 88.11,138.81 84.21,138.81 80.44,135.04 73.3,135.04 59.57,121.31 59.57,117.5 54.82,112.75 54.82,111.72 53.2,110.09 51.16,110.09 50.33,109.26
  IN3 w0.254: 24.04,123.2 24.04,125.49 24.6,126.05 26.6,126.05 27.11,125.54 30.87,125.54 33.97,122.44 v3(33.97,121.19)
  IN3 w0.508: v3(52.63,100.98) 52.49,100.98 47.66,96.15 v1(47.66,95.82) ; v3(33.97,121.19) 31.45,123.71 25.31,123.71 24.8,123.2 24.04,123.2
  IN3 w0.762: v3(14.72,125.49) v3(14.72,124.72) 16.24,123.2 24.04,123.2
  IN4 w0.508: v3(45.98,112.69) 45.35,112.69 44.71,112.05 38.22,112.05 37.34,111.17 35.36,111.17 34.67,110.49 30.02,110.49 v3(28.61,109.08)
  IN4 w1.524: 181.26,84.36 185.71,79.92 190.15,79.92 207.98,62.09
  IN4 w2.032: 254.8,26.96 255.3,26.96 258.12,29.78 264.35,29.78 271.56,36.99 271.56,61.12 265.72,66.97 257.84,66.97 256.45,68.36 252.69,68.36
  BOTTOM w0.254: 14.74,114.56 14.74,115.99 14.08,116.65 14.08,117.61 14.56,118.1 14.56,118.45 14.79,118.68 15.43,118.68 ; 47.8,98.19 47.8,97.56 47.02,96.78 44.76,96.78 43.67,95.69 RH100.1
  BOTTOM w0.457: RH57.2 43.72,90.08 44.12,90.48 44.12,91.01 43.75,91.37 42.7,91.37 v1(42.41,91.67) 42.41,91.91 43.04,92.55 44.46,92.55 45.2,93.28 45.2,94.73 46.07,95.6 47.44,95.6 v1(47.66,95.82)
  BOTTOM w0.508: 249.34,75.22 249.96,74.6 JMINI2.28 ; 249.34,75.22 249.59,75.22 v1(249.97,75.6) ; 249.34,75.22 C594.1 ; JMINI2.48 v1(250.88,66.6) 250.01,67.47 C593.1 ; LH1.1 29.26,112.02 28.51,111.26 28.51,109.18 v3(28.61,109.08) ; v1(250.86,86.6) JMINI2.6 ; 15.43,118.68 15.43,118.31 16.37,117.37 16.37,115.28 15.65,114.56 14.74,114.56 ; v1(39.49,109.19) 39.28,108.98 39.28,107.97
  BOTTOM w0.762: 14.74,114.56 12.86,112.69 12.86,111.82 v1(11.77,110.73) ; 15.43,118.68 15.43,124.01 v3(14.72,124.72) v3(14.72,125.49) ; v3(9.18,92.87) 9.18,92.37 9.84,91.7 9.84,91.4 10.33,90.9 13.56,90.9 14.99,89.47 15.45,89.47 16.14,88.78 v1(16.34,88.78)
  vias: v1(9.91,94.14) v1(16.85,88.25) v1(179.54,85.71) v1(180.12,85.76) v1(180.73,85.81) v3(10.42,110.12) v3(95.69,140.73) v3(95.7,141.42) v3(103.75,141.44) v3(115.73,140.12) v3(115.88,141.34) v3(115.99,140.7) v3(209.46,62.14) v3(209.46,61.5) v3(210.09,62.09) v3(250.1,70.78) v3(250.1,70.14) v3(250.73,70.78) v3(250.73,70.14) v3(252.13,27.21) v3(252.13,26.58) v3(252.76,27.21) v3(252.76,26.58) v4(48.78,107.1)
+1.05V_RUN_VCC: length 2.6
  TOP w0.102: RH241.2 44.43,114.46 v2(43.98,114.92)
  TOP w0.508: RH241.2 45.18,113.53 LH2.1
+1.5V_RUNP: length 15.9
  TOP w0.254: v3(264.02,36.1) 263.91,36.21 254.42,36.21 v3(253.86,35.65)
  BOTTOM w0.254: PR402.1 264.47,32.5 PC402.1 264.75,32.47 265.21,32.93 265.21,34.91 v3(264.02,36.1)
  vias: v2(252.08,32.83)
+1.05VSP_B+: length 1.7
  BOTTOM w0.102: v2(17.86,135.2) 18.41,135.75 PC302.1
+1.35V_MEM: length 279.4
  TOP w0.254: JCPU1.T11 96.61,55.26 ; v1(96.12,66.75) 96.59,67.22 JCPU1.AH11 ; JCPU1.AB11 v1(97.12,61.75) ; JCPU1.N11 v1(96.12,52.75) ; JCPU1.K11 v1(96.12,49.75) ; JCPU1.AE11 v1(96.12,63.75)
  TOP w0.279: v1(97.12,58.75) JCPU1.W11 ; 96.61,55.26 v1(97.12,54.75)
  TOP w0.305: JCPU1.T5 v1(103.12,54.75) ; JCPU1.AB8 v1(99.12,61.75) ; JCPU1.AB5 v1(102.12,61.75) ; JDIMM3.118 160.75,53.06 v1(160.82,53.12) ; JCPU1.AB2 v1(106.12,61.75) ; JDIMM3.124 160.73,51.26 v1(160.82,51.34) ; JCPU1.T2 v1(106.12,54.75) ; JCPU1.AE2 v1(105.12,64.75) ; JCPU1.N8 v1(100.12,51.75) ; JCPU1.AE8 v1(99.12,64.75) ; JCPU1.W2 v1(105.12,57.75) ; JCPU1.W8 v1(99.12,57.75) ; JCPU1.T8 v1(100.12,54.75) ; JCPU1.AE5 v1(102.12,64.75) ; JCPU1.W5 v1(102.12,57.75)
  TOP w0.356: JDIMM3.75 151.19,65.95 149.98,65.95 149.7,66.23 149.7,66.59 149.32,66.97 v1(148.94,66.97) ; JDIMM1.100 144.79,58.45 144.36,58.02 v1(144.36,57.67) ; JDIMM1.88 147.12,62.05 147.78,62.72 v1(147.78,63.07) ; v1(160.82,60.36) 160.72,60.26 JDIMM3.94 ; JDIMM3.82 160.63,63.86 v1(160.82,64.04) ; JDIMM1.112 146.8,54.85 147.2,55.26 v1(147.2,55.89) 147.2,56.42 146.97,56.65 JDIMM1.106 ; v1(148.15,66.92) 146.88,65.65 JDIMM1.76 ; JDIMM1.118 146.8,53.05 147.17,52.68 v1(147.17,52.32) 147.17,51.53 146.9,51.25 JDIMM1.124 ; v1(147.19,63.07) 147.19,63.57 146.91,63.85 JDIMM1.82 ; v1(135.31,64.07) 135.4,64.15 JDIMM1.81 ; JDIMM3.99 149.13,58.76 v1(148.62,58.25) 147.66,59.22 147.66,59.42 146.83,60.25 JDIMM1.94 ; JDIMM3.117 150.16,53.36 149.26,52.46 v1(149.26,52.33) 150.03,51.56 JDIMM3.123 ; v1(160.82,54.9) 160.78,54.86 JDIMM3.112 ; JDIMM3.105 150.04,56.96 v1(149.82,57.19) ; JDIMM1.93 136.11,60.55 ; JDIMM3.93 150.08,60.56 148.45,62.19 v1(148.45,62.6) ; JDIMM1.75 136.14,65.95 ; v1(160.77,56.5) 160.61,56.66 JDIMM3.106 ; v1(160.82,65.82) 160.65,65.66 JDIMM3.76 ; JDIMM1.111 136.33,55.15 ; v1(149.03,62.6) 149.27,62.36 JDIMM3.87 ; 136.23,53.35 JDIMM1.117 ; JDIMM3.88 160.74,62.06 v1(160.82,62.14) ; v1(160.77,58.99) 160.77,58.79 160.44,58.46 JDIMM3.100 ; JDIMM1.123 136.31,51.55 ; JDIMM1.105 136.07,56.95 ; v1(149.77,55.71) 149.77,55.38 149.99,55.16 JDIMM3.111 ; JDIMM1.99 136.09,58.75 ; v1(148.29,63.99) 148.5,64.2 150.12,64.2 150.17,64.15 151.19,64.15 JDIMM3.81 ; JDIMM1.87 134.98,62.35
  TOP w0.508: RD47.1 129.4,48.19 v1(129.4,48.77) ; RD5.1 127.8,73.34 128.25,72.88 134.43,72.88 ; 134.43,72.88 134.43,66.79 ; 134.43,72.88 134.43,83.48 134.07,83.83 132.09,83.83 130.72,82.46 128.53,82.46 128.02,82.97 128.02,83.88 RD44.1
  IN1 w0.508: v3(189.9,56.42) 192.69,59.22 200.31,59.22 202.09,61 v3(202.09,64.32)
  IN4 w0.254: v1(105.12,64.75) 105.63,65.25 107.46,65.25 111.97,69.76 v1(111.97,78.67)
  BOTTOM w0.254: RC16.1 112.56,78.09 v1(111.97,78.67)
  BOTTOM w0.305: v1(160.82,53.12) 160.58,53.36 JDIMM4.117
  BOTTOM w0.356: v1(149.77,55.71) 149.77,55 149.91,54.86 JDIMM4.112 ; JDIMM2.94 136.07,60.25 ; 135.78,65.65 137.6,65.65 JDIMM2.76 ; v1(160.82,60.36) 160.62,60.56 JDIMM4.93 ; v1(148.94,66.97) 149.32,66.97 149.7,66.59 149.7,66.13 150.18,65.65 151.19,65.65 JDIMM4.76 ; v1(160.77,58.99) 160.54,58.76 JDIMM4.99 ; JDIMM2.87 145.8,62.35 146.81,62.35 147.19,62.74 v1(147.19,63.07) 147.19,63.95 146.99,64.15 145.8,64.15 JDIMM2.81 ; JDIMM2.106 136.15,56.65 ; v1(160.82,64.04) 160.7,64.16 JDIMM4.81 ; v1(144.36,57.67) 144.36,58.28 144.83,58.75 JDIMM2.99 ; JDIMM2.82 135.5,63.85 135.5,63.88 v1(135.31,64.07) ; JDIMM4.111 160.56,55.16 v1(160.82,54.9) ; 135.06,62.05 137.6,62.05 JDIMM2.88 ; JDIMM2.111 146.84,55.15 147.2,55.51 v1(147.2,55.89) 147.2,56.58 146.83,56.95 JDIMM2.105 ; 148.83,58.46 v1(148.62,58.25) ; 148.83,58.46 JDIMM4.100 ; 148.83,58.46 149.01,58.63 149.01,59.83 149.44,60.26 JDIMM4.94 ; v1(148.15,66.92) 147.18,65.95 145.8,65.95 JDIMM2.75 ; v1(160.82,62.14) 160.6,62.36 JDIMM4.87 ; v1(148.45,62.6) 148.45,62.34 148.73,62.06 JDIMM4.88 ; JDIMM4.124 150.1,51.26 149.26,52.11 v1(149.26,52.33) 149.26,52.36 149.96,53.06 JDIMM4.118 ; 136.06,58.45 JDIMM2.100 ; JDIMM2.93 147.04,60.55 147.78,61.3 v1(147.78,63.07) ; v1(160.77,56.5) 160.77,56.63 160.43,56.96 JDIMM4.105 ; 136.1,54.98 136.23,54.85 JDIMM2.112 ; v1(148.29,63.99) 148.5,64.2 148.73,64.2 148.75,64.22 149.82,64.22 150.19,63.85 151.19,63.85 JDIMM4.82 ; v1(160.82,65.82) 160.68,65.96 JDIMM4.75 ; v1(149.82,57.19) 149.82,56.86 150.02,56.66 JDIMM4.106 ; JDIMM2.123 145.8,51.55 146.93,51.55 147.17,51.8 v1(147.17,52.32) 147.23,52.37 147.23,52.87 146.74,53.35 145.8,53.35 JDIMM2.117 ; v1(160.82,51.34) 160.6,51.56 JDIMM4.123 ; JDIMM2.124 138.58,51.25 138.92,50.91 139.84,50.91 140.28,51.36 v1(140.28,51.45)
  BOTTOM w0.381: JDIMM2.118 139.02,53.05 139.3,52.77 140.22,52.77 140.4,52.94 v1(140.4,53.48)
  BOTTOM w0.508: RD49.1 179.99,92.54 180.55,93.1 182.99,93.1 186.22,89.88 186.22,86.89 v4(193.36,79.75) 195.03,78.08 196.54,78.08 200.92,73.69 200.92,72.71 203.21,70.42 203.21,65.44 v3(202.09,64.32)
  vias: v1(96.12,65.75) v1(96.12,64.75) v1(96.12,62.75) v1(96.12,61.75) v1(96.12,60.75) v1(96.12,59.75) v1(96.12,58.75) v1(96.12,57.75) v1(96.12,56.75) v1(96.12,55.75) v1(96.12,54.75) v1(96.12,53.75) v1(96.12,51.75) v1(96.12,50.75) v1(96.12,48.75) v1(133.56,57.69) v1(134.45,60.56) v1(134.7,64.07) v1(134.93,51.12) v1(135.06,60.56) v1(139.78,57.67) v1(139.86,69.25) v1(140.12,62.39) v1(140.25,60.1) v1(140.24,55.31) v1(140.39,49.72) v1(140.6,64.78) v1(141.19,67.08) v1(141.39,69.25) v1(141.64,62.39) v1(141.77,60.1) v1(141.77,55.33) v1(141.89,64.78) v1(141.94,53.48) v1(141.91,49.72) v1(142.07,57.67) v1(142.71,67.08) v1(142.91,69.25) v1(143.01,62.39) v1(143.3,60.1) v1(143.29,55.31) v1(143.42,64.78) v1(143.44,49.72) v1(144.43,69.25) v1(149.11,55.71) v1(152.84,58.23) v1(153.7,50.27) v1(153.75,68.65) v1(153.75,55.91) v1(153.84,53.85) v1(153.86,51.81) v1(153.97,62.49) v1(154.03,60.44) v1(154.11,64.58) v1(154.24,66.61) v1(155.13,58.23) v1(155.28,68.65) v1(155.27,55.91) v1(155.22,50.27) v1(155.36,53.85) v1(155.38,51.81) v1(155.46,66.61) v1(155.49,62.49) v1(155.55,60.44) v1(155.63,64.58) v1(156.68,66.61) v1(156.79,55.9) v1(156.8,68.65) v1(156.88,53.85) v1(156.91,51.81) v1(157.02,62.49) v1(157.07,60.44) v1(157.41,58.23) v1(162.06,55.89) v1(162.54,58.99) v3(88.93,51.01) v3(89.82,51.01) v3(89.82,47.79) v3(90.71,51.01) v3(90.71,47.79) v3(93.43,66.81) v3(93.43,64.91) v3(93.43,63) v3(93.43,61.1) v3(93.43,59.19) v3(93.43,57.29) v3(93.43,55.38) v3(93.43,53.48) v3(93.43,51.57) v3(93.43,49.67) v3(93.43,47.76) v3(162.44,67.98) v3(162.44,67.35) v3(162.85,46.39) v3(162.85,45.76) v3(162.98,66.33) v3(162.98,65.53) v3(162.98,63.92) v3(162.98,62.65) v3(162.98,61.5) v3(162.98,60.49) v3(162.98,59.85) v3(162.98,55.79) v3(162.98,55.15) v3(162.98,53.63) v3(162.98,52.49) v3(163.08,67.98) v3(163.08,67.35) v3(163.48,46.39) v3(163.48,45.76) v3(163.71,67.98) v3(163.71,67.35) v3(164.12,46.39) v3(164.12,45.76) v3(181.64,56.42) v3(181.64,55.79) v3(181.64,55.15) v3(181.64,54.52) v3(182.28,56.42) v3(182.28,55.79) v3(182.28,55.15) v3(182.28,54.52) v3(182.91,56.42) v3(182.91,55.79) v3(182.91,55.15) v3(182.91,54.52) v3(183.55,56.42) v3(183.55,55.79) v3(183.55,55.15) v3(183.55,54.52) v3(184.18,56.42) v3(184.18,55.79) v3(184.18,55.15) v3(184.18,54.52) v3(184.82,56.42) v3(184.82,55.79) v3(184.82,55.15) v3(187.36,56.42) v3(187.36,55.79) v3(187.99,56.42) v3(187.99,55.79) v3(188.63,56.42) v3(188.63,55.79) v3(189.26,56.42) v3(189.26,55.79) v3(189.9,55.79)
+1.35V_MEN_P: length 76.4
  TOP w0.254: v3(192.9,60.41) 174.74,60.41 174.07,61.07 174.07,71.21 174.81,71.94 v1(174.81,77.35)
  IN1 w0.254: v3(176.54,78.42) 176.54,72.35 174.61,70.42 174.61,61.63 175.17,61.07 v3(192.9,61.07)
  BOTTOM w0.203: v3(176.54,78.42) 176.34,78.22 PU200.5 ; PC211.2 172.75,77.68 172.7,77.63 PC214.1 172.88,77.13 173.26,77.51 174.1,77.51 PR204.1
  BOTTOM w0.254: v1(174.81,77.35) 174.61,77.56 PR204.1
  vias: v2(175.94,59.1)
+3.3V_ALW: length 664
  TOP w0.254: R817.1 109.06,151.23 110.14,150.15 110.14,146.7 v3(110.83,146.01) ; RP5.2 102.14,166.61 v1(102.38,166.85) 102.64,166.6 RP5.1 ; RP5.4 101.14,166.52 v1(101.56,166.94) 101.64,166.86 RP5.3
  TOP w0.305: v1(85.42,27.99) 85.42,28.01 85.49,28.09 85.49,29.02 JAPS1.7
  TOP w0.356: C723.1 15.8,111 JIO1.2
  TOP w0.381: U7.5 143.18,142.43 143.03,142.57 R1630.2
  TOP w0.508: R932.1 11.26,148.6 v1(11.46,148.4) ; 109.57,116.42 107.98,116.42 107.07,117.33 107.07,120.05 105.47,121.65 105.47,125.22 104.92,125.77 R755.1 104.92,126.64 105.62,127.34 105.62,128.74 106.21,129.32 106.21,131.28 110.97,136.04 v3(110.97,137.73) ; 109.57,116.42 109.66,116.51 R784.2 ; 109.57,116.42 109.98,116.42 115.45,110.95 115.45,110.09 v3(115.55,109.99) ; R759.1 98.23,153.35 v1(97.42,153.35) ; v3(5.27,89.77) 4.63,89.77 2.73,87.87 PR8.2 ; C723.1 17.79,111.11 v3(17.86,111.03) ; R937.1 v1(13.83,144.05) ; R855.1 R814.1 97.49,156.88 v1(97.14,157.24) ; R841.1 112.33,161.83 v1(112.76,161.4) 112.76,161.38 112.33,160.95 R838.1 ; R840.1 v1(112.76,158.66) R872.1 ; JKB1.8 JKB1.7 182.46,112.5 C756.1 v1(183.17,112.51) ; v3(46.69,15.3) 44.56,15.3 43.44,16.42 43.44,25.08 41.02,27.51 40.45,27.51 40.17,27.79 R515.1 ; v3(173.34,54.67) 174.07,53.93 174.07,45.83 175.14,44.77 175.14,43.19 174.95,43 174.95,35.28 173.19,33.51 v3(173.19,26.91) ; v1(112.81,156.25) 112.81,156.22 112.33,155.74 R875.1 ; v3(30.53,140.47) 28.47,142.53 26.2,142.53 25.57,141.91 23.09,141.91 22.39,141.21 20.58,141.21 18.2,143.6 v1(18.2,145.65) ; R396.1 v1(161.27,136.23) ; R839.1 v1(112.73,159.55) ; v1(140.5,142.53) 140.53,142.57 C289.1 R1630.2 ; v1(229.52,64.12) 229.52,60.65 v1(229.65,60.51) 235.01,60.51 236.89,62.4 v1(236.89,64.43)
  IN1 w0.254: v1(21.55,97.38) 23.08,97.38 23.5,97.8 23.5,98.56 23.63,98.69 23.63,99.22 23.91,99.5 24.21,99.5 24.75,100.04 24.75,102.55 24.01,103.29 21.09,103.29 v1(20.48,103.9)
  IN1 w0.508: v3(17.86,111.03) 17.7,111.03 15.84,109.17 15.84,107.19 13.68,105.03 13.68,100.85 15.24,99.29 15.24,98.49 14.77,98.03 14.57,98.03 ; v1(85.42,27.99) 85.42,28.28 85.84,28.7 95.38,28.7 96.39,27.7 104.82,27.7 108.05,24.47 132.52,24.47 133.26,23.73 171.22,23.73 173.19,25.69 v3(173.19,26.91) ; v3(14.61,96.86) 14.69,96.86 14.91,97.09 14.91,97.68 14.57,98.03 ; v1(40.7,136.69) 40.7,140.24 v1(40.75,140.29) ; 14.57,98.03 13.92,98.03 13.03,97.14 13.03,92.13 12.68,91.78 12.68,88.78 12,88.1 8.62,88.1 7.35,89.37 5.67,89.37 v3(5.27,89.77)
  IN2 w0.508: v3(185.73,84.64) 184.77,83.68 180.55,83.68 v1(179.89,83.02) ; v1(154.85,144.41) 155.28,144.84 155.28,146.9 v1(155.08,147.1) ; v3(53.04,15.04) 58.42,15.04 61.1,17.71 65.59,17.71 67.22,19.34 67.22,20.36 69.25,22.39 70.62,22.39 72.6,24.37 72.6,25.59 75.56,28.55 84.86,28.55 v1(85.42,27.99) ; v1(140.5,142.53) 139.84,141.87 139.84,140.22 144.88,135.18 v1(144.88,123.92)
  IN2 w1.016: 83.88,135.76 83.88,134.96 82.81,133.89 73.77,133.89 62.01,122.13 62.01,118.33 56.04,112.36 56.04,111.34
  IN3 w0.508: v1(151.88,155.23) 151.88,151.9 v1(152.59,151.19) 153.37,151.19 153.91,150.66 153.91,149.59 155.08,148.42 v1(155.08,147.1) ; v1(21.55,97.38) 19.64,97.38 19.57,97.31 18.44,97.31 18.06,96.92 14.68,96.92 v3(14.61,96.86) ; v1(120.25,103.52) 117.26,106.51 117.26,108.76 117.94,109.45 119.66,109.45 119.95,109.74 v1(119.95,110.34) 119.64,110.64 116.2,110.64 v3(115.55,109.99)
  IN4 w0.508: v1(179.89,83.02) 171.43,83.02 170.57,82.15 170.57,79.79 v3(170.54,79.77) 170.54,77.86 171.38,77.02 171.38,64.81 173.39,62.8 173.39,56.17 173.95,55.61 173.95,54.98 173.64,54.67 v3(173.34,54.67) ; v1(229.52,64.12) 229.52,65.18 230.54,66.2 230.54,67.6 232.44,69.51 v3(232.44,70.65)
  BOTTOM w0.102: v4(39.79,141.22) 40.71,140.29 v1(40.75,140.29)
  BOTTOM w0.254: U51.A58 104.5,162.3 104.45,162.34 104.45,163.29 104.68,163.52 C757.1 105.22,164.83 105.22,165.59 104.73,166.08 C736.1 105.22,166.61 105.22,167.52 104.89,167.85 ; v1(20.48,103.9) 20.71,103.67 RH240.1 ; v1(168.31,83.37) 168.84,83.91 PR222.1 ; PR216.1 v3(170.54,79.77)
  BOTTOM w0.279: U51.A22 105,148.99 C739.1
  BOTTOM w0.381: PU1080.5 154.42,147.99 PC1080.2 ; C90.1 81.13,102.14 U16.5 ; 121.42,101.79 122.07,101.14 U17.5 ; v1(236.89,64.43) 236.89,63.76 PU704.5 ; U58.5 16.97,151.2 16.93,151.15 ; v1(97.42,153.35) 97.06,153.35 96.45,152.74 R1980.1 ; R19.1 220.3,88.26 221.67,89.63 221.67,90.08 v1(222.03,90.43) 222.03,90.71 221.78,90.97 R805.1 ; U54.5 40.05,137.26 C726.1 ; U50.5 93.74,147.93 93.89,148.07 ; PR1083.1 152.26,150.66 152.59,150.99 v1(152.59,151.19) ; PU1081.5 152.07,154.4 PC1081.2
  BOTTOM w0.508: v3(115.55,109.99) 115.32,109.99 114.89,109.56 114.89,109.54 113.67,108.32 100.44,108.32 98.59,106.46 98.59,106.08 97.06,104.56 91.73,104.56 88.6,101.43 R11.1 88.86,101 89.54,101 90.53,100.01 90.53,97.77 87.01,94.24 84.34,94.24 v4(82.44,96.14) 81.29,97.29 79.94,97.29 79.21,98.03 79.21,100.21 C90.1 ; v3(30.53,140.47) 30.39,140.61 PR21.1 ; PR764.1 PR757.1 173.31,54.65 v3(173.34,54.67) ; PR749.1 v1(229.65,60.51) ; PR300.2 18.8,146.26 v1(18.2,145.65) ; v1(94.09,149.57) 94.09,148.27 93.89,148.07 ; R1125.1 110.83,163.76 109.48,162.42 v1(109.48,162.16) ; R709.1 42.63,152.69 43.47,152.69 43.79,152.37 U62.5 v1(44.53,153.05) ; R871.1 v1(112.81,156.25) R854.1 ; v3(53.04,15.04) 53.04,14.82 52.43,14.21 47.79,14.21 v3(46.69,15.3) 47,15.3 47.38,15.68 47.38,16.97 47.38,17.77 47.38,26.73 45.36,28.75 v1(45.36,30.4) ; R798.1 v1(208.31,85.51) ; PR221.1 v1(163.36,82.83) ; v1(13.83,144.05) 12.66,142.89 12.66,135.62 17.22,131.06 17.22,126.85 16.75,126.38 v4(16.75,125.61) 16.75,118.78 18.68,116.85 18.68,111.82 17.89,111.03 v3(17.86,111.03) ; RH238.1 21.43,97.5 v1(21.55,97.38) ; PR209.1 180.25,82.64 179.94,82.94 179.94,82.97 v1(179.89,83.02) ; R938.1 v1(13.75,147.23) ; PC733.2 v1(229.52,64.12) ; C739.1 C1349.1 104.89,147.33 v1(104.78,147.23) ; PR1025.2 v1(144.88,123.92) ; 121.42,101.79 120.25,102.96 v1(120.25,103.52) ; v1(40.7,136.69) 40.19,137.2 C726.1 ; v1(16.38,150.28) 16.47,150.28 16.93,150.73 16.93,151.15 ; PR2.1 v3(173.19,26.91) ; R1981.1 v1(104,167.85) 104.89,167.85 ; PR119.2 v1(251.77,61.67) ; PR213.1 v1(162.7,79.09) ; v1(155.08,147.1) PC1080.2 ; v1(151.88,155.23) PC1081.2 ; R768.1 v1(213.39,90.38)
  vias: v1(44.53,153.66) v1(56.79,110.89) v1(57.01,111.73) v1(85.52,135.34) v1(85.86,135.86) v1(85.81,134.74) v1(92.17,139.81) v1(92.32,139.24) v1(92.72,140.16) v1(92.82,139.57) v1(93.37,139.79) v1(108.29,168.69) v1(108.87,168.69) v1(110.83,138.34) v1(125.48,166.93) v1(126.07,166.93) v1(126.4,163.57) v1(126.64,164.12) v1(175.32,120.69) v1(175.32,120.05) v1(175.32,119.42) v1(226.96,83.93) v3(56.83,108.33) v3(110.35,145.37) v3(110.98,145.37) v3(111.46,138.31) v3(111.64,145.37) v3(206.97,77.86) v3(207.53,77.56) v3(223.86,70.13) v3(256.57,26.07) v3(257.21,26.07) v3(257.84,26.07) v3(258.48,26.07) v3(266.23,54.39) v3(266.23,53.76) v3(266.23,53.12) v3(266.23,52.49) v3(266.23,49.06) v3(266.23,48.42) v3(266.23,47.79) v3(266.23,47.15) v3(266.86,54.39) v3(266.86,53.76) v3(266.86,53.12) v3(266.86,52.49) v3(266.86,49.06) v3(266.86,48.42) v3(266.86,47.79) v3(266.86,47.15)
+3.3V_ALW2: length 424.5
  TOP w0.381: 12.99,130.8 12.89,130.69 11.06,130.69 10.56,131.19 UH2.5
  TOP w0.508: v1(245.4,63.23) 243.8,61.63 242.45,61.63 237.32,66.76 v1(231.34,66.76) ; 12.99,130.8 12.91,130.87 v1(12.91,131.79) ; R909.1 53.2,135.14 52.85,134.79 49.44,134.79 47.81,136.42 47.81,138.15 47.47,138.49 45.68,138.49 45.27,138.09 45.27,135.57 45.73,135.11 v1(45.73,134.86)
  IN1 w0.508: v1(213.75,55.2) 213.75,58.63 v1(212.91,59.47) ; v1(231.34,66.76) 230.73,67.37 226.64,67.37 225.11,68.9 219.74,68.9 219.24,69.4 204.51,69.4 195.57,78.34 189.57,78.34 189.06,77.84 187.16,77.84 186.65,78.34 183.63,78.34 180.91,81.06 176.87,81.06 v1(168.36,89.57) ; v1(125.1,156.35) 123.15,158.3 122.39,158.3 120.05,160.64 120.05,163.7 118.03,165.72 116.56,165.72 116.18,166.1 113.8,166.1 109.99,169.91 107.96,169.91 v1(107.25,169.2)
  IN2 w0.508: v1(45.73,134.86) 45.73,134.55 46.2,134.08 66.06,134.08 69.6,137.63 69.6,153.02 69.05,153.58 v1(69.05,155.15) ; v1(147.56,114.01) 153.75,114.01 154.75,115 154.75,121.42 155.48,122.16 155.48,129.17 143.04,141.62 143.04,142.34 138.5,146.87 133.31,146.87 126.75,153.43 126.45,153.43 125.28,154.6 125.28,156.17 v1(125.1,156.35)
  IN3 w0.508: v1(30.51,135.9) 30.03,135.9 28.51,134.38 28.51,133.07 22.67,127.24 19.36,127.24 16.24,130.36 16.24,132.12 15.22,133.13 14.26,133.13 v1(12.91,131.79) ; v1(152.13,111.95) 150.07,114.01 v1(147.56,114.01) ; v1(74.38,162.02) 74.38,162.7 75.47,163.79 89.08,163.79 89.55,164.26 100.96,164.26 103.08,166.38 105.41,166.38 107.25,168.22 v1(107.25,169.2)
  IN4 w0.508: v1(231.34,66.76) 231.35,66.75 231.35,60.34 230.3,59.28 v1(229.66,59.28) 229.19,59.75 221.75,59.75 220.96,58.96 215.93,58.96 213.75,56.78 v1(213.75,55.2)
  BOTTOM w0.203: PU101.3 246.58,61.92 247.04,62.38 PC114.2
  BOTTOM w0.381: PC114.2 246.58,62.63 246.46,62.75 PR103.1 245.83,62.75 245.4,63.18 v1(245.4,63.23)
  BOTTOM w0.508: v1(45.73,134.86) 45.73,134.58 45.4,134.25 43.9,134.25 43.6,134.55 40.34,134.55 37.91,132.12 33.05,132.12 32.29,132.88 32.29,134.55 30.94,135.9 v1(30.51,135.9) ; v1(69.05,155.15) 74.38,160.49 v1(74.38,162.02) ; R2192.1 v1(212.91,59.47) ; v1(229.66,59.28) 228.67,58.29 228.67,57.52 228.2,57.05 PR737.1 ; PR741.1 v1(213.75,55.2) ; v1(168.36,89.57) 170.26,89.57 170.75,90.05 170.75,93.25 165.39,98.61 159.98,98.61 158.91,97.55 155.82,97.55 155.02,98.35 155.02,101 154.34,101.69 PR1100.1 154.34,103.11 153.78,103.67 PQ1072.3 153.74,104.47 152.45,104.47 151.81,105.1 151.81,108.89 152.13,109.21 v4(152.13,109.33) v1(152.13,111.95) 151.8,111.95 151.21,112.53 PR1013.1 ; PR1022.1 v1(147.56,114.01) ; PR1073.1 v1(231.34,66.76) ; v1(107.25,169.2) 107.25,169.3 106.51,170.04 R874.2
+3.3V_ALW_PCH: length 504.8
  TOP w0.152: v1(31.15,98.96) 31.15,98.07 UH1.R20
  TOP w0.203: v1(21.88,100.77) 21.88,100.2 22.09,99.99 22.5,99.99 22.53,100.01 23.68,100.01 23.7,100.02 24.34,100.02 UH1.A26
  TOP w0.254: v1(18.37,99.93) 18.45,99.86 18.75,99.86 RH35.1 ; v1(27.09,83.53) 26.88,83.32 26.88,82.59 RH130.1 ; v1(31.15,100.58) 31.15,100.66 UH1.R28 ; v1(31.15,100.58) 31.48,100.25 UH1.U26 31.48,100.07 v1(31.81,99.74) 31.2,99.74 UH1.R24 ; v1(31.15,100.58) 31.15,100.51 UH1.R26 ; v1(31.15,98.96) 30.82,98.63 UH1.R22 ; v3(53.36,103.96) 55.63,101.69 55.63,100.41 54.84,99.61 54.84,99.37 53.85,98.38 52.82,98.38 51.01,96.58 RH128.2
  TOP w0.279: JXDP2.43 21.8,121.27 v1(21.85,121.22) ; JXDP2.44 21.8,118.64 21.7,118.74 v1(21.7,118.79)
  TOP w0.305: 82.48,27.93 JAPS1.1 ; UH1.AJ32 35.77,102.29 v1(35.77,102.21) 35.77,102.13 UH1.AJ30
  TOP w0.457: RH125.2 v1(29.5,83.55) ; RH129.1 v1(24.67,83.55) ; v1(31.71,81.39) 31.78,81.47 RH123.2 RH52.1 ; RH210.2 v1(30.77,83.55)
  TOP w0.508: R796.1 41.06,28.37 44.08,25.34 44.08,17.3 45.35,16.03 v1(46.67,16.03) ; R808.1 111.06,117.13 117.72,117.13 122.26,112.6 v1(129.35,112.6) ; v3(61.86,94.35) 61.86,93.46 62.39,92.92 63.53,92.92 64.07,93.46 72.36,93.46 73.86,94.96 83.47,94.96 85.02,93.41 85.02,90.52 87.98,87.56 96.65,87.56 98.81,89.72 104.03,89.72 109.47,84.29 115.2,84.29 v3(116.82,82.66) ; RH247.1 v1(28.48,83.55) ; R1622.2 138.24,139.88 133.59,135.23 133.59,134.85 v1(133.61,134.82) ; RH75.1 20.99,81.75 v1(21.34,81.39) ; RH249.1 v1(24.67,83.55) ; v1(89.68,26.85) 89.43,26.85 85.4,22.82 84.4,22.82 83.5,23.72 83.5,24.97 82.48,25.99 82.48,27.93 ; RH124.2 v1(35.85,83.55) ; v1(29.5,83.55) RH145.2 ; RH144.2 v1(30.77,83.55)
  IN1 w0.254: v1(18.37,99.93) 18.42,99.99 18.42,100.34 19.08,101 21.65,101 v1(21.88,100.77)
  IN1 w0.508: v1(21.7,118.79) 21.87,118.63 22.51,118.63 22.87,118.98 22.87,120.2 v1(21.85,121.22) 24.47,121.22 25.61,120.08 26.91,120.08 v1(27.44,120.61) ; v1(129.37,102.36) 129.56,102.55 129.56,112.38 v1(129.35,112.6) 129.35,115.52 125.01,119.86 125.01,127.43 131.47,133.89 132.69,133.89 v1(133.61,134.82)
  IN2 w0.254: v1(35.77,102.21) 35.77,101.85 35.21,101.29 32.15,101.29 31.85,100.99 31.85,100.56 31.16,99.87 31.16,98.97 v1(31.15,98.96)
  IN2 w0.508: 42.83,102.14 49.51,102.14 51.33,103.96 v3(53.36,103.96) 53.87,104.47 62.07,104.47 v3(63.74,102.8) ; v1(27.44,120.61) 27.44,119.44 23.56,115.56 23.17,115.56 21.98,114.36 21.98,111.71 20.07,109.81 20.07,107.27 18.7,105.9 18.7,102.91 20.18,101.43 20.18,101.13
  IN3 w0.508: v1(34.71,83.55) 33.69,84.57 v1(33.69,85.68) v1(32.8,85.68) ; v1(46.67,16.03) 46.96,16.03 50.35,12.63 54.35,12.63 59.43,7.55 68.79,7.55 69.91,8.67 69.91,10.79 70.58,11.47 73.61,11.47 74.33,12.19 74.33,13.73 v1(74.13,13.93) 74.93,13.93 75.48,14.49 75.48,19.33 83,26.85 v1(89.68,26.85) ; v1(129.37,102.36) 129.37,97.37 126.3,94.3 126.3,93.72 v3(125.34,92.77)
  IN4 w0.508: v1(33.69,85.68) 35.64,85.68 36.13,85.2 39.93,85.2 43.16,88.43 45.99,88.43 48.35,90.79 51.75,90.79 53.31,92.35 59.86,92.35 v3(61.86,94.35) ; v3(125.34,92.77) 124.99,92.42 122.54,92.42 121.37,93.58 118.8,93.58 116.82,91.6 v3(116.82,82.66) 116.82,71.08 113.45,67.71 113.45,42.97 106.86,36.38 96.18,36.38 93.09,33.29 93.09,30.25 v1(89.68,26.85)
  BOTTOM w0.254: v1(35.77,102.21) 36.15,101.82 CH45.1 ; RC124.1 74.23,13.09 74.23,13.83 v1(74.13,13.93) ; v1(27.44,120.61) 27.09,120.97 RH248.1
  BOTTOM w0.381: RH84.1 28.86,83.93 v1(28.48,83.55) ; CH51.1 30.49,98.21 31.15,98.86 v1(31.15,98.96) ; v1(31.71,81.39) 31.34,81.76 RH46.1
  BOTTOM w0.457: v1(30.77,83.55) 31.34,82.98 RH46.1
  BOTTOM w0.508: RH212.2 v1(32.8,85.68) ; RH60.1 21.88,100.42 v1(21.88,100.77) ; CH2.1 21.48,118.58 v1(21.7,118.79) ; RH166.1 RH249.1 v1(24.67,83.55) ; CH43.1 31.15,100.58 v1(31.15,100.58) ; CH43.1 31.69,99.86 v1(31.81,99.74) ; CH43.1 31.15,98.96 v1(31.15,98.96) ; RH213.2 v1(33.69,85.68) ; RH124.2 v1(35.85,83.55) ; v1(29.5,83.55) 29.75,83.81 RH246.1 ; v3(61.86,94.35) 61.86,94.6 62.21,94.96 64.98,94.96 68.78,98.76 v4(68.78,101.23) 68.78,101.55 66.89,103.44 64.37,103.44 v3(63.74,102.8) ; v1(30.77,83.55) RH144.2 ; RH211.1 v1(34.71,83.55)
+3.3V_ALW_PCH_JTAG: length 5.9
  TOP w0.508: v1(32.83,80.86) 33.49,80.2 34.15,80.2 v2(34.71,80.76) RH50.1 RH48.1
  BOTTOM w0.508: RH46.2 32.74,80.95 v1(32.83,80.86)
+3.3V_ALW_PCH_U34: length 1.8
  BOTTOM w0.102: v2(56.12,105.92) 55.09,105.92 54.94,106.07 PJP4.2
+3.3V_ALW_U46: length 30.6
  TOP w0.254: 213.67,82.05 213.28,82.44 213.28,83.41 213.48,83.41 213.75,83.14 214.44,83.14 214.87,82.71 v1(214.87,82.54) 214.87,82.39 214.54,82.05 213.67,82.05
  TOP w0.508: v1(212.63,88.11) 212.63,84.05 213.27,83.41 213.28,83.41
  IN2 w0.508: v1(212.63,88.11) 212.63,88.43 213.65,89.44 217.73,89.44 218.8,88.37 v1(218.8,88.11)
  BOTTOM w0.254: C719.1 225.99,80.68 225.51,81.16 225.51,81.24 224.42,82.33 223.97,82.33 223.78,82.52 U46.A54
  BOTTOM w0.279: C709.1 219.33,88.54 219.33,87.33 219.17,87.17 U46.A43 ; U46.A17 212.22,77.52 212.1,77.4 v2(211.27,77.4) C710.1
  BOTTOM w0.305: v1(214.87,82.54) 214.87,82.73 214.33,83.27 U46.B30
  BOTTOM w0.318: v1(219.92,77.37) U46.B5
  BOTTOM w0.508: v1(226.04,80) 226.02,80.02 C719.1 ; v1(210.08,76.77) C710.1 ; v1(218.8,88.11) 218.8,88.43 219.06,88.69 C709.1
  vias: v1(208.44,75.96)
+3.3V_ALW_VTR: length 59.3
  TOP w0.457: C1355.1 108.26,159.5 v1(107.64,159.5)
  TOP w0.508: v1(102.32,148.83) 101.86,148.37 v2(99.61,148.37) v3(97.57,148.37)
  IN2 w0.508: v1(110.78,154.25) 110.78,154.28 108.78,156.27 108.78,158.35 v1(107.64,159.5)
  BOTTOM w0.254: C1348.1 103.03,149.29 102.75,149.57 102.75,150.53 103,150.78 U51.A26 ; C780.1 101.37,164.18 101.37,162.52 101.5,162.39 U51.A52
  BOTTOM w0.279: U51.A11 111.17,155.27 C1345.1 ; U51.A41 97.74,156.77 97.7,156.73 96.73,156.73 96.5,156.5 C781.1
  BOTTOM w0.305: C777.1 98.18,151.8 98.9,152.52 U51.B35 ; v1(107.64,159.5) 108.32,159.5 U51.B3
  BOTTOM w0.508: v1(102.32,148.83) C1348.1 ; C780.1 100.57,164.3 99.68,165.19 99.68,168.31 102.12,170.75 110.37,170.75 110.78,170.34 110.78,169.84 ; v1(110.78,154.25) 111.21,154.68 C1345.1 ; 96.38,149.44 C777.1 ; v1(96,157.5) C781.1
  BOTTOM w1.016: 111.46,169.12 112.84,169.12 113.7,168.26 113.7,166.66 114.56,165.8 v3(114.56,161.3) v3(113.67,161.3)
+3.3V_LAN: length 230.8
  TOP w0.381: C478.1 129,146.61 U15.5
  TOP w0.457: v1(131.02,141.21) 131.02,140.63 C472.1
  TOP w0.508: v1(129.7,146.67) C478.1 ; v1(127.93,141.22) 127.92,141.21 C473.1 ; C474.1 128.94,136.33 v1(128.61,136) ; v3(26.88,81.27) 26.73,81.11 26.73,80.55 29.71,77.57 31.7,77.57 31.95,77.82 31.95,78.48 32.29,78.83 38.03,78.83 38.29,78.57 39.17,78.57 41.03,76.72 45.93,76.72 46.77,77.56 48.42,77.56 49.61,76.36 53.12,76.36 55.22,78.47 59.02,78.47 59.05,78.45 62.95,78.45 68.41,83.91 74.95,83.91 75.33,83.53 79.82,83.53 83.22,86.93 v3(83.22,93)
  IN1 w0.254: v1(150.02,166.15) 154.62,166.15 157.06,163.71 159.79,163.71 JLOM1.12 ; v1(150.02,165.26) 152.36,162.93 153.12,162.93 155.61,160.44 155.61,154.09 156.82,152.88 156.82,149.96 158.02,148.75 175.29,148.75 175.8,149.26 175.8,159.66 JLOM1.9
  IN1 w1.016: v1(150.02,166.15) v1(150.02,165.26)
  BOTTOM w0.203: U32.4 v1(125.93,141.21) ; U32.1 v1(124.43,141.21) ; v1(131.02,141.21) 130.93,141.12 U32.14 ; U32.8 v1(127.93,141.22)
  BOTTOM w0.254: U32.21 133.68,137.84 v1(133.79,137.73) ; U32.30 128.43,136.26 128.61,136.08 v1(128.61,136) ; RH174.1 29.04,81.44 29.04,80.55 28.85,80.35 27.85,80.35 27.82,80.33 27.14,80.33 26.83,80.63 26.83,81.21 v3(26.88,81.27) ; v1(122.94,137.65) 123.13,137.84 U32.39
  BOTTOM w0.508: R553.1 v1(124.24,159.04) ; v3(26.88,81.27) 27.34,81.72 RH175.1 ; R554.1 119.15,156.87 v1(119.15,157.83) ; v1(122.41,159.98) 121.57,159.14 R549.1 ; v3(83.22,93) 83.75,93.53 87.19,93.53 99.09,105.43 v4(104.52,105.43) 110,105.43 110.52,105.95 110.52,106.46 111.74,107.68 114.79,107.68 116.19,109.08 116.19,111.67 121.73,117.21 121.73,130.74 123.33,132.34 123.33,137.13 v3(123.48,137.28)
  vias: v1(119.41,159.6) v1(119.44,159.01)
+3.3V_LAN_OUT: length 6.3
  TOP w0.102: v1(126.2,150.84) v2(126.84,150.84)
  TOP w0.457: C464.1 123.35,147.84 v1(122.74,147.23)
  TOP w0.508: v1(121.57,154.95) v1(121.57,155.56) 120.94,156.2 R209.1
  BOTTOM w0.203: v1(126.52,152.53) 126.51,152.53 125.99,152.53 125.89,152.44 U31.15 ; v1(122.74,147.23) 122.74,147.38 122.94,147.58 U31.29 ; U31.19 v1(126.2,150.84)
+3.3V_LAN_U63:
  vias: v2(122.82,163.05)
+3.3V_M: length 389.3
  TOP w0.203: UH1.AD12 34.48,94.7 v1(34.71,94.47)
  TOP w0.305: v1(53.61,90.25) 53.89,89.97 JSPI1.16
  TOP w0.508: v1(167.98,126.73) 167.34,127.37 R818.1 ; v3(116.67,162.09) v2(116.67,156.47) 116.67,148.27 116.47,148.07 116.47,146.56 115.83,145.92 113.66,145.92 111.11,143.37 106.54,143.37 105.11,144.79 103.7,144.79 102.69,143.77 96.21,143.77 94.5,145.49 94.5,147.97 R893.1 ; R426.1 v1(161.5,137.7) ; v1(53.61,90.25) 52.62,90.25 51.57,91.3 49.74,91.3 49.23,91.81 49.23,94.19 50.28,95.23 50.28,96.89 50.73,97.34 50.73,97.8 v3(50.58,97.95) ; R402.1 v1(162.95,133.26) ; R392.1 v1(169.33,140.24)
  IN2 w0.254: 42.48,98.84 42.71,98.61 42.71,97.95 42.58,97.83 37.83,97.83 37.7,97.95 36.69,97.95 37.58,98.84 42.48,98.84
  IN2 w0.508: v1(161.5,137.7) 161.5,136.89 162.07,136.32 162.07,136.04 163.1,135.01 163.1,133.41 v1(162.95,133.26) 161.51,131.82 161.36,131.82 160.13,130.59 157.49,130.59 156.37,131.71 156.37,134.78 148.26,142.89 148.26,144.63 142.86,150.02 137.65,150.02 135.77,151.9 134.45,151.9 133.46,152.89 130.26,152.89 128.2,154.96 126.57,154.96 126.48,155.05 126.48,156.68 125.18,157.97 123.07,157.97 120.91,160.14 120.91,160.56 119.58,161.88 118,161.88 116.91,162.98 v3(116.67,162.98) ; v1(34.71,94.47) 34.71,95.08 35.73,96.1 35.73,97.56 36.12,97.95 36.69,97.95 ; v3(50.05,97.6) 49.55,98.1 42.71,98.1
  IN2 w1.016: 124,114.18 121.71,114.18 120.24,112.71 92.97,112.71 91.65,111.39 86.42,111.39 85.76,110.73 73.67,110.73 73.31,111.08 v3(72.55,111.08) v3(71.66,111.08) ; 167.15,125.78 167.15,123.49 160.44,116.77 158.07,116.77 157.39,116.09 157.39,114.49 155.28,112.38 155.28,111.58 154.12,110.42 142.66,110.42 140.91,112.18 131.03,112.18 129.03,114.18 127,114.18 126.95,114.23
  IN4 w1.016: v3(154.67,158.79) v3(154.67,157.31) 154.67,153.63 155.86,152.44 155.86,148.75 158.02,146.59 170.72,146.59 172.54,144.78 172.54,142.57 171.74,141.77 171.74,140.5
  BOTTOM w0.254: v1(34.71,94.47) 34.91,94.47 35.21,94.17 35.21,91.55 CH59.1
  BOTTOM w0.508: RH185.1 53.01,91.17 53.27,90.9 53.36,90.9 53.61,90.66 v1(53.61,90.25)
  BOTTOM w1.016: v3(154.67,157.31) v3(154.67,158.79) 152.94,158.79 150.66,161.07 150.66,162.95 142.15,171.46 122.77,171.46 116.67,165.36 v3(116.67,162.98) v3(116.67,162.09) ; 50.55,99.07 50.55,102.56 50.14,102.98 50.14,108.77 50.45,109.09 50.45,112.81 51.33,113.69 51.96,113.69 52.83,114.56 69.4,114.56 71.54,112.43
  vias: v1(125.19,114.37) v1(125.78,114.37) v1(167.99,125.99) v1(169.96,140.37) v1(170.6,140.37)
