# Allegro board LA-9771PR10-0624.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N16763050: length 6.8
  BOTTOM w0.102: v2(216.19,53.69) 216.78,54.29 PC731.1
  BOTTOM w0.254: PU703.5 217.44,54.52 PC731.1 217.87,53.63 219.11,53.63 219.41,53.33 PR743.2 PR740.1
N16763106: length 15.7
  TOP w0.254: v1(228.51,54.9) 228.08,55.33 228.08,56.83 227.08,57.82 225.79,57.82 223.68,59.93 v1(223.68,61)
  BOTTOM w0.102: v2(222.68,61.29) 222.97,61 v1(223.68,61)
  BOTTOM w0.254: v1(223.68,61) 223.68,60.18 PR734.1 ; 224.06,55.79 224.57,55.79 225.54,54.82 PC729.1 PR744.1 PR736.2 228.43,54.82 v1(228.51,54.9)
N16763148: length 7.5
  BOTTOM w0.102: v2(222.75,59.59) 222.75,58.01 223.71,57.06 PU703.2
  BOTTOM w0.254: PU703.2 224.7,57.06 225.6,57.96 PR745.1 PC730.1 PR737.2
N16763200: length 5.7
  BOTTOM w0.102: PR741.2 v2(213.31,56.12)
  BOTTOM w0.254: PR741.2 PR747.1 PR748.1 PC732.1 217.53,55.79 218.9,55.79
N16790095: length 3.6
  TOP w0.102: T59.1 22.34,100.29 24.16,100.29 24.49,100.62 24.77,100.62 25.08,100.32 UH1.C26
N16807572: length 1.7
  TOP w0.102: v1(42.27,90.77) 41.94,90.45 UH1.BB2
  BOTTOM w0.089: 42.73,90.71 42.74,90.7 T58.1
  BOTTOM w0.102: 42.73,90.71 42.33,90.71 v1(42.27,90.77)
N16845401: length 1.2
  TOP w0.102: UH1.AW17 40.44,96.55 v1(40.44,96.28)
  BOTTOM w0.089: v1(40.44,96.28) 40.48,96.32 T65.1
N16845569: length 2
  TOP w0.102: UH1.AV17 39.83,96.54 v1(39.83,96.27)
  BOTTOM w0.089: T67.1 39.16,95.71 39.73,96.27 v1(39.83,96.27)
N16848437: length 2.4
  BOTTOM w0.102: Q344.6 18.94,149.07 R956.1 17.67,149.18 v2(17.65,149.21)
N16848559: length 6.1
  BOTTOM w0.102: Q84.1 14.51,153.2 13.72,153.99 11.79,153.99 v2(11.46,153.66) 11.16,153.66 Q80.2
N16855849: length 1.4
  TOP w0.102: PC540.1 52.74,33.09 v2(53.06,33.41)
N16857314: length 1.1
  TOP w0.102: v1(41.61,90.77) 41.6,90.76 41.6,90.64 UH1.BA2
  BOTTOM w0.089: v1(41.61,90.77) 41.94,91.1 T57.1
N16858942: length 2.1
  TOP w0.102: UH1.AB10 33.5,93.51 v1(33.15,93.85)
  BOTTOM w0.089: v1(33.15,93.85) 33.52,94.23 33.52,94.69 T144.1
N16863974: length 10.2
  TOP w0.102: T132.1 47.48,111.82 46.92,111.26 42.96,111.26 40.34,108.65 40.34,108.28 40.04,107.98 40.04,107.5
N16864660: length 6.3
  TOP w0.102: T133.1 46.06,110.15 42.54,110.15 40.87,108.48 UH1.AY45
N16864959: length 8.1
  TOP w0.102: 40.04,108.41 40.04,108.66 42.87,111.49 46.22,111.49 T130.1
N16865260: length 9.1
  TOP w0.102: UH1.AW44 40.55,108.04 40.55,108.54 40.86,108.85 40.88,108.85 43.06,111.03 46.39,111.03 46.97,110.45 47.56,110.45 T131.1
N16869408: length 3.8
  TOP w0.102: UH1.AU42 v1(39.63,106.56)
  BOTTOM w0.089: T134.1 37.09,107.62 37.58,107.62 38.46,106.73 38.93,106.73 39.1,106.56 v1(39.63,106.56)
N16869720: length 5.1
  TOP w0.089: UH1.AU44 39.65,108.58 40.05,108.97 40.05,108.98 40.19,109.13
  TOP w0.102: T66.1 41.87,111.3 41.87,110.86 40.19,109.18 40.19,109.13
N16917464: length 5.2
  BOTTOM w0.102: v2(166.86,82.52) 166.86,80.99 167.01,80.84 PQ205.5
  BOTTOM w0.381: PQ205.5 168.58,80.84 PR223.2 168.66,81.7 PC217.1 PR225.1
N16917466: length 5.2
  BOTTOM w0.102: v2(170.66,76.76) 169.46,76.76 168.94,77.28 PR219.2
  BOTTOM w0.254: PQ204.5 168.75,78.26 PC219.1 ; PC219.1 168.82,78.19 PR219.2 ; PC219.1 PR220.1
N16917470: length 7.6
  BOTTOM w0.102: v2(163.14,76.06) 162.96,76.06 162.62,76.4 162.62,77.53 PR217.1
  BOTTOM w0.381: PC216.1 164.22,78.2 PR213.2 164.52,78.79 165.22,78.79 165.34,78.91 PQ204.3 ; PC216.1 164.75,78.19 164.82,78.26 PQ204.2 ; PC216.1 PR217.1
N16917506: length 6
  BOTTOM w0.102: PR224.1 163.31,81.96 v2(163.17,82.1)
  BOTTOM w0.381: PC220.1 PR221.2 164.79,81.91 165.22,81.49 PQ205.3 ; PC220.1 PR224.1 ; PC220.1 164.41,80.84 PQ205.2
N16917526: length 12.8
  TOP w0.254: v1(175.22,78.9) 173.87,80.25 172.17,80.25 171.69,80.73 170.75,80.73 167.39,77.38 v1(167.39,77.01)
  BOTTOM w0.102: v1(167.39,77.01) 167.12,77.01 v2(166.47,76.36)
  BOTTOM w0.254: PQ204.6 167.52,77.13 v1(167.39,77.01) ; PR211.1 v1(175.22,78.9)
N16917538: length 1.2
  BOTTOM w0.381: PR218.2 168.51,80.19 PQ205.6
N16919045: length 4.8
  TOP w0.102: v2(175.84,135.6) R820.2
  TOP w0.254: U29.31 172.35,134.51 172.88,135.04 174.28,135.04 174.79,135.55 R820.2
N16923593: length 4.8
  TOP w0.102: Q345.4 38.37,136.04 39.05,135.37 39.96,135.37 v2(40.22,135.62) 41.11,136.51 R20.1
N16923598: length 3.8
  TOP w0.102: Q345.1 40.91,138.27 R21.1 41.66,139.02 42.9,139.02 v2(43.05,138.87)
N16923957: length 14.7
  TOP w0.102: v2(41.23,142.25) R12.2 ; R12.2 39.07,140.88 Q346.3 ; R12.2 41.79,140.32 43.16,140.32 43.49,139.99 43.49,139.43 43.32,139.25 40.19,139.25 39.94,139 39.56,139 39.02,138.47 Q345.2 Q345.5
N16958896: length 1.3
  TOP w0.102: UH1.AD10 34.68,93.08 v1(34.71,93.08)
  BOTTOM w0.102: v1(34.71,93.08) 34.37,92.75 T141.1
N17068457: length 1.3
  TOP w0.102: UH1.AD39 34.33,105.88 v1(34.74,106.29)
  BOTTOM w0.089: T148.1 34.85,106.29 v1(34.74,106.29)
N17068936: length 1.3
  TOP w0.102: v1(34.74,105.64) 34.38,105.28 UH1.AD38
  BOTTOM w0.089: T147.1 34.91,105.64 v1(34.74,105.64)
N17075402: length 11.4
  TOP w0.102: 2.7,85.53 2.22,86.02 1.53,86.02 1.08,85.56 1.08,79.82 v2(1.44,79.45) 2.22,78.67 PQ2.3 ; 2.7,85.53 PR9.1 ; 2.7,85.53 PR7.2
N17106356: length 5.6
  TOP w0.102: UH1.BA45 42.29,109.15 45.94,109.15 T149.1
N17106357: length 6.5
  TOP w0.102: UH1.BC45 42.66,108.93 45.37,108.93 46.46,107.83 47.61,107.83 T150.1
N17106358: length 5.3
  TOP w0.102: T120.1 46.2,106.42 46.2,107.45 45.6,108.05 44.04,108.05 43.41,107.41 43.38,107.41 UH1.BE43
N17106359: length 4.1
  TOP w0.102: T121.1 46.76,107.21 45.7,108.28 43.65,108.28 UH1.BE44
N17132539: length 129
  TOP w0.254: v1(228.81,54.32) 229.22,54.72 229.22,58.94 226.06,62.1 224.94,62.1 220.2,66.84 218.34,66.84 217.49,67.69 217.49,68.19 215.52,70.17 212.96,70.17 v1(211.54,71.59)
  IN1 w0.254: v1(144.89,121.13) 145.4,120.62 145.4,116.11 144.99,115.71 144.99,108.4 154.04,99.35 154.96,99.35 155.55,99.93 159.8,99.93 165.06,94.67 166.16,94.67 177.31,83.52 179.32,83.52 179.56,83.75 181.27,83.75 184.29,80.74 195.73,80.74 205.19,71.28 211.24,71.28 v1(211.54,71.59)
  BOTTOM w0.254: PQ1001.4 227.49,52.19 PC1001.2 227.21,52.49 227.21,52.72 v2(228.3,53.81) v1(228.81,54.32) ; PR1002.2 v1(144.89,121.13)
N17139830: length 1.8
  TOP w0.102: UH1.M33 29.6,103.57 v1(29.29,103.87)
  BOTTOM w0.089: v1(29.29,103.87) 30.31,103.87 T122.1
N17139840: length 1.2
  TOP w0.102: v1(28.69,103.88) 28.95,103.62 UH1.L33
  BOTTOM w0.089: v1(28.69,103.88) 28.69,103.54 T123.1
N17164171: length 4.8
  TOP w0.102: UH1.BC30 42.82,101.94 43.12,102.25 43.65,102.25 43.93,102.53 46.69,102.53 T124.1
N17164181: length 1.5
  TOP w0.102: UH1.BB29 41.61,101.85 v1(41.14,101.85)
  BOTTOM w0.089: T125.1 41.33,102.05 v1(41.14,101.85)
N17205976: length 2.9
  TOP w0.254: JDEG2.10 169.85,118.24 v2(170.33,118.72) 171.03,119.42 R864.2
N17319754: length 142.1
  IN1 w0.254: v1(158.73,120.69) 157.54,119.49 157.54,118.42 158.33,117.63 158.33,117.25 159.7,115.88 159.7,114.49 161.4,112.79 161.4,110.54 169.74,102.19 172.55,102.19 182.25,92.49 182.25,91.68 184.49,89.44 184.49,86.19 v1(184.36,86.07)
  IN2 w0.254: v1(187.04,30.58) 176.12,30.58 174.81,31.89 174.81,45.41 172.4,47.83 172.4,52.21 169.86,54.75 169.71,54.75 168.79,55.67 168.79,57.54 170.34,59.09 170.34,78.78 169.96,79.16 169.96,81.16 173.49,84.69 173.98,84.69 176.01,86.73 177.86,86.73 178.29,87.16 182.05,87.16 183.35,85.86 184.16,85.86 v1(184.36,86.07)
  BOTTOM w0.254: PQ1003.4 193.84,33.69 192.95,32.8 189.26,32.8 v2(188.55,32.09) v1(187.04,30.58) PC1004.1 ; v1(158.73,120.69) 158.73,121.09 158.25,121.58 PR1004.1
N17649391: length 29.2
  BOTTOM w0.102: v2(199.08,22.1) 198.76,21.78 197.6,21.78 197.09,22.28 PD3.3 196.67,22.28 195.14,20.76 189.8,20.76 188.4,19.37 174.92,19.37 PBATT1.7
N17657331: length 3.4
  BOTTOM w0.102: PC1099.1 215.86,44.55 215.45,44.14 214.04,44.14 v4(213.55,44.64)
N17657337: length 22
  IN1 w0.508: v3(217.59,46.14) 219.87,43.85 v3(222.42,43.85) 222.42,41.58 v3(219.24,38.39)
  BOTTOM w0.102: v2(213.58,46.43) 214.92,45.1 PD1099.1
  BOTTOM w0.508: PQ1008.4 222.17,43.09 222.42,43.34 v3(222.42,43.85) ; PQ1009.4 219.24,38.96 v3(219.24,38.39) ; PD1099.1 215.8,45.95 PC1099.2 217.06,45.45 PR1099.2 217.71,46.01 v3(217.59,46.14) 217.59,46.72 PR1097.1
N17657416: length 3.8
  BOTTOM w0.508: PR1097.2 v2(216.49,48.08) 216.49,48.73 216.32,48.91 216.32,49.44 215.81,49.95 PQ1010.1
N17657433: length 2.3
  BOTTOM w0.102: PR1098.2 217.89,51.6 218.22,51.93 v2(218.22,52.12)
  BOTTOM w0.508: PR1098.2 217.26,51.58 PQ1010.2
N17657445: length 21.1
  IN2 w0.762: v3(200.06,41.69) 210.47,41.69 214.92,46.14 v3(214.92,48.55)
  BOTTOM w0.102: v2(214.24,49.15) 214.84,48.55 v3(214.92,48.55)
  BOTTOM w0.635: PD1099.2 v3(214.92,48.55)
N17657654: length 128.7
  IN1 w0.254: v1(159.17,118.17) 159.17,117.64 161.4,115.4 161.4,113.96 162.16,113.19 162.16,110.85 169.77,103.25 172.84,103.25 185.35,90.73 185.35,85.13 v1(185.3,85.08)
  IN2 w0.254: v3(195.86,39.18) 195.58,38.9 187.31,38.9 186.19,40.02 178.68,40.02 176.03,42.66 176.03,45.81 173.54,48.3 173.54,52.68 171,55.22 171,57.36 171.7,58.06 171.7,78.15 172.86,79.31 174.21,79.31 176.86,81.96 176.86,84.32 178.93,86.4 181.62,86.4 183.07,84.95 185.17,84.95 v1(185.3,85.08)
  BOTTOM w0.254: PR1006.1 157.72,120.53 v2(158.77,119.48) 158.99,119.26 158.99,118.35 v1(159.17,118.17) ; v3(195.86,39.18) 196.34,39.18 196.53,38.99 PQ1002.4
N17669554: length 5
  TOP w0.102: R13.2 41.17,139.68 Q346.6 Q346.5 38.47,139.13 36.89,139.13 v2(36.57,139.44)
N17684555: length 1.8
  BOTTOM w0.508: PC1005.1 178.41,29.85 PR1005.2
N17707524: length 4.7
  BOTTOM w0.102: v2(229.26,67.21) 229.55,67.5 PR1073.2 230.52,67.6 PQ1071.3 230.52,69.49 230.69,69.66 230.95,69.66 231.17,69.43 PQ1071.2
N17707536: length 4
  BOTTOM w0.102: PR1070.1 234.16,72.07 PR1071.2 ; PR1070.1 v2(235.02,73.15) ; PR1070.1 235.44,71.65 PQ1070.3
N17707538: length 3.9
  BOTTOM w0.102: PR1071.1 233.14,72.07 PR1072.1 ; PR1071.1 233.51,71.7 PQ1070.2 ; PR1071.1 233.19,73.11 v2(233.18,73.12)
N17707548: length 2.5
  BOTTOM w0.102: PQ1071.6 231.82,71.61 PR1072.2 231.37,73.12 v2(231.36,73.12)
N17708032: length 6.3
  BOTTOM w0.102: v2(172.08,35.2) 172.08,32.83 PQ1.2
  BOTTOM w0.508: PQ1.2 173.15,30.29 PC5.1 PR33.2
N17708061: length 5.2
  BOTTOM w0.102: PQ1.1 175.24,34.57 v2(174.57,35.24)
  BOTTOM w0.508: PQ1.1 176.44,31.52 PD5.2
N18894456: length 51.2
  TOP w0.102: PR528.2 PR525.2 55.28,21.42 v1(55.74,21.42) ; v1(40.12,41.84) 40.12,43.06 41.97,44.92 41.97,48.84 39.84,50.97 v2(39.84,55.46) 39.84,55.79 PH500.2
  IN4 w0.102: v1(55.74,21.42) 55.56,21.25 48.65,21.25 47.06,22.83 47.06,26.76 46.26,27.56 44.27,27.56 42.78,29.04 42.78,33.06 40.99,34.85 40.99,38.51 39.66,39.84 39.66,41.39 v1(40.12,41.84)
N18894698: length 5.9
  TOP w0.203: 54.76,28.85 54.71,28.85 54.33,28.47 PU500.17
  TOP w0.254: PR526.1 56.38,30.69 v2(55.59,29.9) 55.17,29.48 v1(55.17,29.4) 55.17,29.27 54.76,28.85
  BOTTOM w0.254: PC511.1 53.82,28.55 54.68,29.4 v1(55.17,29.4)
N18894707: length 2.8
  TOP w0.203: 49.88,26.4 PU500.28
  TOP w0.254: PR507.2 48.47,26.35 49.83,26.35 49.88,26.4
N18894708: length 3
  TOP w0.203: PU500.30 50.31,25.6 50.08,25.37
  TOP w0.254: 50.08,25.37 v2(49.36,25.37) 48.94,25.37 48.37,24.8 PR514.2
N18894710: length 2.8
  TOP w0.203: 50.01,26 PU500.29
  TOP w0.254: 50.01,26 49.98,25.97 48.52,25.97 PR509.2
N18894766: length 2
  TOP w0.102: PC520.2 v2(62.31,21.6)
  TOP w0.203: PC520.2 62.26,22.69 PR533.1
N18894780: length 2.6
  TOP w0.102: v2(59.65,23.77) 59.89,23.53 61.2,23.53 PR543.1
  TOP w0.254: PC527.2 PR543.1
N18894784: length 2.2
  TOP w0.102: PC526.2 v2(57.36,19.62)
  TOP w0.203: PC526.2 56.92,20.86 56.84,20.79 PR541.1
N18894793: length 6.2
  TOP w0.203: PU500.9 55.23,24.8 55.41,24.62 55.41,24.42 56.89,22.93 v2(58.12,22.93) 59.25,22.93 59.47,22.72 PR529.2
N18894855: length 5.1
  TOP w0.203: PU500.14 55.6,26.8 v2(56.15,27.35) 56.32,27.52 v1(56.32,27.98)
  BOTTOM w0.254: PR537.1 59.09,28.31 PC522.1 56.65,28.31 v1(56.32,27.98)
N18894856: length 2.8
  BOTTOM w0.102: v2(56.73,27.65) 56.98,27.9 57.69,27.9 PC522.2
  BOTTOM w0.254: PR545.2 59.06,27.39 PC522.2
N18894871: length 42.7
  TOP w0.254: PH501.2 v1(50.2,53.93)
  BOTTOM w0.254: PR551.1 64.07,23.35 64.98,24.27 64.98,28.88 60.41,33.45 v2(60.41,35.13) 60.41,39.31 59.45,40.27 53.43,40.27 49.06,44.64 49.06,52.36 50.2,53.5 v1(50.2,53.93)
N18894872: length 5.5
  BOTTOM w0.254: PC538.1 PC532.1 v2(61.25,25.27) 61.25,27.14 PR548.2
N18894895: length 6.1
  TOP w0.254: PU500.16 55.21,27.6 55.3,27.7 55.3,28.73 v1(55.81,29.23)
  TOP w0.508: v1(55.81,29.23) 56.83,29.23 v2(57.31,29.7) PR531.1
  BOTTOM w0.254: PC519.1 55,28.42 v1(55.81,29.23)
N18986312: length 8.9
  BOTTOM w0.254: PU700.20 180.28,47.5 181.53,46.25 PC791.1
  BOTTOM w0.635: PC791.1 v2(182.16,44.11) 179.36,41.31 PR775.1
N18986344: length 2.8
  BOTTOM w0.102: PU700.9 175.86,49 174.87,49.99 174.56,49.99 PR766.1
N18986424: length 4.9
  BOTTOM w0.254: PU700.10 176.25,49.5 v2(175.24,50.51) 174.53,51.22 PR758.1 174.24,52.1 PR760.1 PR764.2
N18986719: length 11.4
  BOTTOM w0.102: PR705.2 167.42,49.08 v2(168.26,49.92)
  BOTTOM w0.203: PU700.7 174.65,48 PC744.2 174.23,48.47 173.77,48.93 172.63,48.93 172.42,49.13 168.82,49.13 PR704.2 PR705.2
N18986737: length 2.5
  BOTTOM w0.102: PR765.2 183.68,48.84 184.62,48.84 v2(184.77,48.99)
  BOTTOM w0.508: PC734.2 PR765.2
N18986745: length 2.9
  BOTTOM w0.102: PU700.8 175.89,48.5 v2(175.24,49.15) 174.63,49.76 174.55,49.76 PR763.1
N18986747: length 2.6
  BOTTOM w0.254: PR759.1 178.23,52.79 v2(178.23,51.6) PU700.13
N18986804: length 2.9
  BOTTOM w0.254: PR761.1 v2(176.95,51.74) 177.73,50.95 PU700.12
N18989990: length 2.8
  BOTTOM w0.102: PQ710.6 171.89,51.71 v2(171.59,51.41)
  BOTTOM w0.254: PQ710.6 173.02,52.47 173.31,52.18 PR760.2
N19021798: length 6.1
  BOTTOM w0.102: PU1081.4 150.77,153.19 151.06,152.89 152.23,152.89 152.48,153.15 152.48,154.35 152.98,154.85 v2(153.3,154.85) 153.48,154.85 153.96,154.37 PQ1080.5
N19021978: length 4.9
  BOTTOM w0.102: v2(149.68,151.51) 150.48,150.71 PR1081.2 ; PR1081.2 150.48,149.97 150.91,149.54 PQ1082.1 ; PR1081.2 PR1083.2 151.42,150.61 PU1081.2
N19041240: length 14.4
  IN4 w0.109: v1(31.61,69.68) 31.5,69.68 31.05,70.14 31.05,72.93 26.91,77.07 26.91,77.99 v1(26.73,78.17)
  BOTTOM w0.102: PR701.3 31.7,69.59 v1(31.61,69.68) ; v1(26.73,78.17) 26.93,77.96 26.93,77.53 26.65,77.25 PQ702.1
N19061218: length 3.2
  TOP w0.102: v2(83.49,116.24) PR713.1 PR715.2 84.58,115.31 PQ703.4
N19183947: length 2.6
  BOTTOM w0.102: v2(34.32,73.14) 34.11,73.35 PR702.2
  BOTTOM w0.254: PR702.2 33.87,74.42 33.23,74.42 33.1,74.55 PU701.6
N19183951: length 3.2
  BOTTOM w0.102: v2(30.7,76.29) 30.98,76.01 PR706.2
  BOTTOM w0.254: PU701.4 31.8,75.45 31.63,75.63 PR706.2 31.63,76.88 PR708.2
N19208717: length 2.5
  BOTTOM w0.102: PU1080.4 154.11,150.07 v2(154.11,150.68) 154.11,150.83 153.96,150.98 PQ1080.2
N19242649: length 20.9
  IN3 w0.254: v1(227.92,64.3) 225.67,64.3 221.78,60.4 218.92,60.4 216,57.48 216,55.08 v3(215.43,54.51)
  BOTTOM w0.102: v1(227.92,64.3) v2(227.16,65.06)
  BOTTOM w0.254: v1(227.92,64.3) 227.72,64.3 227.46,64.03 PQ707.3 ; PR747.2 v3(215.43,54.51)
N19359738: length 6.6
  BOTTOM w0.102: v2(246.19,65.06) 247.69,65.06 PR100.2
  BOTTOM w0.203: PR102.2 247.89,62.78 247.89,62.39 247.46,61.96 247.3,61.96 246.98,61.64 PU101.4
  BOTTOM w0.254: PR102.2 248.47,64.23 PR100.2
N19359776: length 3.5
  BOTTOM w0.203: PU101.7 248.54,59.85 249.36,60.67 v2(249.37,60.67) 249.39,60.69 250.26,60.69 PR118.2
  BOTTOM w0.254: PR119.1 250.27,61.65 PR118.2
N19359778: length 4.1
  BOTTOM w0.102: v2(250.38,62.79) 250.26,62.9 248.92,62.9 248.5,62.48 PR105.1
  BOTTOM w0.203: PU101.5 247.38,61.4 248.41,62.43 PR105.1
N19359887: length 5.2
  BOTTOM w0.102: v2(244.14,65.36) 244.74,64.77 PR101.2
  BOTTOM w0.203: PU101.2 246.18,61.61 245.22,62.57 245.22,62.75 244.74,63.23 PR104.2
  BOTTOM w0.254: PR101.2 PR104.2
N19360011: length 3.1
  BOTTOM w0.102: v2(243.79,61.39) 243.79,61.4 PR106.1
  BOTTOM w0.203: PU101.1 245.78,61.31 PR106.1
N19407535: length 2.6
  BOTTOM w0.254: PQ1083.1 199.29,26.35 199.11,26.54 199.11,27.07 199.34,27.3 PQ1083.2
N19407555: length 23.4
  BOTTOM w0.102: v2(196.41,29) 196.41,28.64 196.8,28.25 PQ1083.4
  BOTTOM w0.508: PQ1083.4 198.32,28.25 199.08,29.02 206.79,29.02 208.01,30.24 PR1026.2 208.38,38.96 208.38,39.6 208.09,39.89 PQ1005.4
N19407586: length 29.3
  IN1 w0.254: v1(157.43,109.92) 157.43,110.13 156.84,110.72 156.66,110.72 155.9,111.48 155.9,114.16 154.73,115.33 154.73,123.71 152.27,126.17 151.76,126.17 150.91,127.02 v1(150.91,127.87)
  BOTTOM w0.102: v2(156.98,110.54) 157.43,110.09 v1(157.43,109.92)
  BOTTOM w0.254: v1(150.91,127.87) 151.94,128.9 154.07,128.9 154.36,128.61 154.36,127.65 153.83,127.11 PR1014.2 ; PD1010.2 157.92,108.94 157.43,109.43 v1(157.43,109.92)
N19407600: length 1.6
  BOTTOM w0.102: PD1100.2 159.45,107.17 v2(159.85,107.57)
N19407654: length 6
  BOTTOM w0.102: v2(153.18,107.34) 154.01,106.51 PQ1072.1
  BOTTOM w0.254: PQ1072.1 155.88,106.51 156.04,106.68 PR1032.2 157.2,107.41 157.43,107.64 PD1010.3
N19407656: length 4.9
  BOTTOM w0.102: v2(156.21,102.68) PR1100.2
  BOTTOM w0.254: PR1100.2 155.25,103.1 155.71,103.55 PQ1072.2 156.52,104.43 156.93,104.02 PQ1011.1
N20156535:
  vias: v2(258.48,147.31)
N20207345: length 3.9
  BOTTOM w0.102: C555.1 44.89,149.86 44.53,150.22 U62.4 43.94,150.47 43.61,150.8 v2(43.39,150.8) R709.2
N20966390: length 14.2
  TOP w0.102: PR7.1 1.81,84.52 PR10.2 1.3,84.01 1.3,80.16 3.18,78.28 PQ2.1 2.9,75.35 PL3.1 1.87,73.43 v2(1.86,73.43)
N20966408: length 2.9
  TOP w0.102: PR10.1 2.7,83.5 PR12.2 2.73,83.15 3.22,82.65 PQ3.2
N20966410: length 5.9
  TOP w0.102: PR11.2 PR13.1 2.83,79.92 PQ3.1 2.57,79.61 4.15,78.04 PQ2.2
N21631508: length 120.4
  IN1 w0.254: v1(177.53,85.81) 177.32,85.81 160.26,102.87 158.67,102.87 150.61,110.93 150.61,114.39 148.51,116.49 148.51,127.02 v1(148.73,127.24)
  IN2 w0.254: v3(187.54,38.03) 187.54,38.03 185.96,39.61 178.55,39.61 175.65,42.5 175.65,45.65 173.16,48.14 173.16,52.53 170.62,55.07 170.62,57.67 171.32,58.37 171.32,78.31 172.7,79.69 174.05,79.69 176.28,81.93 176.28,84.9 177.17,85.79 177.5,85.79 v1(177.53,85.81)
  BOTTOM w0.102: v1(148.73,127.24) 148.4,127.24 v2(148.14,127.49)
  BOTTOM w0.254: v3(187.54,38.03) 187.05,38.03 186.8,38.28 PQ1004.4 ; v1(148.73,127.24) 148.75,127.21 PR1009.1
N21765641: length 3.4
  TOP w0.102: C554.1 122.11,165.02 121.45,165.68 v2(121.45,166.37)
  TOP w0.203: U63.12 122.56,164.84 C554.1
N21766116: length 5.8
  TOP w0.203: U63.5 126.38,165.64 126.53,165.78 v2(126.53,167.6) 126.44,167.69 R844.2 126.44,169.29 R717.1 127.45,169.53 R815.2
N21766341: length 3.7
  TOP w0.102: C545.1 122.12,167.33 v2(121.65,167.8)
  TOP w0.203: U63.10 123.32,165.64 122.96,166 122.96,166.98 C545.1
N21774776: length 1.4
  BOTTOM w0.102: U35.12 122.98,108.27 C436.1
N21775970: length 1.4
  BOTTOM w0.102: U35.10 122.89,109.07 C543.1
N21777187: length 3.2
  BOTTOM w0.102: C435.1 52.56,108.37 52.56,109.66 v2(52.73,109.83) 53.14,110.24 U34.12
N21777255: length 96.3
  IN3 w0.127: v1(28.13,136.41) 28.65,136.93 30.71,136.93 32.17,135.48 32.17,132.94 33.75,131.35 42.63,131.35 42.91,131.63 47.19,131.63 48.24,130.59 55.05,130.59 56.23,129.4 56.23,118.14 52.98,114.89 v1(52.98,109.15)
  BOTTOM w0.102: v1(28.13,136.41) 28.13,131.74 29.19,130.67 29.19,127.88 31.1,125.97 31.1,122.41 30.72,122.03 30.72,120.81 29.6,119.7 26.21,119.7 24.67,118.15 22.86,118.15 v2(21.01,116.29) 19.11,114.39 19.11,110.5 18.12,109.51 C548.1 ; v1(52.98,109.15) 53.27,109.44 U34.10
N21778289: length 3.9
  TOP w0.102: U57.12 43.88,34.7 C549.1 43.72,34.83 43.2,35.35 43.2,36.19 42.93,36.46 v2(42.93,36.73)
N21778337: length 4
  TOP w0.102: v2(45.61,36.82) 45.17,36.37 45.17,35.29 C544.1 44.68,34.8 U57.10
N22506578: length 2.3
  BOTTOM w0.254: PU1001.28 155.33,122.28 155.63,122.59 v2(155.88,122.59) PR1008.1
N22841899: length 2.6
  TOP w0.508: R944.2 150.58,107.74 151.53,107.74 v2(151.66,107.87) 151.9,108.11 151.9,108.73 Q87.1
N22890234: length 8.5
  TOP w0.102: v1(40.09,92.9) 40.04,92.95 39.18,92.95 UH1.AT8
  BOTTOM w0.102: RH195.2 42.05,87.62 v2(41.25,88.42) 40.98,88.68 39.79,88.68 39.45,89.01 39.45,89.61 39.73,89.89 39.73,91.17 40.09,91.53 v1(40.09,92.9)
N23248496: length 3.6
  BOTTOM w0.102: U46.B18 212.97,77.27 211.76,76.06 v2(211.25,76.06) R802.2
N24484285: length 4
  BOTTOM w0.102: C546.1 262.89,59.23 v2(262.67,59.01)
  BOTTOM w0.254: C546.1 263.88,59.66 264.19,59.98 265.09,59.98 265.34,59.73 U43.6
N24485569: length 4
  BOTTOM w0.102: U56.6 115.66,145.92 115.99,146.24 115.99,146.68 C547.1 115.67,147.23 v2(115.3,147.6)
N24487647: length 1.4
  BOTTOM w0.254: U37.6 50.94,77.48 51.23,77.77 C541.1
N24489474: length 6.7
  BOTTOM w0.102: U38.6 83.34,140.12 83.03,140.43 81.22,140.43 C542.1 80.67,139.66 80.37,139.37 v2(80.37,138.72)
N25846218: length 7.1
  BOTTOM w0.102: R15.2 85.62,134.33 v2(84.59,133.3) 82.81,133.3 82.42,133.69 C16.1 82.67,134.47 82.76,134.47 83.34,135.04 U38.3
N32810427: length 0.9
  BOTTOM w0.102: RE5.2 CE3.1
N32854162: length 2.5
  TOP w0.102: v2(105.19,120.22) R756.2 105.22,118.81 C704.1
N32854418: length 2.3
  BOTTOM w0.102: v2(98.43,112.23) CE8.1 RE11.2
N32854492: length 2
  BOTTOM w0.102: CE9.1 RE12.2 v2(90.03,112.23)
N32916170: length 6.8
  TOP w0.102: v1(213.99,77.41) 213.99,77.22 211.97,75.19 211.97,74.86 v1(212,74.84)
  BOTTOM w0.102: v1(212,74.84) 211.24,74.08 R804.1 v2(212.45,73.77) ; v1(213.99,77.41) 213.63,77.77 U46.B19
N32917691: length 1.9
  BOTTOM w0.102: C713.1 R795.2 209,82.94 v2(209.33,83.27)
N32917710: length 2
  BOTTOM w0.102: R794.2 C712.1 208.14,84.94 207.78,85.29 v2(207.78,85.65)
N33080426: length 3.3
  BOTTOM w0.102: Q22.1 50.29,157.7 v2(50.86,158.28)
  BOTTOM w0.254: R423.2 51.67,156.75 50.89,156.75 Q22.1
N34391004: length 2.4
  BOTTOM w0.254: Q29.5 169.91,47.92 R513.2 170.16,48.63 Q29.6
N38606908: length 2.3
  TOP w0.102: v2(67.64,167.37) 67.71,167.3 R783.1 68.57,167.26 U48.7
N48711348: length 1.6
  TOP w0.102: v2(47.95,30.22) 47.09,29.36 PC521.1
N51290432: length 1.6
  BOTTOM w0.102: PR502.1 v2(36.67,75.32)
N51302473: length 1.1
  BOTTOM w0.089: PR501.1 38.76,69.86 38.39,70.23
  BOTTOM w0.102: 38.39,70.23 v2(38.27,70.34)
N53085144: length 3.7
  BOTTOM w0.102: PC206.2 179.83,72.24 180.73,73.14 v2(180.73,73.71)
  BOTTOM w0.508: PR200.1 PC206.2
N53085275: length 3.1
  BOTTOM w0.203: PU200.9 178.29,79.36 178.47,79.54
  BOTTOM w0.635: 178.47,79.54 v2(179.1,80.17) PR205.2
N53866851: length 2.7
  BOTTOM w0.102: v2(100.17,146.54) C747.1 R885.2
N63746311: length 6.2
  TOP w0.102: R884.1 108.8,162.72 108.44,162.37 108.44,161.8 v2(108.19,161.55) 107.86,161.21 107.86,160.28 v1(107.68,160.11)
  BOTTOM w0.102: U51.B2 107.76,160.02 v1(107.68,160.11)
N63746359: length 11.5
  TOP w0.102: v1(107.63,157.1) 107.31,156.78 106.89,156.78 v2(105.88,155.76) 105.29,155.18 105.29,153.33 105.37,153.26 105.37,149.29 105.83,148.83 R1984.1
  BOTTOM w0.102: v1(107.63,157.1) 107.7,157.02 U51.B8
N72304780: length 6.2
  TOP w0.102: UH1.AY1 41,89.65 41,89.28 42.36,87.92 46.02,87.92 T126.1
N85751870: length 1.2
  BOTTOM w0.102: PR301.2 17.55,142.85 v2(17.52,142.87)
N85751893: length 2.9
  TOP w0.102: PC309.1 v2(14.26,140.69)
  TOP w0.508: PR304.2 14.26,138.72 PC309.1
N88960285: length 3
  BOTTOM w0.102: v2(23.59,150.79) 22.91,150.1 R955.1 21.51,150.97 Q344.3
N90453843: length 4.3
  BOTTOM w0.102: R101.2 80.5,142.53 80.12,142.53 79.71,142.94 79.61,142.94 v2(79.37,143.18) 78.72,143.83 78.72,144.87 78.6,144.99 U23.12
N94639990: length 4.4
  BOTTOM w0.102: D68.2 50.34,149.03 51.19,149.03 v2(51.34,149.18) 51.8,149.64 51.8,150.05 51.57,150.28 50.88,150.28 50.72,150.44 U3.4
N106386290: length 1.1
  BOTTOM w0.102: CE1.1 48.29,94.47 RE1.2
N106390602: length 2.7
  BOTTOM w0.102: RE2.2 55.79,95.29 v2(55.7,95.37) 55.61,95.47 54.01,95.47 CE2.1
N109035766: length 43.2
  IN2 w0.127: v1(211.24,62.09) 212.1,62.95 216.11,62.95 217.18,61.89 222.84,61.89 226.75,65.8 234.63,65.8 244.08,75.25 v1(244.08,76.39)
  BOTTOM w0.102: Q340.3 243.15,77.15 243.91,76.39 v1(244.08,76.39) 244.45,76.39 v2(244.69,76.63) ; R2190.2 v1(211.24,62.09)
N109035794: length 38.3
  IN2 w0.127: v1(211.31,60.23) 212.71,61.63 216.37,61.63 216.82,61.17 223.12,61.17 227.24,65.29 235.42,65.29 239.15,69.02 v1(241.82,69.02)
  BOTTOM w0.102: Q339.6 242.03,69.24 v1(241.82,69.02) ; v1(241.82,69.02) 241.82,68.95 242.17,68.59 Q339.5 ; v1(241.82,69.02) 241.82,69.28 v2(241.37,69.72) ; v1(211.31,60.23) 211.35,60.27 R2192.2
N109035808: length 2.7
  BOTTOM w0.102: v2(239.21,75.59) R2191.2 240.65,75.45 Q340.6
N111311136: length 1.4
  TOP w0.102: JCPU1.AC7 v1(101.12,62.75)
  BOTTOM w0.102: v1(101.12,62.75) 100.64,62.27 T60.1
N111311586: length 1.4
  TOP w0.102: JCPU1.AG8 v1(100.12,66.75)
  BOTTOM w0.089: T64.1 99.68,67.19 v1(100.12,66.75)
N111316295: length 1.4
  TOP w0.102: JCPU1.R27 v1(80.12,54.75)
  BOTTOM w0.102: T69.1 80.2,54.75 v1(80.12,54.75)
N111321501: length 1.4
  TOP w0.279: v1(107.12,74.75) JCPU1.AR1
  BOTTOM w0.089: T99.1 107.12,74.75 v1(107.12,74.75)
N111321503: length 2.7
  TOP w0.102: v1(105.12,39.75) JCPU1.A2
  BOTTOM w0.102: T100.1 106.25,39.75 v1(105.12,39.75)
N111321505: length 1.5
  TOP w0.305: JCPU1.K6 v1(101.12,48.75)
  BOTTOM w0.102: v1(101.12,48.75) 101.63,49.26 T94.1
N111321507: length 1.4
  TOP w0.102: v1(102.12,44.75) JCPU1.F5
  BOTTOM w0.102: T93.1 102.62,45.25 v1(102.12,44.75)
N111321509: length 1.5
  TOP w0.102: JCPU1.AM2 v1(106.12,71.75)
  BOTTOM w0.102: T95.1 106.04,71.75 v1(106.12,71.75)
N111321511: length 2.7
  TOP w0.102: v1(72.12,41.75) 72.59,42.22 JCPU1.C35
  BOTTOM w0.089: v1(72.12,41.75) 71.98,41.75 71.38,42.34 70.46,42.34 T82.1
N111321513: length 1.5
  TOP w0.102: v1(72.12,40.75) 72.59,41.22 JCPU1.B35
  BOTTOM w0.102: T81.1 72.55,41.18 v1(72.12,40.75)
N111321515: length 1.5
  TOP w0.102: JCPU1.A34 73.59,40.22 v1(73.12,39.75)
  BOTTOM w0.102: v1(73.12,39.75) 73.57,40.19 T73.1
N111321517: length 1.5
  TOP w0.102: JCPU1.A35 72.59,40.22 v1(72.12,39.75)
  BOTTOM w0.089: T74.1 71.7,39.75 v1(72.12,39.75)
N111321521: length 6.5
  TOP w0.089: JCPU1.AT2 105.59,77.25
  TOP w0.102: 105.59,77.25 105.59,79.08 T71.1
N111321546: length 1.4
  TOP w0.102: v1(87.12,43.75) 87.59,44.22 JCPU1.E20
  BOTTOM w0.102: T101.1 87.12,43.82 v1(87.12,43.75)
N111321548: length 1.4
  TOP w0.102: JCPU1.E21 86.59,44.22 v1(86.12,43.75)
  BOTTOM w0.089: v1(86.12,43.75) 86.12,44.3 T102.1
N111321550: length 1.4
  TOP w0.102: v1(89.12,43.75) 89.59,44.22 JCPU1.E18
  BOTTOM w0.089: T96.1 89.12,44.32 89.12,43.79
  BOTTOM w0.102: 89.12,43.79 v1(89.12,43.75)
N111321552: length 1.4
  TOP w0.102: v1(84.12,42.75) 84.59,43.22 JCPU1.D23
  BOTTOM w0.102: T88.1 84.15,42.75 v1(84.12,42.75)
N111321596: length 1.2
  TOP w0.102: JCPU1.W30 v1(77.12,58.75)
  BOTTOM w0.089: v1(77.12,58.75) 77.12,58.43 T84.1
N111321598: length 1.4
  TOP w0.102: v1(76.12,58.75) 76.59,58.28 JCPU1.W31
  BOTTOM w0.089: 76.12,58.7 76.12,58.69 T83.1
  BOTTOM w0.102: 76.12,58.7 v1(76.12,58.75)
N111321602: length 1.5
  TOP w0.102: JCPU1.W29 v1(78.12,58.75)
  BOTTOM w0.089: T75.1 78.3,58.57 v1(78.12,58.75)
N111321604: length 1.4
  TOP w0.102: JCPU1.W28 79.59,58.28 79.13,58.74 v1(79.12,58.74)
  BOTTOM w0.089: T76.1 79.17,58.74 79.13,58.74
  BOTTOM w0.102: 79.13,58.74 v1(79.12,58.74)
N111321610: length 1.5
  TOP w0.102: JCPU1.P10 v1(98.12,52.75)
  BOTTOM w0.102: T97.1 97.62,53.25 v1(98.12,52.75)
N111321612: length 1.5
  TOP w0.102: JCPU1.U10 v1(98.12,55.75)
  BOTTOM w0.102: v1(98.12,55.75) 97.57,56.3 T98.1
N111321642: length 1.3
  TOP w0.102: JCPU1.AL25 v1(82.12,70.75)
  BOTTOM w0.102: T85.1 82.58,70.29 v1(82.12,70.75)
N111321646: length 7.2
  TOP w0.089: JCPU1.AT1 106.59,77.25
  TOP w0.102: T70.1 108,79.27 107.38,79.27 106.59,78.48 106.59,77.25
N111321650: length 2.1
  TOP w0.102: v1(81.12,71.75) JCPU1.AM26
  BOTTOM w0.089: v1(81.12,71.75) 81.66,72.29 T89.1
N111321654: length 1.4
  TOP w0.102: JCPU1.AR33 v1(74.12,74.75)
  BOTTOM w0.089: v1(74.12,74.75) 73.61,75.26 T91.1
N111321656: length 1.4
  TOP w0.102: JCPU1.AM27 v1(80.12,71.75)
  BOTTOM w0.089: T92.1 80.12,71.81 v1(80.12,71.75)
N111321658: length 1.5
  TOP w0.102: JCPU1.B23 84.59,41.22 v1(84.12,40.75)
  BOTTOM w0.102: v1(84.12,40.75) 84.12,40.82 T78.1
N111321660: length 1.5
  TOP w0.102: JCPU1.C23 84.59,42.22 v1(84.12,41.75)
  BOTTOM w0.089: T86.1 84.05,41.75 v1(84.12,41.75)
N111321662: length 1.5
  TOP w0.102: JCPU1.D24 83.59,43.22 v1(83.12,42.75)
  BOTTOM w0.089: T87.1 83.12,43.42 83.12,42.87
  BOTTOM w0.102: 83.12,42.87 v1(83.12,42.75)
N111321667: length 1.3
  TOP w0.102: JCPU1.AL30 77.12,69.81 v1(77.12,69.76)
  BOTTOM w0.089: T79.1 77.12,69.84 v1(77.12,69.76)
N111321671: length 1.5
  TOP w0.102: JCPU1.AD10 v1(98.12,63.75)
  BOTTOM w0.102: T72.1 97.66,63.28 v1(98.12,63.75)
N111327495: length 1.3
  TOP w0.102: v1(80.12,57.75) JCPU1.V27
  BOTTOM w0.102: v1(80.12,57.75) 80.55,57.32 T113.1
N111327547: length 4.8
  TOP w0.102: JCPU1.AT35 72.59,80.01 T157.1
N111327958: length 1.4
  TOP w0.254: JCPU1.AL27 v1(80.12,70.75)
  BOTTOM w0.089: v1(80.12,70.75) 80.05,70.75 T151.1
N111328199: length 5
  TOP w0.102: JCPU1.AR35 72.04,74.83 72.04,78.76 T158.1
N111328255: length 1.3
  TOP w0.102: v1(80.12,69.75) JCPU1.AK27
  BOTTOM w0.102: T152.1 80.55,69.32 v1(80.12,69.75)
N111328259: length 1.4
  TOP w0.254: JCPU1.AL13 v1(94.12,70.75)
  BOTTOM w0.254: T154.1 94.6,70.27 v1(94.12,70.75)
N111329001: length 1.4
  TOP w0.254: v1(80.12,50.75) JCPU1.L27
  BOTTOM w0.102: v1(80.12,50.75) 80.54,50.33 T77.1
N111329005: length 1.4
  TOP w0.254: v1(80.12,49.75) JCPU1.K27
  BOTTOM w0.089: T110.1 80.09,49.75 v1(80.12,49.75)
N111329010: length 1.3
  TOP w0.102: JCPU1.T27 v1(80.12,55.75)
  BOTTOM w0.089: T112.1 79.71,55.75 v1(80.12,55.75)
N111329086: length 1.4
  TOP w0.102: JCPU1.E17 90.59,44.22 v1(90.12,43.75)
  BOTTOM w0.102: v1(90.12,43.75) 90.59,44.21 T153.1
N111329153: length 1.7
  TOP w0.102: JCPU1.W32 v1(75.12,58.75)
  BOTTOM w0.089: T160.1 74.8,58.75 v1(75.12,58.75)
N111329155: length 1.3
  TOP w0.305: JCPU1.AL16 v1(91.12,70.75)
  BOTTOM w0.089: T159.1 v1(91.12,70.75)
N111329157: length 1.4
  TOP w0.102: v1(81.12,52.75) 81.12,52.75 81.59,52.28 JCPU1.N26
  BOTTOM w0.102: v1(81.12,52.75) 81.12,52.75 81.12,52.68 T115.1
N111337107: length 1.3
  TOP w0.102: JCPU1.AK33 v1(74.12,69.75)
  BOTTOM w0.089: v1(74.12,69.75) 74.05,69.75 T114.1
N111857606: length 1.3
  TOP w0.102: v1(78.12,70.75) JCPU1.AL29
  BOTTOM w0.102: T80.1 78.52,70.35 v1(78.12,70.75)
N113061370: length 3.8
  TOP w0.102: JMXM1.55 119.75,105.73 119.8,105.78 119.8,107.43 R1970.2 119.21,107.66 v2(119.06,107.81)
N116160023: length 2.7
  BOTTOM w0.102: U54.4 40.96,139.7 v2(41.11,139.85) 41.4,140.15 D67.2
N116282053: length 2.1
  TOP w0.102: v2(123.35,84.3) 123.8,84.75 CD89.2
  TOP w0.508: RC109.1 124.37,84.72 CD89.2
N116282133: length 2.5
  TOP w0.102: RC110.1 v2(123.82,47.2)
  TOP w0.508: CD90.2 RC110.1
N116406009: length 2.1
  BOTTOM w0.102: RC111.1 177.55,88.53 v2(177,88.53)
  BOTTOM w0.508: CD91.2 RC111.1
N116905454: length 6.8
  TOP w0.102: Q113.5 Q113.2 86.05,131.46 85.63,131.46 R1537.2 84.39,130.97 Q110.3 83.76,129.66 v2(83.85,129.56)
N116905461: length 2.9
  TOP w0.102: Q113.3 87.19,131.38 87.56,131.76 R1530.2 88.3,132.84 v2(88.37,132.91)
N116905506: length 2.9
  TOP w0.102: R1539.2 84.87,135.06 85.61,134.33 85.77,134.33 v2(85.91,134.19) 85.99,134.11 85.99,133.36 85.89,133.26 Q113.6
N116909867: length 3.3
  TOP w0.102: Q335.3 30.75,162.63 R2157.2 32.41,163.36 v2(33.09,162.67)
N116909894: length 4.3
  TOP w0.102: v2(26.88,146.86) 26.56,147.18 R2152.2 26.56,149.25 27.34,150.02 Q336.6
N116909908: length 7.3
  TOP w0.102: v2(31.38,159.36) 31.54,159.19 v1(32.39,159.19) 32.05,159.53 Q335.6 ; v1(29.42,156.55) 29.12,156.25 R2151.2
  BOTTOM w0.102: v1(32.39,159.19) 32.06,159.19 v1(29.42,156.55)
N116909947: length 2.5
  TOP w0.102: R2161.2 28.79,163.15 28.21,162.58 Q337.3 27.38,162.28 v2(27.16,162.49)
N116909973: length 3
  TOP w0.102: Q337.6 29.51,160.04 29.75,159.8 v2(29.75,159.37) 29.75,158.63 29.22,158.1 R2154.2
N117170853: length 5.6
  BOTTOM w0.102: R1171.2 v2(154.76,164.7) 158.49,164.7 JLOM1.13
N117170855: length 52.8
  BOTTOM w0.102: R1167.2 153.25,162.93 v2(154.83,161.34) 155.99,160.18 155.99,149.2 156.47,148.73 175.2,148.73 175.7,149.23 175.7,158 170.52,163.18 JLOM1.11
N117171278: length 51.9
  BOTTOM w0.102: R1170.2 154.67,160.23 155.76,159.14 155.76,148.32 156.36,147.72 v2(158.38,147.72) 160.28,147.72 161.06,148.5 175.29,148.5 175.93,149.13 175.93,161.78 JLOM1.10
N117983692: length 2.9
  TOP w0.102: U29.17 167.32,129.03 R818.2 166.62,129 v2(166.33,129.3)
N117984013: length 6.3
  TOP w0.102: v2(161.86,134.16) 162.42,134.72 R420.1
  TOP w0.254: U29.11 165.76,134.01 164.14,135.62 162.75,135.62 R420.1
N117984029: length 4.3
  TOP w0.102: R418.1 164.21,131.75 162.8,131.75 v2(162.64,131.6)
  TOP w0.254: R418.1 164.97,132.51 U29.14
N118331047: length 2.8
  TOP w0.102: v2(7.5,144.79) 7.57,144.72 R939.1 8.94,144.32 Q79.1
N118331054: length 3.4
  TOP w0.102: Q78.1 v2(12.25,145.77) 11.71,145.77 11.3,146.17 Q79.2
N118331059: length 2.3
  TOP w0.102: v2(7.62,147.43) 8.09,146.96 R934.1 9.37,146.96 Q75.1
N118331066: length 4.8
  TOP w0.102: v2(12.87,152.54) 12.58,152.25 D59.1 11.68,152.21 10.8,152.21 10.6,152.41 8.9,152.41 8.66,152.17 Q74.3
N118331070: length 7.9
  TOP w0.102: Q74.1 9.96,151.18 10.52,150.61 11.48,150.61 D59.2 ; Q328.3 12.85,149.01 D62.2 11.85,149.57 R932.2 12.18,150.39 D59.2 ; D59.2 12.69,150.85 v2(12.92,151.08)
N118331074: length 1.1
  TOP w0.102: Q75.2 9.96,149.44 Q74.6
N118331095: length 3.6
  BOTTOM w0.102: v2(13.48,152.25) 13.23,151.99 R941.1 12.07,151.44 12.58,150.93 Q318.1
N118331099: length 3.7
  BOTTOM w0.102: v2(9.51,150.96) 9.51,151.27 8.82,151.96 R942.1 8.29,153.26 Q80.1
N118331106: length 2.2
  BOTTOM w0.102: v2(15.5,144.66) 15.66,144.51 R943.1 16.75,144.59 Q86.1
N118331109: length 3.7
  TOP w0.102: v1(16.08,148.12) 15.15,149.06 Q328.1 v2(16.51,149.26)
  BOTTOM w0.102: Q86.2 16.1,148.11 v1(16.08,148.12)
N118535661: length 5.6
  BOTTOM w0.102: U39.9 169.37,113.35 R656.1 170.34,113.52 170.63,113.23 170.63,111.72 170.18,111.26 v2(170.18,110.88)
N118640218: length 6.4
  TOP w0.102: UH1.AA2 33.11,89.73 32.88,89.49 32.88,87.31 32,86.43 v2(31.76,86.43) 31.58,86.43 30.77,85.62 RH144.1
N118640221: length 7
  TOP w0.102: RH145.1 29.5,85.1 31.8,87.4 31.95,87.4 v2(32.28,87.73) 32.42,87.87 32.42,89.91 32.72,90.22 UH1.Y3
N119148113: length 1.4
  TOP w0.254: v1(80.12,48.75) JCPU1.J27
  BOTTOM w0.102: v1(80.12,48.75) 80.57,48.3 T164.1
N119362006: length 3.4
  BOTTOM w0.102: U45.7 256.33,102.07 255.92,102.47 255.66,102.47 255.18,102.96 R747.1 254.93,103.12 254.61,102.79 253.87,102.79 v2(253.83,102.83)
N119363129: length 2.8
  BOTTOM w0.102: R2141.2 227.08,87.44 227.08,86.93 227.61,86.41 U638.30
N119556938: length 2.3
  TOP w0.102: v2(156.37,133.91) R399.2 156.41,135.26 Q28.2
N260222010: length 37
  IN1 w0.254: v1(214.52,50.9) 214.52,50.81 214.38,50.67 214.38,45.9 207.69,39.2 207.69,30.17 206.22,28.71 199.8,28.71 v1(198.83,27.73)
  BOTTOM w0.102: PR1033.1 214.55,52.11 v2(213.91,52.74)
  BOTTOM w0.254: PR1033.1 214.55,50.92 v1(214.52,50.9) ; PQ1083.5 198.4,27.3 v1(198.83,27.73)

## Copper pours and planes (outline as drawn)
1.05V_RUN_ENABLE on TOP (solid shape): 38.39,129.45 38.39,129.3 38.39,128.45 38.39,128.43 38.39,127.54 38.39,127.42 38.13,127.16 37.63,127.16 37.5,127.29 37.5,127.67 36.74,128.43 34.96,128.43 34.71,128.69 34.71,129.58 34.96,129.83 38.01,129.83
1.5VSP_LX on BOTTOM (solid shape): 259.24,33.56 259.88,33.56 260,33.44 260,32.93 259.88,32.8 259.24,32.8 258.99,32.55 258.99,30.14 257.46,28.61 255.81,28.61 255.56,28.87 255.56,34.45 255.81,34.71 258.1,34.71
1.5VSP_VIN on BOTTOM (solid shape): 263.05,33.31 263.05,28.87 262.8,28.61 260,28.61 259.75,28.87 259.75,29.37 260,29.63 261.4,29.63 261.78,30.01 261.78,31.28 262.04,31.53 262.04,31.73 262.04,31.73 262.04,33.44 262.16,33.56 262.8,33.56
1.35V_B+ on BOTTOM (solid shape): 185.45,67.09 185.45,62.9 185.2,62.65 180.88,62.65 179.23,64.3 175.17,64.3 174.91,64.55 174.91,67.22 175.04,67.35 185.2,67.35
+0.9V_LAN on TOP (solid shape): outline of 318 points within 117.43,148.25 126.53,158.15
+0.9V_LAN on BOTTOM (solid shape): 118.53,153.58 118.53,153.2 118.78,152.94 119.8,152.94 119.8,152.31 118.78,152.31 118.27,152.82 117.64,152.82 117.38,153.07 117.38,153.58 117.64,153.83 118.27,153.83
+0.675V_DDR_VTT on TOP (solid shape): outline of 355 points within 121.19,23.91 167.29,31.02
+0.675V_DDR_VTT on BOTTOM (solid shape): 169.58,76.22 169.58,73.95 169.33,73.7 168.31,73.7 167.55,74.46 167.55,76.03 167.58,76.04 167.79,76.29 167.73,76.61 167.7,76.65 167.8,76.74 169.05,76.74
+0.675V_DDR_VTT on BOTTOM (solid shape): outline of 309 points within 150.02,22.77 171.74,29.25
+0.675V_DDR_VTT on IN3 (solid shape): 167.67,29.5 167.67,28.1 167.42,27.85 165.01,27.85 164.75,28.1 164.75,29.5 165.01,29.75 167.42,29.75
+0.675V_DDR_VTT on IN3 (solid shape): 169.96,76.49 169.96,73.82 169.33,73.19 168.18,73.19 167.93,73.44 167.93,76.49 168.18,76.74 169.71,76.74
+0.675V_P on BOTTOM (solid shape): 177.19,75.93 177.19,75.18 176.85,74.84 176.56,74.84 176.31,74.59 176.31,73.82 176.06,73.57 170.42,73.57 170.32,73.67 170.32,75.19 170.47,75.35 174.66,75.35 174.91,75.6 176.06,75.6 176.31,75.86 176.82,75.86 176.95,75.98 177.14,75.98
+1.05V_M on TOP (solid shape): 28.05,132.44 28.11,132.53 28.22,132.51 28.57,132.17 31.21,132.17 31.33,132.05 31.33,130.07 31.4,129.99 31.4,129.96 31.66,129.7 31.66,125 31.4,124.75 29.88,124.75 29.64,124.99 29.64,125 29.55,125.15 29.39,125.24 29.38,125.25 28.08,126.55 28.08,127.14 27.52,127.14 27.52,127.39 28.05,127.39 28.08,127.42 28.08,127.95 27.52,127.95 27.52,128.2 28.08,128.2 28.08,131.07 27.52,131.07 27.52,131.23 28.05,131.23 28.05,131.33 28.08,131.33 28.08,131.89 27.52,131.89 27.52,132.03 28.05,132.03 28.05,132.14 28.05,132.14
+1.05V_M on TOP (solid shape): 32.52,99.38 32.52,99.36 32.57,99.21 32.69,99.1 32.7,99.1 33.05,98.75 33.05,97.7 33.2,97.55 33.2,97.55 33.43,97.32 33.44,97.3 33.5,97.11 33.66,96.99 33.69,96.98 33.69,96.81 33.44,96.56 30.9,96.56 30.64,96.81 30.64,97.02 30.79,97.16 30.83,97.36 30.85,97.43 30.9,97.47 31.04,97.56 31.1,97.72 31.33,97.94 31.33,98.65 31.5,98.94 31.35,99.25 31.3,99.33 31.33,99.41 31.44,99.51 31.53,99.51 31.55,99.5 31.86,99.39 32.12,99.58 32.14,99.6 32.29,99.6
+1.05V_M on BOTTOM (solid shape): 33.56,99.22 33.56,97.95 33.5,97.89 32.94,97.89 32.71,97.66 32.71,97.1 32.54,96.94 31.23,96.94 31.13,96.84 30.44,96.84 30.44,96.81 30.39,96.81 30.01,96.43 29.54,96.43 29.05,96.57 28.93,96.08 28.93,95.97 28.84,95.92 28.61,95.92 28.39,96.14 28.4,96.17 28.4,96.3 28.36,96.42 28.36,96.43 28.36,96.56 28.77,96.98 28.79,96.98 28.95,97.07 29.05,97.24 29.05,97.25 29.12,97.32 30.12,97.32 30.12,97.28 30.68,97.04 30.64,97.64 30.59,97.72 30.62,97.81 31.53,98.72 31.53,99.1 31.78,99.35 33.44,99.35
+1.05V_M on BOTTOM (solid shape): 32.17,116.24 32.67,116.24 32.73,116.18 32.76,116.08 32.67,116.01 32.53,115.95 32.42,115.84 32.34,115.79 32.25,115.82 31.64,115.51 32.32,115.47 32.37,115.5 32.42,115.48 32.45,115.43 32.47,115.36 32.45,115.3 32.72,114.72 33,115.3 32.97,115.36 33,115.43 33.05,115.51 33.08,115.61 33.14,115.69 33.25,115.67 33.56,115.35 33.56,114 33.53,113.97 33.51,113.93 33.42,113.88 33.33,113.93 32.67,113.75 33.33,113.57 33.42,113.62 33.51,113.57 33.53,113.54 33.56,113.5 33.56,113.45 33.82,113.19 33.82,110.54 33.32,110.05 32.78,110.05 32.67,110.15 32.67,111.96 31.78,112.85 31.78,113.32 31.53,113.57 31.53,114.5 31.15,114.88 31.15,115.23 30.51,115.86 29.28,115.86 29.27,115.86 28.85,115.7 28.86,115.24 28.86,114.84 28.61,114.59 27.85,114.59 27.59,114.84 27.59,116.75 27.82,116.98 30.57,116.98 30.59,117 31.4,117
+1.05V_M on VCC (solid shape): outline of 3249 points within 24.55,96.18 32.67,128.56
+1.05V_MP on TOP (solid shape): 25.14,138.17 25.51,137.88 25.88,138.17 27.38,138.17 27.85,137.7 27.85,136.63 27.77,136.41 27.85,136.19 27.85,135.84 27.54,135.54 27.54,133.19 27.85,132.89 27.85,132.37 27.34,132.37 27.34,130.85 27.39,130.85 27.39,130.83 27.85,130.83 27.85,128.43 27.34,128.43 27.34,126.91 27.85,126.91 27.85,126.53 27.72,126.4 22.13,126.4 21.24,127.29 21.24,128.43 21.5,128.69 22.26,128.69 22.39,128.81 22.39,129.58 22.26,129.7 21.5,129.7 21.24,129.96 21.24,132.12 22.51,133.39 22.51,138.01 22.67,138.17
+1.5V_RUN on TOP (solid shape): 252.38,86.65 252.38,66.46 252.26,66.33 250.73,66.33 249.72,67.35 249.72,76.49 250.35,77.13 250.35,86.65 250.61,86.9 252.13,86.9
+1.05V_RUN on TOP (solid shape): 36.99,127.8 36.99,127.29 37.25,127.04 39.66,127.04 39.89,126.81 39.89,123.07 39.66,122.85 35.09,122.85 34.83,123.1 34.83,127.8 35.09,128.05 36.74,128.05
+1.5V_RUN on TOP (solid shape): 16.73,89 16.73,88.98 16.78,88.72 16.99,88.57 17,88.56 17,87.87 17.13,87.74 16.67,87.29 16.67,86.78 16.54,86.65 14.51,86.65 14.39,86.78 12.23,86.78 12.1,86.9 12.1,87.67 12.23,87.79 15.19,87.79 15.28,87.78 15.37,87.79 15.53,87.79 15.78,88.05 15.78,88.28 15.83,88.33 15.83,88.99 16.04,89.19 16.54,89.19
+1.5V_RUN on TOP (solid shape): 104.17,142.24 104.17,140.71 103.83,140.37 95.67,140.37 95.41,140.63 95.41,141.25 95.42,141.28 95.44,141.34 95.46,141.4 95.46,141.46 95.46,141.52 101.25,141.52 101.25,141.46 101.26,141.41 101.28,141.36 101.3,141.31 101.33,141.27 101.37,141.23 101.41,141.19 101.45,141.17 101.5,141.15 101.56,141.14 101.61,141.13 101.66,141.14 101.71,141.15 101.76,141.17 101.81,141.19 101.85,141.23 101.89,141.27 101.92,141.31 101.94,141.36 101.96,141.41 101.96,141.46 101.96,141.52 101.96,141.57 101.94,141.62 101.92,141.67 101.89,141.71 101.85,141.75 101.81,141.78 101.76,141.81 101.71,141.83 101.66,141.84 101.61,141.85 101.56,141.84 101.5,141.83 101.45,141.81 101.41,141.78 101.37,141.75 101.33,141.71 101.3,141.67 101.28,141.62 101.26,141.57 101.25,141.52 95.46,141.52 95.45,141.58 95.44,141.61 95.44,142.14 95.74,142.44 103.97,142.44
+1.05V_RUN on BOTTOM (solid shape): 47.89,111.5 47.89,111.22 47.26,110.59 47.1,110.59 46.87,110.82 46.87,111.09 47.45,111.67 47.72,111.67
+1.5V_RUN on BOTTOM (solid shape): 254.29,27.6 254.29,26.2 254.03,25.94 251.75,25.94 251.49,26.2 251.49,27.6 251.75,27.85 254.03,27.85
+1.5V_RUN on BOTTOM (solid shape): 12.35,111.03 12.35,110.65 11.59,109.89 10.24,109.89 10.19,109.89 9.94,110.15 9.94,110.4 11.34,111.8 11.59,111.8
+1.5V_RUN on BOTTOM (solid shape): 15.73,118.25 15.87,118.11 15.78,118.02 15.04,118.02 14.99,118.02 14.89,118.02 14.77,118.15 14.77,118.98 14.77,119.29 15.02,119.54 15.73,119.54
+1.05V_RUN on BOTTOM (solid shape): 14.03,102.98 14.34,102.87 14.63,103.03 14.95,103.03 15.04,102.95 15.04,102.19 14.87,102.02 13.24,102.02 12.99,102.27 12.99,103.03 13.24,103.29 13.73,103.29
+1.5V_RUN on BOTTOM (solid shape): 16.62,89.57 16.69,89.54 16.72,89.48 16.75,89.36 16.8,89.27 16.83,89.2 16.8,89.14 16.78,88.72 17.18,88.57 17.27,88.55 17.31,88.47 17.31,88.3 17.05,88.05 16.72,88.05 16.6,88.17 16.54,88.17 16.42,88.3 15.91,88.3 15.53,88.68 15.53,89.06 16.04,89.57
+1.05V_RUN on BOTTOM (solid shape): outline of 189 points within 35.59,114.72 39.91,122.97
+1.5V_RUN on BOTTOM (solid shape): outline of 2208 points within 35.47,97.83 49.82,113.07
+1.5V_RUN on IN1 (solid shape): 181.26,85.7 181.26,85.34 179.4,85.34 179.1,85.63 177.98,85.63 177.9,85.67 177.88,85.75 177.87,85.92 177.78,86.07 177.75,86.14 177.78,86.21 178.72,87.16 179.81,87.16
+1.5V_RUN on IN1 (solid shape): outline of 1216 points within 115.48,114.97 154.09,149.52
+1.5V_RUN on IN1 (solid shape): outline of 2171 points within 208.44,59.35 252.38,71.11
+1.05V_RUN on VCC (solid shape): outline of 6625 points within 30.01,95.41 50.58,128.56
+1.5V_RUN on IN2 (solid shape): 96.68,142.78 96.68,141.11 95.61,140.04 95.41,140.24 95.41,142.78 95.67,143.04 96.43,143.04
+1.5V_RUN on IN2 (solid shape): outline of 659 points within 40.04,105.57 51.09,113.07
+1.5V_RUN on IN3 (solid shape): outline of 297 points within 103.41,139.74 116.87,142.4
+1.5V_RUN on IN4 (solid shape): 182.15,84.8 182.15,84.11 181.52,83.48 180.25,83.48 179.1,84.62 179.1,85.89 179.36,86.14 180.81,86.14
+1.5V_RUN on IN4 (solid shape): 208.7,62.77 210.6,62.77 210.85,62.52 210.85,61.12 210.6,60.87 207.81,60.87 206.16,62.52 206.16,62.77 206.92,63.54 207.93,63.54
+1.5V_RUN on IN4 (solid shape): 253.02,69.38 253.02,67.47 252.76,67.22 252.26,67.22 249.59,69.89 249.59,70.78 249.84,71.03 251.37,71.03
+1.5V_RUN on IN4 (solid shape): 255.43,27.98 255.43,27.85 255.3,27.72 255.43,27.6 255.43,26.2 255.18,25.94 251.75,25.94 251.49,26.2 251.49,27.98 251.75,28.23 255.18,28.23
+1.5V_RUN on BOTTOM: 8.8,92.24 8.54,92.49 8.54,94.02 8.78,94.25 8.88,94.27 8.95,94.18 8.97,94.07 9.03,93.97 9.05,93.9 9.03,93.84 9.31,93.25 9.58,93.84 9.56,93.9 9.58,93.97 9.65,94.11 9.65,94.27 9.67,94.36 9.75,94.4 10.06,94.4 10.22,94.25 10.22,92.51 9.94,92.24
+1.5V_RUN on IN1: 8.92,92.49 8.67,92.75 8.67,95.16 9.35,95.84 9.43,95.87 9.51,95.82 10.02,95.71 10.08,96.23 10.05,96.3 10.08,96.37 10.17,96.62 10.07,96.86 10.07,99.42 10.12,99.6 10.07,99.79 10.07,102.4 9.62,102.85 9.62,102.85 9.56,102.93 9.48,102.99 9.47,102.99 8.93,103.54 8.93,110.4 9.18,110.65 11.21,110.65 11.46,110.4 11.46,109.67 11.41,109.48 11.46,109.3 11.46,109.08 11.41,108.9 11.46,108.72 11.46,106.39 11.41,106.21 11.46,106.02 11.46,105.81 11.41,105.62 11.46,105.44 11.46,105.18 11.41,105 11.46,104.82 11.46,99.81 11.06,99.41 11.05,99.38 11.03,99 11.36,98.82 11.43,98.79 11.46,98.72 11.46,98.28 11.43,98.21 11.36,98.18 11.01,97.97 11.08,97.58 11.11,97.51 11.08,97.44 11.01,97.04 11.36,96.84 11.43,96.81 11.46,96.73 11.46,95.06 11.21,94.8 11.21,92.94 10.76,92.49
+1.5V_RUNP on BOTTOM (solid shape): 253.78,38.26 253.78,38.23 254.29,37.73 254.29,35.6 255.18,34.71 255.18,28.87 254.92,28.61 251.75,28.61 251.49,28.87 251.49,33.31 252.51,34.33 252.51,38.52 252.76,38.77 253.27,38.77
+1.05VSP_B+ on BOTTOM (solid shape): 21.09,141.46 21.09,138.14 21.26,137.97 21.96,137.97 22.04,137.88 22.04,135.69 21.9,135.54 18.55,135.54 18.16,135.93 18.16,138.14 17.98,138.32 17.29,138.32 17.14,138.47 17.14,139.28 17.14,139.28 17.69,139.28 17.69,139.83 17.14,139.83 17.14,139.83 17.14,140.08 17.69,140.08 17.69,140.08 17.69,140.63 17.69,140.63 17.15,140.63 17.15,140.63 17.15,141.4 17.41,141.67 20.88,141.67
+1.35V_MEM on TOP (solid shape): 136.43,66.2 136.43,51.09 136.2,50.86 135.95,50.86 135.69,51.47 135.45,50.86 135.35,50.83 135.26,50.78 134.3,50.78 134.17,51.47 134.04,50.78 132.63,50.78 132.5,50.92 132.5,53.38 132.62,53.5 132.62,54.52 132.5,54.65 132.5,55.92 132.62,56.04 132.62,56.93 132.5,57.06 132.5,58.46 132.62,58.58 132.62,59.47 132.5,59.6 132.5,62.9 132.37,63.03 132.37,64.04 132.5,64.17 132.5,65.31 132.24,65.57 132.24,66.97 132.5,67.22 135.42,67.22
+1.35V_MEM on TOP (solid shape): outline of 111 points within 93.15,46.9 97.44,68.24
+1.35V_MEM on BOTTOM (solid shape): 182.79,57.01 183.55,57.01 183.55,57.54 183.98,57.54 183.98,57.01 187.69,57.01 187.69,57.54 188.12,57.54 188.12,57.01 188.88,57.01 188.88,57.54 189.31,57.54 189.31,57.01 190,57.01 190.28,56.73 190.28,55.66 190.03,55.41 187.61,55.41 186.22,54.01 181.52,54.01 181.26,54.27 181.26,56.68 181.59,57.01 182.36,57.01 182.36,57.54 182.79,57.54
+1.35V_MEM on BOTTOM (solid shape): 136.31,67.6 136.31,54.94 136.06,54.94 135.77,54.65 135.67,54.65 133.38,52.36 133.38,50.96 133.13,50.71 132.62,50.71 132.37,50.96 132.37,53.58 132.4,53.6 132.44,53.6 132.44,53.65 132.5,53.7 132.5,54.57 132.37,54.7 132.37,55.99 132.5,56.12 132.5,56.98 132.37,57.11 132.37,58.28 132.62,58.53 132.62,59.27 132.37,59.53 132.37,64.04 132.5,64.17 132.5,64.37 132.5,64.37 132.5,65.37 132.5,65.44 132.37,65.57 132.37,67.6 132.62,67.85 136.05,67.85
+1.35V_MEM on BOTTOM (solid shape): 164.43,68.22 164.43,67.21 164.25,67.03 164.25,53 163.31,52.06 163.1,52.06 162.73,51.87 162.67,51.46 162.68,51.43 162.21,50.96 160.82,50.96 160.56,51.22 160.56,54.9 160.82,55.15 162.34,55.15 162.72,55.54 162.72,55.92 162.98,56.17 162.98,59.22 162.72,59.47 160.94,59.47 160.69,59.73 160.69,68.11 160.94,68.36 164.29,68.36
+1.35V_MEM on BOTTOM (solid shape): outline of 12838 points within 88.05,33.05 111.39,69.38
+1.35V_MEM on IN2 (solid shape): outline of 13256 points within 88.68,43.55 165.64,72.54
+1.35V_MEM on TOP: 164.25,51.22 165.48,49.98 165.48,49 165.9,48.59 165.9,45.76 165.64,45.5 164.37,45.5 163.74,44.87 163.74,41.18 167.17,37.76 167.17,36.36 166.79,35.98 162.72,35.98 162.09,36.61 162.09,42.96 162.28,43.45 162.09,43.94 162.09,45.5 161.83,45.76 161.83,50.06 161.83,50.07 161.83,50.36 161.15,51.04 160.74,51.04 160.56,51.22 160.56,55.49 160.61,55.58 160.71,55.58 160.92,55.54 161.12,55.62 161.18,55.64 161.25,55.62 161.67,55.59 161.82,55.98 162.98,57.14 162.98,59.47 162.72,59.73 160.82,59.73 160.56,59.98 160.56,68.11 161.32,68.87 161.32,77.93 161.57,78.17 166.71,78.17 167.04,77.84 167.04,74.08 166.79,73.82 163.94,73.82 163.82,73.7 163.82,69.08 164.16,68.74 166.79,68.74 167.04,68.49 167.04,64.68 166.63,64.27 164.68,64.27 164.08,64.87 164.08,65.06 163.93,65.21 163.22,65.21 163.15,65.14 163.15,64.11 163.41,63.85 164.1,63.85 164.13,63.82 164.13,62.77 164.25,62.66
+1.35V_MEM on VCC: outline of 342 points within 88.55,34.2 191.8,78.01
+1.35V_MEN_P on BOTTOM (solid shape): 174.66,71.46 174.66,70.93 174.68,70.9 175.14,70.9 175.17,70.93 175.17,71.46 175.19,71.49 175.47,71.49 175.68,71.28 175.68,69.89 174.66,68.87 174.66,62.01 174.91,61.76 190.6,61.76 191.42,62.58 191.42,70.14 191.68,70.39 199.93,70.39 200.19,70.14 200.19,62.14 199.93,61.89 198.15,61.89 196.38,60.11 196.38,57.44 196.12,57.19 189.49,57.19 189.49,57.72 188.71,57.72 188.71,57.16 188.27,57.16 188.27,57.72 187.51,57.72 187.51,57.16 184.16,57.16 184.16,57.72 183.4,57.72 183.37,57.69 183.37,57.16 182.94,57.16 182.94,57.72 182.18,57.72 182.18,57.19 174.53,57.19 172.5,59.22 172.5,70.14 173.85,71.49 174.63,71.49
+3.3V_ALW on TOP (solid shape): 111.08,138.69 111.44,138.69 111.79,138.34 111.79,137.7 111.54,137.45 109.89,137.45 109.64,137.7 109.64,138.59 109.76,138.72 111.08,138.72
+3.3V_ALW on TOP (solid shape): 45.64,31.58 45.78,31.44 45.78,30.28 45.66,30.16 45.18,30.16 45.11,30.24 45.11,30.48 44.97,30.62 44.97,31.54 45.01,31.58 45.53,31.58
+3.3V_ALW on TOP (solid shape): 126.87,164.22 126.87,163.71 126.49,163.33 125.95,163.33 125.51,163.77 125.51,164.49 125.56,164.54 125.82,164.54 125.82,164.54 126.56,164.54
