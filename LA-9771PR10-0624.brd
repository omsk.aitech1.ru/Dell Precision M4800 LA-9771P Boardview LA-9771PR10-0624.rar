# Allegro board LA-9771PR10-0624.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MB_DP_RP_P0: length 91.6
  IN1 w0.117: v1(247.95,83.15) 247.78,83.33 247.43,83.33 247.13,83.63 247.13,84.31 247.49,84.67 249.67,84.67 251.29,86.3 251.29,96.67 253.31,98.69 253.31,103.83 256.26,106.78 256.26,115.79 258,117.53 258,119.7 259.29,120.99 259.29,127.88 260.27,128.86 260.27,144.52 260.99,145.24 260.99,160 263.15,162.15 263.15,163.32 263.66,163.84 264.41,163.84 JDP1.1
  BOTTOM w0.102: C307.1 247.44,83.34 247.76,83.34 v1(247.95,83.15)
MB_DP_RP_P1: length 94.8
  IN1 w0.117: v1(248.26,85.16) 248.44,85.34 248.97,85.34 249.78,86.14 249.78,95.88 252.68,98.77 252.68,103.93 255.75,107.01 255.75,116.03 257.5,117.78 257.5,124.1 258.01,124.61 258.01,132.14 259.22,133.35 259.22,144.21 260.47,145.46 260.47,160.24 262.39,162.16 262.39,163.31 263.93,164.85 265.57,164.85 266.84,163.59 266.84,162.44 266.61,162.22 266.43,162.22 266.33,162.32 266.33,162.98 266.23,163.08 265.92,163.08 265.72,162.88 JDP1.4
  BOTTOM w0.102: v1(248.26,85.16) 248.07,85.35 247.93,85.35 247.69,85.11 247.43,85.11 C295.1
MB_DP_RP_P2: length 86
  IN1 w0.117: v1(252.88,89.37) 252.74,89.52 252.39,89.52 252.1,89.81 252.1,93.03 255.37,96.29 255.37,104.07 255.78,104.48 255.78,104.93 256.8,105.95 257.49,105.95 258.35,106.81 258.35,116.73 258.78,117.17 258.78,119.25 260.09,120.55 260.09,126.91 261.06,127.88 261.06,144.01 261.93,144.88 261.93,159.51 263.21,160.79 264.36,160.79 JDP1.7
  BOTTOM w0.102: v1(252.88,89.37) 252.7,89.55 249.97,89.55 249.04,88.62 249.04,88.14 v3(248.29,87.38) 247.79,86.89 247.43,86.89 C306.1
MB_DP_RP_P3: length 97
  IN1 w0.117: v1(247.94,88.48) 248.12,88.66 248.47,88.66 248.8,88.99 248.8,96.05 251.89,99.14 251.89,108.2 254.92,111.23 254.92,116.32 256.7,118.1 256.7,125.09 257.01,125.4 257.01,133.06 258.44,134.49 258.44,144.6 259.65,145.81 259.65,160.61 261.48,162.44 261.48,163.54 263.61,165.67 265.95,165.67 267.64,163.97 267.64,159.95 266.91,159.22 266.45,159.22 266.33,159.34 266.33,160.01 266.23,160.11 265.97,160.11 265.72,159.85 JDP1.10
  BOTTOM w0.102: v1(247.94,88.48) 247.76,88.67 247.43,88.67 C303.1
MB_DP_RST#: length 4.5
  BOTTOM w0.102: U22.35 238.58,81.57 238.43,81.42 R415.2 C88.1 v2(238.43,77.98)
MCARD_MISC_PWREN: length 163.8
  TOP w0.102: v1(170.99,126.49) 176.51,120.97 180.65,120.97 184.35,117.27 184.35,109.85 182.96,108.47 182.96,102.73 186.08,99.62 198.1,99.62 204.48,93.24 221.31,93.24 221.64,92.91 221.64,92.45 221.45,92.26 221.45,89.37 221.67,89.14 221.67,86.09 221.81,85.96 v1(221.81,84.93)
  IN3 w0.127: v1(110.69,142.15) 110.73,142.15 111.06,142.48 117.02,142.48 117.86,141.63 117.86,140.56 118.27,140.16 119.21,140.16 119.69,139.67 119.69,137.17 122.93,133.93 138.83,133.93 v1(139.44,134.54)
  IN4 w0.109: v1(170.99,126.49) 171.62,127.12 171.62,128.54 169.98,130.18 166.22,130.18 165.73,130.67 164.96,130.67 163.86,131.76 149.92,131.76 147.44,134.24 139.75,134.24 v1(139.44,134.54)
  BOTTOM w0.102: U46.B53 221.97,84.77 v1(221.81,84.93) ; U56.3 112.09,145.92 112.04,145.97 111.66,145.97 111.05,146.58 v2(110.84,146.58) 110.48,146.58 109.72,145.82 R733.1 109.83,145.31 109.83,143.01 v1(110.69,142.15)
MCARD_PCIE#_SATA: length 16.3
  IN3 w0.127: v1(218.73,62.32) 220.68,62.32 222.79,64.43 222.79,66.69 224.49,68.39 v1(224.49,69.96)
  BOTTOM w0.102: v2(219.82,61.06) 219.55,61.33 R785.2 ; Q322.1 224.7,69.76 v1(224.49,69.96) ; R785.2 217.87,62.19 U637.17 ; R785.2 v1(218.73,62.32)
MCARD_PCIE_SATA#: length 296.6
  TOP w0.102: v1(220.84,77.38) 220.92,77.3 220.92,76.05 v1(223.58,73.39) ; UH1.AN2 37.99,90.2 38.11,90.08 38.11,89.66 38.26,89.5 38.26,88.91 40.93,86.24 40.93,85.08 40.47,84.62 40.47,83.83 40.5,83.81 40.5,83.35 RH226.1 v1(40.93,83.55) ; v1(13.67,111.8) 14.44,111.8 14.62,111.62 18.6,111.62 v2(18.91,111.92) RH16.1
  IN2 w0.127: v1(40.93,83.55) 41.35,83.97 46.77,83.97 47.1,84.3 50.96,84.3 52.21,85.55 59.33,85.55 59.64,85.85 61.04,85.85 61.67,85.21 66.04,85.21 70.8,89.98 72.05,89.98 75.99,93.91 80.92,93.91 84.24,97.24 87.15,97.24 87.58,97.68 87.58,98.1 88.08,98.6 113.8,98.6 114.02,98.38 117.58,98.38 119.54,96.43 129.08,96.43 130.31,97.66 130.31,99.45 133.62,102.75 137.9,102.75 141,99.65 175.45,99.65 180.5,94.6 198.65,94.6 199.55,93.7 199.55,83.22 203.79,78.98 203.79,74.89 208.18,70.51 215.85,70.51 217.31,71.96 217.31,72.49 218.64,73.82 223.15,73.82 v1(223.58,73.39)
  IN4 w0.109: v1(40.93,83.55) 39.72,84.76 35.24,84.76 34.89,85.11 31.77,85.11 31.53,85.35 26.04,85.35 25.63,85.76 25.01,85.76 24.75,86.03 21.85,86.03 19.61,88.26 19.61,89.29 19.13,89.77 18.77,89.77 17.11,91.44 17.11,92.45 16.25,93.3 16.25,93.52 15.82,93.95 15.44,93.95 14.45,92.96 13.91,92.96 13.09,93.78 13.09,100.67 12.36,101.4 12.36,107.84 12.91,108.39 12.91,110.93 13.67,111.7 v1(13.67,111.8)
  BOTTOM w0.102: Q322.2 223.58,72.63 v1(223.58,73.39) ; v1(220.84,77.38) 220.92,77.3 U46.B3
MCARD_WWAN_PWREN: length 11.3
  TOP w0.102: v1(217.89,88) 217.74,87.84 217.74,87.31 217.99,87.06 219.39,87.06 219.9,86.55 219.9,84.24 219.67,84.01 217.15,84.01 216.72,84.44 216.72,84.8 v1(217.13,85.2)
  BOTTOM w0.102: U46.B42 217.42,85.6 217.18,85.35 217.18,85.25 v1(217.13,85.2) ; v1(217.89,88) 217.89,88.45 T127.1
ME_FWP: length 254.2
  TOP w0.102: RH45.1 v1(16.04,100.24)
  IN2 w0.127: v1(189.57,96.19) 187.11,98.65 187.11,98.66 182.73,103.03 142.81,103.03 141.18,104.66 132.54,104.66 128.39,100.51 116.73,100.51 116.15,101.09 115.24,101.09 114.8,100.66 111.09,100.66 110.35,101.39 109.32,101.39 109.1,101.18 91.64,101.18 91.47,101.34 82,101.34 79.91,99.25 77.2,99.25 76.56,98.61 76.23,98.61 75.32,97.7 74.15,97.7 71.15,94.71 71.15,93.99 65.97,88.81 64.55,88.81 64.09,88.35 62.95,88.35 62.42,88.89 57.51,88.89 56.74,88.12 51.65,88.12 51.07,88.71 50.12,88.71 49.44,88.02 46.96,88.02 45.22,86.28 40.1,86.28 39.99,86.17 38.05,86.17 37.38,86.84 35.82,86.84 35.21,87.45 31.02,87.45 30.35,86.78 29.14,86.78 28.12,87.79 25.51,87.79 24.93,88.38 20.19,88.38 19.91,88.66 19.91,89.54 19.57,89.88 19.57,91.93 18.94,92.56 17.96,92.56 17.22,93.3 17.22,94.36 16.79,94.78 16.79,96.61 16.29,97.11 16.29,99.99 v1(16.04,100.24)
  BOTTOM w0.102: U46.A8 v2(218.17,74.76) 218.17,73.9 217.64,73.37 217.64,71.87 216.75,70.98 214.11,70.98 212.81,69.68 207.46,69.68 203.16,73.99 203.16,87.82 203.67,88.33 203.67,90.39 202.29,91.78 196.32,91.78 191.62,96.48 189.86,96.48 v1(189.57,96.19)
ME_SUS_PWR_ACK: length 310.6
  TOP w0.102: UH1.J4 28.25,90.65 28.54,90.36 28.54,90.1 28.35,89.91 28.35,88.73 27.43,87.8 24.88,87.8 24.45,87.38 24.45,86.64 23.93,86.12 23.33,86.12 21.96,84.75 21.79,84.75 RH91.1 21.26,83.61 v1(21.32,83.55) 21.32,83.25 RH75.2
  IN2 w0.127: v1(21.32,83.55) 21.32,83.81 23.02,85.51 31,85.51 31.67,86.18 34.68,86.18 35.96,84.9 40.51,84.9 40.63,85.01 46.37,85.01 48.09,86.73 57.14,86.73 58.03,87.62 60.71,87.62 62.1,86.23 65.4,86.23 70.16,90.99 71.63,90.99 75.58,94.94 79.37,94.94 80.7,96.28 81.06,96.28 82.27,97.48 82.27,97.85 83.59,99.17 86.49,99.17 86.93,99.62 114.22,99.62 114.44,99.4 118.99,99.4 119.79,98.6 120.28,98.6 120.48,98.4 121.03,97.85 123.32,97.85 124.11,98.64 128.06,98.64 133.19,103.77 138.69,103.77 141.01,101.45 181.95,101.45 v1(182.04,101.53)
  IN3 w0.127: v1(116.29,168.08) 116.5,168.08 119.45,165.14 123.75,165.14 125.92,162.96 128.81,162.96 129.14,162.63 136.26,162.63 138.37,160.52 140.75,158.14 144.73,158.14 147.16,155.71 147.16,154.78 150.38,151.56 151.27,151.56 154.19,148.64 154.38,148.45 154.38,146.9 156.04,145.24 156.04,142.8 159.06,139.78 159.06,132.92 161.3,130.68 164.41,130.68 167.27,127.82 167.27,125.21 174.76,117.71 174.76,108.92 182.04,101.65 v1(182.04,101.53)
  BOTTOM w0.102: U51.A8 109.54,156.77 109.61,156.7 110.04,156.7 111.26,157.92 113.32,157.92 115.86,160.46 v2(115.86,166.55) 115.86,167.65 v1(116.29,168.08)
MEC_XTAL1: length 7.4
  BOTTOM w0.102: U51.A61 106,162.36 106.22,162.58 v2(106.22,163.66) 106.68,164.12 108.03,164.12 108.95,165.04 C743.1 108.95,166.22 Y6.1
MEC_XTAL2: length 7
  BOTTOM w0.102: U51.A62 106.5,162.56 107.72,163.78 v2(107.84,163.78) 108.01,163.78 108.72,164.49 108.85,164.49 C741.1 109.81,166.22 Y6.2
MEM_SMBCLK: length 20.1
  TOP w0.102: QH4.6 18.31,88.06 18.93,87.44 v2(20.82,87.44) 22.34,87.44 v1(22.51,87.62) ; v1(30.21,93.2) 30.52,93.51 UH1.R10
  IN1 w0.089: v1(30.21,93.2) 30.45,93.2 30.57,93.07 30.57,91.68 30.11,91.22 30.11,90.92 30.08,90.89 30.08,90.87
  IN1 w0.109: 30.08,90.87 30.08,89.95 27.18,87.05 26.65,87.05 26.1,86.5 23.45,86.5 23.21,86.74 23.21,87.18 22.94,87.44 22.69,87.44 v1(22.51,87.62)
  BOTTOM w0.102: RPH5.1 21.84,87.65 21.98,87.51 22.41,87.51 v1(22.51,87.62)
MEM_SMBDATA: length 19.6
  TOP w0.102: v1(22.51,87.03) 22.34,87.21 21.08,87.21 20.98,87.11 19.8,87.11 19.61,86.92 QH4.3 ; UH1.U11 31.38,94.1 v1(31.12,93.84)
  IN1 w0.089: v1(31.12,93.84) 30.72,93.44 30.72,93.18 30.75,93.15 30.75,91.61 30.29,91.15 30.29,90.92 30.32,90.89 30.32,90.87
  IN1 w0.109: v1(22.51,87.03) 22.69,87.21 22.84,87.21 22.97,87.08 22.97,86.65 23.35,86.27 26.2,86.27 26.75,86.82 27.28,86.82 30.32,89.86 30.32,90.87
  BOTTOM w0.102: RPH5.2 21.85,87.15 21.98,87.29 22.26,87.29 v1(22.51,87.03)
MIIC_SCL0: length 7.9
  BOTTOM w0.102: R1990.1 82.65,153.53 v2(82.13,153.01) 81.3,152.18 79.47,152.18 78.48,151.19 78,151.19 77.49,150.68 U23.48
MIIC_SDA0: length 5
  BOTTOM w0.102: U23.47 77.09,150.78 77.2,150.89 77.37,150.89 77.9,151.42 78.23,151.42 v2(79.05,152.24) 79.42,152.61 R1993.2
MINI1CLK_REQ#: length 277.6
  TOP w0.102: UH1.AB1 33.1,89.35 33.1,87.21 31.98,86.09 31.61,86.09 31.33,85.81 31.33,83.37 RH123.1 31.28,82.41 31.28,81.32 v1(30.77,80.81)
  IN2 w0.127: v1(253.53,86.2) 253.52,86.2 246.73,79.41 240.25,79.41 234.99,74.15 227.64,74.15 224.98,71.49 223.52,71.49 222.71,70.67 220.59,70.67 219.88,71.38 218.53,71.38 218.48,71.33 218.12,71.33 216.27,69.49 207.75,69.49 202.73,74.52 202.73,78.57 198.46,82.84 198.46,88.91 194.29,93.08 179.87,93.08 179.23,93.71 162.26,93.71 158.83,97.14 155,97.14 154.31,97.83 139.73,97.83 138.66,98.89 134.74,98.89 133.3,97.45 133.3,96.7 131,94.4 118.39,94.4 117.17,95.62 115.59,95.62 114.99,95.02 113.99,95.02 113.35,95.65 89.91,95.65 87.71,93.46 86.21,93.46 84.88,92.13 84.88,89.76 80.01,84.88 69.25,84.88 67.3,82.93 53.89,82.93 51.3,80.34 46.78,80.34 46.57,80.12 35.24,80.12 34.91,80.45 34.3,80.45 34.2,80.35 31.23,80.35 v1(30.77,80.81)
  BOTTOM w0.102: v1(253.53,86.2) JMINI2.7
MINI2CLK_REQ#: length 164
  TOP w0.102: v1(35.85,82.92) 35.39,83.37 35.39,84.62 RH124.1 35.85,85.74 v2(35.42,86.16) 35.26,86.32 35.26,87.89 34.96,88.2 34.96,89.55 34.85,89.66 34.85,89.92 35.04,90.11 35.04,90.36 34.76,90.65 UH1.AE4
  IN1 w0.109: v1(133.94,101.97) 132.09,103.82 132.09,114.79 127.85,119.04 127.85,129.3 131.91,133.36 132.8,133.36 v1(134.25,134.81)
  IN2 w0.127: v1(35.85,82.92) 35.9,82.87 41.11,82.87 41.39,82.59 43.52,82.59 43.87,82.23 46.09,82.23 47.65,83.79 52.24,83.79 53.16,84.71 66.25,84.71 71.01,89.47 72.26,89.47 76.2,93.41 81.13,93.41 84.45,96.73 88.12,96.73 88.82,97.43 114.25,97.43 114.51,97.18 117.91,97.18 119.17,95.92 129.39,95.92 131.12,97.65 131.12,99.22 133.87,101.97 v1(133.94,101.97)
  BOTTOM w0.102: v1(134.25,134.81) 134.25,140.33 134.86,140.94 JMINI4.7
MINI3CLK_REQ#: length 130.9
  TOP w0.089: v1(30.79,89.29) 30.79,89.91 31.1,90.22 UH1.T3
  IN1 w0.109: v1(107.83,130.64) 108.43,130.05 108.43,126.9 105,123.48 105,119.73 107.43,117.3 107.43,112.68 108.62,111.49 108.62,107.88 107.4,106.67 107.4,103.88 v1(106.16,102.64)
  IN2 w0.127: v1(30.79,89.29) 30.82,89.27 36.84,89.27 38.37,87.73 43.02,87.73 43.26,87.97 45.29,87.97 49.66,92.34 63.11,92.34 66.97,96.2 67.97,96.2 69.03,97.27 70.09,97.27 71.76,98.94 72.04,98.94 74.14,101.04 79.37,101.04 81.36,103.03 89.34,103.03 89.81,103.5 93.39,103.5 94.26,102.64 v1(106.16,102.64)
  BOTTOM w0.102: v1(30.79,89.29) 31.17,88.91 31.17,88.1 30.77,87.69 v2(30.77,86.97) RH254.1 ; JMINI3.7 115.35,133.72 112.28,130.64 v1(107.83,130.64)
MOD_MD: length 204.6
  TOP w0.102: v1(112.2,117.83) 111.54,118.49 R808.2 ; v1(38.03,28.52) 39.23,29.72 39.23,31.58 39.44,31.8 Q81.1 39.72,32.08 38.05,33.75 JODD1.11
  IN1 w0.109: v1(119.64,92.95) 119.21,92.52 118.86,92.52 117.49,93.89 116.45,93.89 115.69,94.65 115.69,96.2 114.93,96.96 114.93,100.22 115.71,101 115.71,106.79 114.97,107.53 114.97,109.74 112.2,112.51 v1(112.2,117.83)
  IN4 w0.109: v1(119.64,92.95) 119.64,72.95 114.12,67.43 114.12,42.69 107.14,35.71 96.46,35.71 93.76,33.01 93.76,29.59 92.7,28.53 92.7,26.17 92.21,25.68 89.72,25.68 75.44,11.4 75.44,10.28 72.07,6.91 48.81,6.91 42.09,13.63 42.09,24.21 38.03,28.27 v1(38.03,28.52)
  BOTTOM w0.102: v1(38.03,28.52) v4(39.11,28.52)
MODC_EN: length 358.7
  TOP w0.102: Q81.5 42.17,31.15 v1(42.29,31.04) 42.29,30.96 42.71,30.54 42.71,30.02 v2(42.68,30) 42.68,29.31 43.24,28.75 43.83,28.75 44.28,29.2 44.28,29.78 44.02,30.04 44.02,30.52 43.88,30.66 U57.3 ; v1(219.79,74.51) 219.77,74.51 218.92,75.36 v1(218.92,77.37)
  IN1 w0.109: v1(219.79,74.51) 220.23,74.94 220.23,75.19 220.56,75.52 221.71,75.52 222.24,75 244.28,75 246.87,77.59 251.42,77.59 253.78,79.95 261,79.95 271.23,69.71 271.23,46.89 264.24,39.9 258.93,39.9 256.79,37.76 251.44,37.76 250.26,36.58 236.58,36.58 222.35,22.35 196.01,22.35 195.2,21.54 132.33,21.54 131.74,22.14 107.34,22.14 103.79,25.69 89.26,25.69 88.91,26.03 84.65,26.03 76.79,18.18 76.79,14.99 72.68,10.88 56.47,10.88 52.76,14.59 50.28,14.59 49.44,15.43 48.99,15.43 48.29,14.73 46.49,14.73 45.97,15.25 45.97,17.8 44.17,19.6 44.17,25.37 41.73,27.81 41.73,30.48 v1(42.29,31.04)
  BOTTOM w0.102: R514.1 219.62,74.33 v1(219.79,74.51) ; v1(218.92,77.37) U46.B7
MODC_EN#: length 4
  TOP w0.102: Q81.2 Q81.3 40.17,30.06 R515.2 39.26,28.42 v2(39.26,27.72)
MODE: length 3.3
  TOP w0.102: R63.2 27.85,158.96 R58.2 27.54,158.41 v2(26.89,158.41) 26.4,158.41 26.27,158.54 U9.53
MSATA_PCIE_PIN51: length 1.1
  BOTTOM w0.102: T119.1 224.41,81.02 U46.A57
MSATA_PRX_WANTX_N4_RP: length 2.8
  BOTTOM w0.102: U637.12 219.73,65.56 219.87,65.7 220.24,65.7 220.43,65.89 220.45,65.89 220.84,66.28 221.36,66.28 C538.2
MSATA_PRX_WANTX_N4_RP_C: length 43.1
  IN1 w0.117: v1(223.96,66.08) 224.16,66.28 224.82,66.28 225.49,65.61 231.78,65.61 236.79,70.62 242.79,70.62 243.39,71.22 247.4,71.22 248.72,72.55 251.97,72.55 253.5,74.08 254.16,74.08 256.17,76.08 257.96,76.08 v1(258.17,75.87)
  BOTTOM w0.102: v1(258.17,75.87) 258.36,76.07 259.2,76.07 259.47,75.8 JMINI2.25 ; v1(223.96,66.08) 223.75,66.29 222.95,66.29 C538.1
MSATA_PRX_WANTX_P4_RP: length 2.8
  BOTTOM w0.102: C537.2 221.36,66.5 220.74,66.5 v3(220.47,66.24) 220.15,65.92 219.91,65.92 219.77,66.06 U637.11
MSATA_PRX_WANTX_P4_RP_C: length 43.1
  IN1 w0.117: v1(223.96,66.71) 224.16,66.51 224.92,66.51 225.59,65.85 231.68,65.85 236.69,70.86 242.69,70.86 243.29,71.46 247.3,71.46 248.62,72.78 251.88,72.78 253.41,74.31 254.06,74.31 256.07,76.32 257.98,76.32 v1(258.17,76.51)
  BOTTOM w0.102: v1(223.96,66.71) 223.75,66.5 222.95,66.5 C537.1 ; v1(258.17,76.51) 258.39,76.29 259.19,76.29 259.5,76.6 JMINI2.23
MSATA_PTX_WANRX_N4_RP: length 2.7
  BOTTOM w0.102: C539.2 221.37,64.73 221.08,64.73 220.79,64.43 220.25,64.43 220.24,64.42 219.92,64.42 219.78,64.56 U637.14
MSATA_PTX_WANRX_N4_RP_C: length 42.5
  IN1 w0.117: v1(258.58,73.3) 258.38,73.1 255.19,73.1 255.18,73.11 253.5,73.11 252.31,71.92 249.21,71.92 248.45,71.16 248.45,70.42 247.8,69.78 246.53,69.78 246.39,69.92 244.49,69.92 243.17,68.6 235.75,68.6 232.12,64.97 225.77,64.97 225.53,64.73 223.63,64.73 v1(223.43,64.93)
  BOTTOM w0.102: JMINI2.31 259.5,73.4 259.19,73.09 258.8,73.09 v1(258.58,73.3) ; v1(223.43,64.93) 223.22,64.72 222.95,64.72 C539.1
MSATA_PTX_WANRX_P4_RP: length 2.7
  BOTTOM w0.102: C540.2 221.36,64.51 221.17,64.51 220.86,64.2 v3(220.53,64.2) 219.92,64.2 219.78,64.06 U637.15
MSATA_PTX_WANRX_P4_RP_C: length 42.5
  IN1 w0.117: v1(223.43,64.3) 223.63,64.5 225.63,64.5 225.87,64.73 232.22,64.73 235.85,68.36 243.27,68.36 244.59,69.68 246.29,69.68 246.43,69.54 247.9,69.54 248.68,70.32 248.68,71.06 249.31,71.68 252.4,71.68 253.6,72.88 255.08,72.88 255.09,72.87 258.38,72.87 v1(258.58,72.67)
  BOTTOM w0.102: C540.1 222.95,64.51 223.22,64.51 v1(223.43,64.3) ; v1(258.58,72.67) 258.78,72.87 259.2,72.87 259.47,72.6 JMINI2.33
MSCLK: length 135
  TOP w0.102: v1(166.43,115.36) 166.57,115.5 167.23,115.5 167.46,115.74 JDEG2.5 171.15,115.74 R847.2 ; v1(106.82,138.87) 106.82,140.99 104.92,142.89 95.77,142.89 93.02,145.63 93.02,152.17 v2(92.85,152.34) 92.29,152.91 v1(92.29,152.97)
  IN1 w0.109: v1(140.2,148.84) 144.61,144.43 144.61,139.66 153.98,130.29 154.23,130.29 155.47,129.05 155.47,127.3 160.82,121.95 160.82,121.44 163.56,118.7 163.56,118.2 165.45,116.31 165.45,116.07 165.72,115.8 166,115.8 v1(166.43,115.36)
  IN3 w0.127: v1(140.2,148.84) 137.13,151.92 133.99,151.92 133.02,150.95 129.41,150.95 126.7,153.66 119.43,153.66 117.8,155.28 109.77,155.28 109.11,155.94 101.28,155.94 v1(100.49,156.73) 99.77,156 95.39,156 93,153.62 92.82,153.62 92.29,153.08 v1(92.29,152.97)
  BOTTOM w0.102: v1(100.49,156.73) 100.11,156.35 99.5,156.35 99.33,156.52 U51.B43 ; JMINI3.19 107.35,136.41 106.82,136.94 v1(106.82,138.87)
MSDATA: length 144.1
  TOP w0.102: v1(111.15,141.17) 110.92,141.4 106.73,141.4 105.02,143.11 95.86,143.11 93.25,145.72 93.25,152.56 v1(92.87,152.94) ; JDEG2.4 167.41,115.24 166.85,114.68 166.44,114.68 v1(166.43,114.69)
  IN1 w0.109: v1(166.43,114.69) 165.9,114.69 164.98,115.62 164.98,116.12 163.09,118 163.09,118.5 160.34,121.25 160.34,121.76 155,127.1 155,128.85 154.04,129.81 153.79,129.81 153.78,129.82 144.14,139.46 144.14,143.99 139.58,148.55 138.74,148.55 v1(138.73,148.56)
  IN3 w0.127: v1(138.73,148.56) 135.63,151.66 134.1,151.66 133.13,150.7 129.3,150.7 126.6,153.4 119.08,153.4 118.09,154.39 115.55,154.39 115.3,154.14 113.8,154.14 112.96,154.98 109.62,154.98 109.5,155.09 106.35,155.09 106.27,155.17 98.62,155.17 98.05,155.74 96.76,155.74 v1(96,154.98) 94.69,153.67 93.59,153.67 v1(92.87,152.94)
  BOTTOM w0.102: v1(138.73,148.56) 139.96,147.33 143.61,147.33 147.27,143.67 R706.2 ; U51.A40 97.37,156.27 v2(97.23,156.14) 96.71,155.61 R869.2 v1(96,154.98) ; v1(111.15,141.17) 111.83,141.17 112.55,141.89 JMINI3.14
MUX_AUX: length 18.5
  TOP w0.102: v1(32.75,161.91) 32.38,162.28 Q335.1 ; v1(26.78,157.85) 26.49,158.14 U9.52 25.19,158.14 25.05,158 25.05,157.47 25.18,157.33 U9.50 ; v1(32.37,156.5) 32.55,156.68 33.1,156.68 33.18,156.6 U629.32
  IN4 w0.109: v1(32.75,161.91) 32.75,160.46 33.22,159.99 33.22,157.04 32.86,156.68 32.55,156.68 v1(32.37,156.5) 32.21,156.66 29.89,156.66 29.57,156.98 27.96,156.98 27.68,156.7 27.14,156.7 26.78,157.06 v1(26.78,157.85)
MUX_AUX#: length 20
  TOP w0.102: U629.31 33.18,157 33.1,156.91 32.57,156.91 v1(32.37,157.11) ; U9.51 26.26,157.74 26.56,157.44 v1(27.21,157.44) 27.36,157.29 27.36,156.32 27.26,156.22 27.11,156.22 27.01,156.32 27.01,156.91 26.88,157.03 26.35,157.03 26.25,156.93 U9.49 ; v1(30.82,159.62) 30.9,159.7 30.9,159.91 30.75,160.06 Q335.4
  IN4 w0.109: v1(27.21,157.44) 27.12,157.44 27.02,157.34 27.02,157.16 27.23,156.94 27.58,156.94 27.86,157.22 29.67,157.22 29.99,156.9 30.44,156.9 30.55,157.01 30.88,157.01 30.99,156.9 31.32,156.9 31.43,157.01 31.76,157.01 31.87,156.9 32.18,156.9 32.37,157.08 v1(32.37,157.11) 32.56,156.91 32.76,156.91 32.99,157.14 32.99,159.89 32.59,160.28 31.48,160.28 v1(30.82,159.62)
MUX_CA_DET: length 38.5
  TOP w0.102: U629.48 32.95,150.2 v1(32.88,150.12) ; v1(33.52,143.66) v2(33,143.14) 33,142.7 34.31,141.39 R82.1 37.45,141.59 37.73,141.59 38.21,142.07 38.74,142.07 39.02,141.79 Q346.2 ; v1(20.81,162.6) 20.76,162.55 20.76,161.93 20.96,161.73 20.96,161.3 20.86,161.2 U9.11
  IN1 w0.109: v1(33.52,143.66) 33.52,146.94 34.02,147.43 34.02,148.98 v1(32.88,150.12)
  IN4 w0.109: v1(20.81,162.6) 20.63,162.42 20.63,162.06 22.64,160.06 23.45,160.06 25.27,158.23 25.27,154.53 29.68,150.12 v1(32.88,150.12)
MUX_CEXT: length 2.9
  TOP w0.203: U629.47 32.73,150.6 32.23,150.1 31.56,150.1 C97.2
MUX_D0: length 26.8
  TOP w0.102: C505.1 25.35,165.17 25.35,165.71 25.75,166.11 v1(26.07,166.11) ; v1(32.37,150.89) 32.56,151.08 33.13,151.08 33.21,151 U629.46
  IN3 w0.127: v1(26.07,166.11) 25.82,166.11 25.66,165.95 25.66,165.65 25.84,165.47 26.81,165.47 27.87,166.53 29.63,166.53 33.56,162.6 33.56,151.49 33.11,151.04 32.53,151.04 v1(32.37,150.89)
MUX_D0#: length 26.8
  TOP w0.102: v1(25.59,166.56) 25.59,166.25 25.14,165.8 25.14,165.17 C506.1 ; U629.45 33.24,151.4 33.13,151.29 32.55,151.29 v1(32.37,151.47)
  IN3 w0.127: v1(25.59,166.56) 25.66,166.48 25.66,166.3 25.41,166.05 25.41,165.54 25.73,165.22 26.91,165.22 27.98,166.28 29.52,166.28 33.31,162.5 33.31,151.6 33,151.29 32.55,151.29 v1(32.37,151.47)
MUX_D0#_C: length 4
  TOP w0.102: U9.4 23.66,161.13 23.75,161.22 23.75,162.01 v3(24.6,162.85) 25.12,163.37 25.12,163.6 C506.2
MUX_D0_C: length 4.1
  TOP w0.102: U9.3 24.06,161.13 23.97,161.22 23.97,161.92 24.55,162.49 24.56,162.49 24.95,162.88 24.95,162.9 25.33,163.28 25.33,163.56 C505.2
MUX_D1: length 3.5
  TOP w0.102: U629.43 33.22,152.2 33.13,152.28 32.62,152.28 32.21,151.88 32.19,151.88 31.96,151.65 31.96,151.19 31.77,151 31.57,151 C507.1
MUX_D1#: length 3.5
  TOP w0.102: U629.42 33.24,152.6 33.14,152.5 32.51,152.5 v3(32.24,152.23) 31.75,151.74 31.75,151.28 31.68,151.22 31.56,151.22 C508.1
MUX_D1#_C: length 19
  TOP w0.102: v1(22.36,162.01) 22.55,161.82 22.55,161.22 22.46,161.13 U9.7 ; C508.2 30.03,151.27 29.85,151.27 v1(29.63,151.5)
  IN3 w0.127: v1(22.36,162.01) 22.54,162.19 22.54,162.47 22.79,162.72 23.68,162.72 24.67,161.74 24.67,154.72 28.05,151.34 29.47,151.34 v1(29.63,151.5)
MUX_D1_C: length 19
  TOP w0.102: C507.2 30.31,150.96 30.22,151.05 29.89,151.05 v1(29.63,150.79) ; U9.6 22.86,161.13 22.77,161.22 22.77,161.81 v1(22.97,162.01)
  IN3 w0.127: v1(29.63,150.79) 29.63,150.96 29.5,151.09 27.95,151.09 24.42,154.62 24.42,161.63 23.58,162.47 22.9,162.47 22.79,162.37 22.79,162.19 v1(22.97,162.01)
MUX_D2: length 3
  TOP w0.102: C509.1 31.56,152.77 31.82,152.77 32.24,153.19 32.26,153.19 32.56,153.49 33.12,153.49 33.21,153.4 U629.40
MUX_D2#: length 3
  TOP w0.102: U629.39 33.22,153.8 33.13,153.71 32.46,153.71 v3(32.29,153.54) 31.73,152.98 31.57,152.98 C510.1
MUX_D2#_C: length 20.4
  TOP w0.102: v1(21.17,162.11) 21.36,161.92 21.36,161.25 21.26,161.15 U9.10 ; C510.2 30.04,153.06 29.84,153.06 v1(29.63,153.27)
  IN3 w0.127: v1(29.63,153.27) 29.47,153.12 27.37,153.12 25.43,155.05 25.43,162.06 24.01,163.48 21.87,163.48 21.33,162.94 21.33,162.28 v1(21.17,162.11)
MUX_D2_C: length 20.4
  TOP w0.102: C509.2 30.31,152.74 30.21,152.84 29.9,152.84 v1(29.63,152.56) ; U9.9 21.66,161.14 21.57,161.22 21.57,161.94 v1(21.75,162.11)
  IN3 w0.127: v1(21.75,162.11) 21.58,162.28 21.58,162.84 21.98,163.23 23.91,163.23 25.18,161.96 25.18,154.95 27.26,152.87 29.5,152.87 29.63,152.74 v1(29.63,152.56)
MUX_D3: length 3
  TOP w0.102: C511.1 31.56,155.43 31.68,155.43 31.96,155.16 31.96,155.14 32.33,154.77 32.35,154.77 32.43,154.69 33.13,154.69 33.22,154.6 U629.37
MUX_D3#: length 3
  TOP w0.102: C512.1 31.57,155.65 31.77,155.65 v3(32.3,155.12) 32.51,154.91 33.11,154.91 33.2,155 U629.36
MUX_D3#_C: length 21.3
  TOP w0.102: U9.13 20.06,161.13 20.14,161.21 20.14,161.37 v1(19.95,161.55) ; C512.2 30.03,155.71 29.85,155.71 v1(29.63,155.94)
  IN3 w0.127: v1(29.63,155.94) 29.47,155.78 28.76,155.78 28.56,155.58 26.45,155.58 26.19,155.84 26.19,162.39 24.34,164.24 20.94,164.24 20.13,163.43 20.13,161.74 v1(19.95,161.55)
MUX_D3_C: length 21.3
  TOP w0.102: C511.2 30.31,155.38 30.2,155.5 29.89,155.5 v1(29.63,155.23) ; v1(20.56,161.55) 20.35,161.35 20.35,161.2 20.46,161.09 U9.12
  IN3 w0.127: v1(20.56,161.55) 20.38,161.74 20.38,163.33 21.04,163.99 24.24,163.99 25.94,162.29 25.94,155.74 26.35,155.33 28.66,155.33 28.86,155.53 29.5,155.53 29.63,155.41 v1(29.63,155.23)
MUX_HPD: length 19.3
  TOP w0.102: U629.44 v1(32.88,151.8) ; U9.5 v1(23.26,161.5)
  IN4 w0.109: v1(32.88,151.8) 30.97,153.71 26.7,153.71 25.51,154.9 25.51,159.25 v1(23.26,161.5)
  BOTTOM w0.102: v2(33.9,151.01) 33.12,151.8 v1(32.88,151.8)
MUX_PC0: length 7.3
  TOP w0.102: R98.1 31.82,154.21 v1(31.83,154.2) U629.38
  BOTTOM w0.102: v2(31.8,149.88) 31.23,150.45 R115.1 31.23,153.59 v1(31.83,154.2)
MUX_PC1: length 4.8
  TOP w0.102: R99.1 35.21,144.56 35.21,145.65 R116.1 v2(35.72,147.2) 35.72,147.33 36.03,147.64 U629.55
MUX_PI0: length 6.1
  TOP w0.102: v2(36.74,143.34) 37.25,143.85 R124.1 37.25,144.66 37.45,144.87 37.45,145.71 R123.1 36.38,146.77 36.38,148.17 36.43,148.22 U629.56
MUX_REXT: length 5.3
  TOP w0.102: v2(32.22,158.29) 32.2,158.28 R96.2 31.76,157.74 31.76,156.74 31.96,156.54 31.96,156.32 32.52,155.76 33.16,155.76 33.19,155.8 U629.34
MXM_ALERT#: length 7.4
  TOP w0.102: v1(119.05,97.92) 119,97.87 JMXM1.58
  BOTTOM w0.102: v2(116.62,103.15) 117.75,102.02 Q5.3 117.75,100.69 117.81,100.62 R4.2 117.81,99.16 v1(119.05,97.92)
MXM_BIA_PWM: length 108.2
  TOP w0.102: JMXM1.63 117.75,105.7 117.05,106.4 117.05,107.17 117.29,107.41 117.29,113.59 v2(115.5,115.38) v1(114.46,116.42)
  IN3 w0.127: v1(52.13,152.31) 52.18,152.26 52.18,149.49 52.05,149.36 52.05,148.22 52.1,148.17 52.1,146.9 53.07,145.93 55.63,145.93 58.38,148.68 66.95,148.68 71.43,153.15 77.1,153.15 77.37,152.89 78.84,152.89 80.5,151.23 85.2,151.23 91.14,145.29 91.14,139.26 97.92,132.48 98.5,132.48 102.35,128.64 102.35,127.62 104.38,125.59 104.38,123.01 106.75,120.64 107.87,120.64 108.68,119.83 108.68,119.59 112.33,115.94 113.98,115.94 v1(114.46,116.42)
  BOTTOM w0.102: U3.2 50.07,152.28 50.33,152.03 51.85,152.03 v1(52.13,152.31)
MXM_CLK_REQ#: length 14.6
  TOP w0.102: JMXM1.182 v1(86,95.13)
  BOTTOM w0.102: v1(86,95.13) 86,95.99 87.23,97.22 v2(87.59,97.22) 87.99,97.22 89.16,98.38 89.59,98.38 89.85,98.64 89.85,99.3 89.52,99.63 88.12,99.63 87.41,98.92 86.78,98.92 86.52,99.17 86.52,99.78 87.41,100.67 R1978.2
MXM_CRT_BLU: length 69.7
  TOP w0.102: v1(86.8,103.55) 86.8,103.55 85.54,103.55 82.03,100.03 82.03,99.25 81.5,98.72 JMXM1.200
  IN1 w0.109: v1(86.8,103.55) 86.8,104.47 86.33,104.94 86.33,108.55 85.72,109.16 85.72,110.77 88.05,113.09 88.05,116.14 90.53,118.63 90.53,121.09 89.28,122.35 89.28,125.76 91.22,127.7 91.22,128.05 90.76,128.51 90.76,129.25 90.46,129.55 90.46,130.76 89.66,131.56 89.66,134.24 90.13,134.71 90.13,137.41 89.46,138.08 89.46,142.45 88.89,143.02 88.89,154.35 86.98,156.26 v1(86.98,156.73)
  BOTTOM w0.102: v1(86.98,156.73) 86.95,156.75 U19.9
MXM_CRT_DDC_CLK: length 73.7
  TOP w0.102: v1(84.92,97.93) 84.5,97.51 JMXM1.188
  IN1 w0.109: v1(87.92,158.46) 87.74,158.29 86.96,158.29 85.86,157.19 85.86,154.54 87.76,152.64 87.76,146.45 85.71,144.41 85.71,141.12 86.87,139.97 86.87,138.09 88.35,136.61 88.35,131.3 89,130.65 89,128 88.17,127.17 88.17,121.62 88.81,120.99 88.81,118.51 86.51,116.21 86.51,113.19 84.6,111.28 84.6,108.68 84.92,108.36 84.92,104.79 85.62,104.08 85.62,103.59 85.1,103.06 85.1,98.11 v1(84.92,97.93)
  BOTTOM w0.102: v1(87.92,158.46) 87.74,158.28 86.6,158.28 86.53,158.35 U19.5 ; v1(84.92,97.93) 84.49,98.36 83.94,98.36 83.55,98.75 83.55,99.07 R5.2
MXM_CRT_DDC_DAT: length 73.6
  TOP w0.102: JMXM1.186 85,97.42 v1(85.51,97.93)
  IN1 w0.109: v1(85.51,97.93) 85.33,98.1 85.33,102.96 85.86,103.49 85.86,104.18 85.16,104.88 85.16,108.46 84.84,108.78 84.84,111.18 86.75,113.09 86.75,116.11 89.04,118.41 89.04,121.08 88.41,121.72 88.41,127.07 89.24,127.9 89.24,130.75 88.59,131.4 88.59,136.71 87.11,138.19 87.11,140.07 85.95,141.22 85.95,144.31 87.99,146.35 87.99,152.74 86.1,154.64 86.1,157.09 87.06,158.05 87.74,158.05 v1(87.92,157.87)
  BOTTOM w0.102: v1(85.51,97.93) 85.1,98.33 84.84,98.33 84.58,98.59 84.03,98.59 83.78,98.84 83.78,99.07 R3.2 ; U19.6 86.55,157.95 86.65,158.05 87.74,158.05 v1(87.92,157.87)
MXM_CRT_GRN: length 72.4
  TOP w0.102: JMXM1.198 82,98.36 82.63,98.99 82.63,99.78 85.63,102.78 87.14,102.78 v1(87.92,103.56)
  IN1 w0.109: v1(87.92,103.56) 87.92,104.48 87.18,105.22 87.18,108.57 86.34,109.41 86.34,109.84 89.01,112.51 89.01,113.57 90.2,114.77 90.2,117.33 91.41,118.54 91.41,121.18 90.15,122.44 90.15,125.76 91.84,127.44 91.84,128.31 91.38,128.77 91.38,129.5 91.08,129.81 91.08,131.02 90.27,131.82 90.27,133.98 90.75,134.45 90.75,137.66 90.07,138.34 90.07,142.71 89.5,143.28 89.5,154.61 88.23,155.88 88.23,156.11 v1(87.61,156.73)
  BOTTOM w0.102: v1(87.61,156.73) 87.19,157.15 U19.8 ; v1(87.92,103.56) 87.92,104.14 v2(87.41,104.65)
MXM_CRT_HSYNC: length 78.9
  TOP w0.102: JMXM1.192 83.5,96.08 84.88,94.7 86.21,94.7 v1(86.59,95.09)
  IN1 w0.109: v1(86.59,95.09) 86.61,95.11 87.99,95.11 90.69,97.8 90.69,108.49 91.73,109.54 91.73,111.54 93.73,113.55 93.73,114.64 93.06,115.32 93.06,121.87 92.04,122.88 92.04,125.31 93.83,127.1 93.83,129.65 93.65,129.82 93.65,136.36 92.49,137.52 92.49,138.25 91.72,139.02 91.72,143.39 91.15,143.96 91.15,156.7 88.29,159.56 87.33,159.56 v1(86.93,159.15)
  BOTTOM w0.102: U19.3 v1(86.93,159.15)
MXM_CRT_RED: length 71.9
  TOP w0.102: v1(88.55,103.56) 88.55,103.33 87.25,102.02 85.74,102.02 83.24,99.53 83.24,98.74 82.5,98 JMXM1.196
  IN1 w0.109: v1(88.55,103.56) 88.55,104.72 87.8,105.47 87.8,107.93 87.97,108.1 87.97,110.12 92.03,114.18 92.03,121.44 90.77,122.69 90.77,125.5 92.79,127.53 92.79,129.22 92.62,129.4 92.62,130.99 90.89,132.72 90.89,133.73 91.36,134.2 91.36,137.92 90.69,138.59 90.69,142.96 90.12,143.53 90.12,155.19 88.58,156.73 v1(88.23,156.73)
  BOTTOM w0.102: U19.7 87.65,157.55 88.23,156.97 v1(88.23,156.73)
MXM_CRT_VSYNC: length 77.5
  TOP w0.102: JMXM1.190 84,96.16 85.05,95.11 v1(85.38,95.11)
  IN1 w0.109: v1(87.51,159.14) 88.12,159.14 90.74,156.53 90.74,143.79 91.31,143.22 91.31,138.85 91.98,138.17 91.98,133.73 91.82,133.56 91.82,132.66 93.24,131.24 93.24,129.65 93.41,129.48 93.41,127.27 91.63,125.48 91.63,122.71 92.64,121.7 92.64,113.5 90.85,111.71 90.43,111.71 89.85,111.13 89.85,109.23 89.17,108.55 89.17,102.1 86.34,99.27 86.34,96.71 85.91,96.28 85.91,95.64 v1(85.38,95.11)
  BOTTOM w0.089: 87.56,159.14 v1(87.51,159.14)
  BOTTOM w0.102: v2(88.02,161.01) 88.02,159.6 87.56,159.14 ; U19.4 87.12,158.75 v1(87.51,159.14)
MXM_DP_HDMI_HPD: length 198.9
  TOP w0.102: v1(220.76,74.51) 220.71,74.51 220.3,74.92 220.3,76 220.35,76.05 220.35,77.5 v1(220.81,77.96) 220.48,77.96 216.77,81.67 216.77,81.89 215.05,83.62 215.05,83.93 214.71,84.26 214.31,84.26 213.47,85.1 213.47,86.22 213.11,86.57 213.11,88.28 v1(211.06,90.33)
  IN2 w0.127: v1(58.66,102.84) 60.38,102.84 61.89,101.33 64.36,101.33 72.1,109.07 75.51,109.07 76.12,108.46 80.21,108.46 80.94,109.19 82.13,109.19 82.44,108.89 97.94,108.89 99.97,110.92 118.32,110.92 119.43,109.81 125.84,109.81 126.5,110.48 128.71,110.48 130.25,108.94 154.78,108.94 156.6,110.75 159.72,110.75 160.36,111.4 162.76,111.4 163.69,112.33 165.46,112.33 168.44,109.36 174.81,109.36 175.37,109.92 175.9,109.92 176.39,109.43 176.39,108.69 178.07,107.01 182.36,107.01 187.63,101.74 195.57,101.74 199.2,98.11 200.03,98.11 205.24,92.9 207.48,92.9 210.04,90.33 v1(211.06,90.33)
  BOTTOM w0.102: v1(58.66,102.84) 59.82,103.99 D18.1 D7.1 58.31,105.83 D8.1 ; R17.2 221.01,74.25 v1(220.76,74.51) ; U46.B4 220.42,77.57 v1(220.81,77.96)
MXM_DPB_AUX: length 50.7
  TOP w0.102: v1(81.97,114.16) 81.85,114.03 C387.2 ; v1(72.24,113.88) 72.62,113.5 U20.12 ; v1(56.2,98.41) 56.2,98.54 56.4,98.74 56.63,98.74 56.77,98.59 56.77,97.77 56.7,97.7 56.57,97.7 56.5,97.62 JMXM1.300
  IN3 w0.127: v1(72.24,113.88) 72.24,114.19 72.04,114.39 71.54,114.39 71.18,114.03 71.18,108.42 72.53,107.08 72.53,105.91 71.48,104.86 71.48,103.6 70.65,102.78 69,102.78 67.63,101.41 66.99,101.41 65.44,99.86 65.44,98.8 63.88,97.24 57.23,97.24 56.8,97.67 56.8,98.46 56.62,98.64 56.32,98.64 56.2,98.52 v1(56.2,98.41)
  IN4 w0.109: v1(72.24,113.88) 72.24,114.34 72.38,114.48 73.14,114.48 74.19,115.53 75.1,115.53 75.71,114.93 81.84,114.93 81.97,114.79 v1(81.97,114.16)
  BOTTOM w0.102: v2(82.55,112.98) 82.55,113.59 v1(81.97,114.16)
MXM_DPB_AUX#: length 49.3
  TOP w0.102: v1(56.19,99.1) 56.32,98.97 56.72,98.97 57,98.69 JMXM1.298 ; v1(72.27,115.19) 72.53,115.45 U20.9 ; C388.2 81.42,115.96 81.85,115.96 v1(81.95,116.06)
  IN3 w0.127: v1(72.27,115.19) 72.27,114.82 72.09,114.64 71.43,114.64 70.93,114.13 70.93,108.32 72.27,106.97 72.27,106.01 71.22,104.96 71.22,103.71 70.54,103.03 68.89,103.03 67.53,101.67 66.89,101.67 65.19,99.96 65.19,98.91 63.77,97.5 57.34,97.5 57.06,97.77 57.06,98.56 56.73,98.89 56.4,98.89 v1(56.19,99.1)
  IN4 w0.109: v1(72.27,115.19) 72.27,114.82 72.38,114.72 73.04,114.72 74.09,115.77 75.2,115.77 75.81,115.17 81.84,115.17 81.95,115.27 v1(81.95,116.06)
MXM_DPB_N0: length 51.6
  TOP w0.102: JMXM1.274 63,97.57 62.89,97.67 62.89,98.17 v1(63.09,98.36)
  IN3 w0.127: v1(74.79,137.48) 74.63,137.32 74.63,136.8 77.12,134.31 77.12,127.02 78.49,125.65 78.49,121.47 74.18,117.16 74.18,116.95 73.26,116.04 72.07,116.04 70.06,114.03 70.06,107.58 70.37,107.27 70.37,105.97 64.46,100.06 63.25,100.06 62.93,99.74 62.93,98.52 v1(63.09,98.36)
  BOTTOM w0.102: C438.2 74.59,137.14 74.59,137.28 v1(74.79,137.48)
MXM_DPB_N1: length 57.7
  TOP w0.102: v1(61.79,99.05) 61.59,98.86 61.59,98.15 61.38,97.93 61.38,97.65 61.5,97.52 JMXM1.280
  IN3 w0.127: v1(61.79,99.05) 61.61,99.23 61.61,99.58 63.05,101.03 64.28,101.03 69.55,106.3 69.55,106.92 69.12,107.35 69.12,114.27 72.57,117.72 73.58,117.72 77.67,121.81 77.67,124.96 75.5,127.13 75.5,133.35 72.93,135.92 72.93,137.63 73.27,137.96 74.98,137.96 75.38,137.57 75.38,136.98 75.79,136.57 76.27,136.57 76.59,136.88 76.59,137.24 v1(76.72,137.38)
  BOTTOM w0.102: v1(76.72,137.38) 76.6,137.26 76.6,137.06 76.89,136.76 C440.2
MXM_DPB_N2: length 57.7
  TOP w0.102: JMXM1.286 60,97.57 59.89,97.67 59.89,98.17 v1(60.09,98.36)
  IN3 w0.127: v1(60.09,98.36) 59.91,98.54 59.91,99.36 62.52,101.97 64.06,101.97 67.45,105.35 67.45,113.35 66.7,114.09 66.7,132.66 72.83,138.79 76.19,138.79 77.25,137.72 77.25,137.19 77.83,136.61 78.41,136.61 78.7,136.9 78.7,137.2 v1(78.88,137.37)
  BOTTOM w0.102: v1(78.88,137.37) 78.68,137.18 78.68,137.05 78.96,136.76 C442.2
MXM_DPB_N3: length 63.6
  TOP w0.102: JMXM1.292 58.5,97.57 58.39,97.67 58.39,98.17 v1(58.59,98.36)
  IN3 w0.127: v1(80.88,137.42) 80.72,137.27 80.72,136.91 80.41,136.59 79.86,136.59 79.39,137.06 79.39,137.67 78.74,138.31 78.06,138.31 76.74,139.63 72.49,139.63 65.88,133.02 65.88,113.57 66.63,112.81 66.63,105.7 64.8,103.87 60.82,103.87 58.02,101.08 58.02,99.33 58.43,98.92 58.43,98.52 v1(58.59,98.36)
  BOTTOM w0.102: C444.2 81.01,136.76 80.69,137.09 80.69,137.23 v1(80.88,137.42)
MXM_DPB_P0: length 51.6
  TOP w0.102: v1(62.45,98.36) 62.63,98.19 62.63,97.65 62.5,97.52 JMXM1.276
  IN3 w0.127: v1(62.45,98.36) 62.63,98.54 62.63,99.86 63.13,100.37 64.34,100.37 70.06,106.09 70.06,107.15 69.76,107.45 69.76,114.15 71.95,116.34 73.14,116.34 73.87,117.08 73.87,117.29 78.18,121.6 78.18,125.52 76.81,126.89 76.81,134.19 74.32,136.68 74.32,137.3 v1(74.15,137.48)
  BOTTOM w0.102: C431.2 74.32,137.14 74.32,137.3 v1(74.15,137.48)
MXM_DPB_P1: length 57.7
  TOP w0.102: JMXM1.282 61,97.53 61.11,97.64 61.11,98.04 61.33,98.26 61.33,98.88 v1(61.15,99.05)
  IN3 w0.127: v1(76.13,137.38) 76.28,137.23 76.28,137.01 76.14,136.87 75.92,136.87 75.68,137.11 75.68,137.7 75.11,138.27 73.14,138.27 72.63,137.75 72.63,135.79 75.2,133.22 75.2,127 77.37,124.83 77.37,121.94 73.45,118.02 72.44,118.02 68.82,114.4 68.82,107.22 69.24,106.8 69.24,106.42 64.15,101.33 62.92,101.33 61.3,99.71 61.3,99.2 v1(61.15,99.05)
  BOTTOM w0.102: C439.2 76.07,136.76 76.33,137.03 76.33,137.18 v1(76.13,137.38)
MXM_DPB_P2: length 57.7
  TOP w0.102: JMXM1.288 59.5,97.52 59.63,97.65 59.63,98.19 v1(59.45,98.36)
  IN3 w0.127: v1(78.24,137.37) 78.4,137.22 78.4,137.03 78.29,136.92 77.96,136.92 77.56,137.32 77.56,137.85 76.32,139.09 72.7,139.09 66.39,132.78 66.39,113.97 67.14,113.22 67.14,105.48 63.93,102.27 62.39,102.27 59.61,99.49 59.61,98.52 v1(59.45,98.36)
  BOTTOM w0.102: C441.2 78.13,136.76 78.41,137.05 78.41,137.2 v1(78.24,137.37)
MXM_DPB_P3: length 63.7
  TOP w0.102: v1(57.95,98.36) 58.13,98.19 58.13,97.65 58,97.52 JMXM1.294
  IN3 w0.127: v1(57.95,98.36) 58.13,98.54 58.13,98.79 57.72,99.2 57.72,101.2 60.69,104.18 64.68,104.18 66.33,105.83 66.33,112.69 65.57,113.44 65.57,133.15 72.37,139.94 76.87,139.94 78.19,138.62 78.87,138.62 79.69,137.79 79.69,137.19 79.98,136.9 80.28,136.9 80.42,137.03 80.42,137.25 v1(80.25,137.42)
  BOTTOM w0.102: v1(80.25,137.42) 80.42,137.25 80.42,137.06 80.12,136.76 C443.2
MXM_DPC_AUX: length 97.9
  TOP w0.102: v1(68.2,106.62) 68.39,106.43 68.39,105.88 68.25,105.74 JMXM1.255 ; v1(35.09,163.23) 35.29,163.03 35.29,161.48 C531.1 ; v1(37.63,160.97) 37.8,160.79 37.8,159.17 37.31,158.67 37.31,158.28 37.23,158.2 U629.23 ; R21.2 42.02,138.15 42.25,137.92 43.05,137.92 43.11,137.98 43.11,138.24 42.99,138.36 v1(42.88,138.36)
  IN1 w0.109: v1(68.2,106.62) 68.38,106.79 68.38,108.24 68.25,108.37 68.25,111.72 63.3,116.68 63.3,128.75 63.57,129.03 63.57,132.94 61.15,135.37 61.15,137.75 60.61,138.29 60.61,140.5 60,141.11 58.18,141.11 56.64,142.65 55.45,142.65 55.3,142.5 53.28,142.5 53.2,142.58 51.89,142.58 49.86,140.55 48.85,140.55 45.92,137.62 43.4,137.62 43.06,137.96 43.06,138.19 v1(42.88,138.36)
  IN3 w0.127: v1(42.88,138.36) 43.09,138.58 43.09,138.94 42.98,139.05 42.67,139.05 39.68,142.03 39.68,148.75 38.6,149.83 38.6,151.96 37.79,152.78 37.79,160.81 v1(37.63,160.97)
  BOTTOM w0.102: v1(37.63,160.97) 37.8,161.15 37.8,161.91 37.14,162.57 35.52,162.57 35.29,162.8 35.29,163.03 v1(35.09,163.23)
MXM_DPC_AUX#: length 97.9
  TOP w0.102: v1(38.21,160.97) 38.03,160.79 38.03,159.07 37.53,158.57 37.53,158.32 37.63,158.22 U629.22 ; C532.1 35.52,161.48 35.52,163.03 v1(35.72,163.23) ; JMXM1.253 68.75,105.77 68.62,105.9 68.62,106.43 v1(68.81,106.62) ; R20.2 42.26,137.69 43.14,137.69 43.34,137.89 43.34,138.19 v1(43.52,138.36)
  IN1 w0.109: v1(43.52,138.36) 43.3,138.14 43.3,138.06 43.5,137.86 45.83,137.86 48.75,140.79 49.76,140.79 51.79,142.82 53.29,142.82 53.38,142.73 55.2,142.73 55.35,142.89 56.74,142.89 58.28,141.34 60.1,141.34 60.84,140.6 60.84,138.39 61.38,137.85 61.38,135.46 63.81,133.04 63.81,128.93 63.53,128.66 63.53,116.77 68.49,111.82 68.49,108.47 68.61,108.34 68.61,106.81 v1(68.81,106.62)
  IN3 w0.127: v1(38.21,160.97) 38.04,160.8 38.04,152.89 38.86,152.07 38.86,149.93 39.94,148.85 39.94,142.14 42.77,139.3 43.09,139.3 43.35,139.04 43.35,138.53 v1(43.52,138.36)
  BOTTOM w0.102: v1(35.72,163.23) 35.51,163.02 35.51,162.9 35.61,162.8 37.24,162.8 38.03,162.01 38.03,161.15 v1(38.21,160.97)
MXM_DPC_AUX#_C: length 2.7
  TOP w0.102: C532.2 35.52,159.91 v3(35.52,159.04) 35.52,158.32 35.63,158.21 U629.27
MXM_DPC_AUX_C: length 2.7
  TOP w0.102: C531.2 35.3,159.9 35.3,158.28 35.23,158.21 U629.28
MXM_DPC_HPD: length 74.8
  TOP w0.102: U629.3 v1(39.58,150.2)
  IN3 w0.127: v1(39.58,150.2) 41.03,148.75 41.03,141.77 42.03,140.76 42.78,140.76 44.23,139.32 44.23,138.91 44.65,138.49 46.73,138.49 48.48,140.24 49.3,140.24 51.78,142.72 52.98,142.72 55.29,140.41 55.29,140.07 56.55,138.81 56.81,138.81 63.41,132.21 63.41,113.25 v1(62.7,112.53)
  BOTTOM w0.102: v1(62.7,112.53) 62.26,112.1 v2(62.26,109.57) 62.26,106.17 D7.2 63.23,104.51 63.23,102.6 63.48,102.35 64.25,102.35 64.9,103.01 65.77,103.01 65.95,102.83 U25.2
MXM_DPC_HPD_GATE: length 5.5
  TOP w0.102: v1(67.34,99.54) 67.28,99.54 65.97,98.23 65.97,97.62 66,97.6 JMXM1.262
  BOTTOM w0.102: v2(67.86,99.25) 67.57,99.54 v1(67.34,99.54) 66.82,99.54 66.6,99.77 U25.4
MXM_DPC_N0: length 73.2
  TOP w0.102: v1(45.53,148.98) 45.32,148.77 44.71,148.77 44.6,148.66 43.64,148.66 43.29,148.32 42.45,148.32 C524.1 ; v1(74.84,108.42) 74.63,108.21 74.63,105.83 74.75,105.71 JMXM1.229
  IN1 w0.117: v1(45.53,148.98) 45.65,148.85 46.14,148.85 46.21,148.93 49.07,148.93 50.18,150.04 50.18,150.61 51,151.43 57.19,151.43 62.61,146.01 64.57,146.01 66,144.57 66,143.82 67.42,142.4 67.42,127.75 66.69,127.02 66.69,118.09 71.61,113.17 72.83,113.17 74.11,111.89 74.11,109.43 74.7,108.83 74.7,108.56 v1(74.84,108.42)
MXM_DPC_N0_C: length 3.4
  TOP w0.102: C524.2 40.92,148.31 40.73,148.31 40.28,148.76 40.21,148.83 40.21,149.13 39.61,149.73 39.29,149.73 39.22,149.8 U629.2
MXM_DPC_N1: length 71.3
  TOP w0.102: v1(44.26,149.79) 44.03,149.57 43.65,149.57 43.11,150.1 42.45,150.1 C526.1 ; JMXM1.235 73.25,105.71 73.13,105.83 73.13,108.21 v1(73.34,108.42)
  IN1 w0.117: v1(44.26,149.79) 44.38,149.67 44.73,149.67 45.02,149.38 45.02,148.06 45.34,147.74 47.51,147.74 47.9,148.13 50.31,148.13 52.18,150 57.52,150 62.29,145.22 63.99,145.22 64.85,144.36 64.85,138.31 66.15,137.02 66.15,127.96 65.9,127.71 65.9,117.76 71.21,112.45 71.21,110.85 73.2,108.86 73.2,108.56 v1(73.34,108.42)
MXM_DPC_N1_C: length 3
  TOP w0.102: C526.2 40.92,150.09 40.75,150.09 40.33,150.52 39.91,150.94 39.29,150.94 39.23,151 U629.5
MXM_DPC_N2: length 70.8
  TOP w0.102: v1(71.84,106.21) 71.63,106 71.63,105.83 71.75,105.71 JMXM1.241 ; v1(43.14,152.08) 42.93,151.88 42.45,151.88 C528.1
  IN1 w0.117: v1(71.84,106.21) 71.7,106.35 71.7,108.55 70.06,110.19 70.06,112.48 65.11,117.43 65.11,128.03 65.37,128.28 65.37,134.19 63.13,136.43 63.13,142.28 61.26,144.14 61.26,145.15 57.81,148.6 54.15,148.6 52.88,147.33 48.42,147.33 48.04,146.95 44.68,146.95 43.75,147.88 43.75,150.45 43.9,150.6 43.9,151.64 43.58,151.95 43.26,151.95 v1(43.14,152.08)
MXM_DPC_N2_C: length 2.7
  TOP w0.102: C528.2 40.93,151.88 40.53,151.88 40.38,151.73 v3(39.98,151.73) 39.3,151.73 39.24,151.8 U629.7
MXM_DPC_N3: length 76.4
  TOP w0.102: v1(70.29,103.46) 70.13,103.63 70.13,104.1 70.25,104.23 JMXM1.247 ; v1(43.81,153.3) 43.67,153.44 43.67,153.72 43.34,154.05 42.77,154.05 42.49,153.77 42.34,153.77 C530.1
  IN1 w0.117: v1(43.81,153.3) 43.64,153.13 43.64,152.89 43.32,152.56 42.78,152.56 42.5,152.29 42.5,147.35 43.56,146.29 43.84,146.29 44,146.14 48.58,146.14 48.92,146.48 53.16,146.48 54.02,147.34 57.95,147.34 60.4,144.9 60.4,143.28 61.76,141.92 61.76,138.59 62.17,138.18 62.17,135.78 64.59,133.36 64.59,128.61 64.33,128.35 64.33,117.1 69.27,112.15 69.27,109.53 70.14,108.67 70.14,103.61 v1(70.29,103.46)
MXM_DPC_N3_C: length 3
  TOP w0.102: C530.2 40.93,153.66 40.62,153.66 v3(40.24,153.27) 39.9,152.93 39.29,152.93 39.22,153 U629.10
MXM_DPC_P0: length 73.2
  TOP w0.102: v1(45.53,148.27) 45.29,148.51 44.82,148.51 44.71,148.4 43.75,148.4 43.4,148.05 42.46,148.05 C523.1 ; JMXM1.231 74.25,105.7 74.37,105.81 74.37,108.29 74.24,108.42 v1(74.13,108.42)
  IN1 w0.117: v1(74.13,108.42) 74.3,108.42 74.42,108.53 74.42,108.72 73.82,109.31 73.82,111.77 72.71,112.88 71.49,112.88 66.4,117.97 66.4,127.13 67.14,127.87 67.14,142.28 65.72,143.7 65.72,144.46 64.45,145.73 62.49,145.73 57.07,151.15 51.12,151.15 50.46,150.49 50.46,149.92 49.19,148.65 46.33,148.65 46.25,148.57 45.6,148.57 45.53,148.49 v1(45.53,148.27)
MXM_DPC_P0_C: length 3.4
  TOP w0.102: U629.1 39.24,149.4 39.3,149.46 39.5,149.46 39.95,149.02 39.95,148.72 v3(40.09,148.58) 40.62,148.04 40.93,148.04 C523.2
MXM_DPC_P1: length 71.2
  TOP w0.102: v1(72.63,108.42) 72.74,108.42 72.87,108.29 72.87,105.81 72.75,105.7 JMXM1.237 ; v1(44.26,149.08) 44.04,149.3 43.54,149.3 43,149.83 42.46,149.83 C525.1
  IN1 w0.117: v1(72.63,108.42) 72.8,108.42 72.92,108.53 72.92,108.74 70.93,110.73 70.93,112.33 65.62,117.64 65.62,127.83 65.87,128.08 65.87,136.9 64.57,138.2 64.57,144.24 63.87,144.94 62.18,144.94 57.4,149.71 52.3,149.71 50.43,147.85 48.02,147.85 47.62,147.45 45.23,147.45 44.73,147.95 44.73,149.26 44.61,149.38 44.33,149.38 44.26,149.31 v1(44.26,149.08)
MXM_DPC_P1_C: length 3
  TOP w0.102: U629.4 39.2,150.6 39.28,150.67 39.8,150.67 v3(40.14,150.33) 40.64,149.83 40.92,149.83 C525.2
MXM_DPC_P2: length 70.8
  TOP w0.102: C527.1 42.46,151.61 42.9,151.61 v1(43.14,151.37) ; v1(71.13,106.21) 71.24,106.21 71.37,106.08 71.37,105.81 71.25,105.7 JMXM1.243
  IN1 w0.117: v1(43.14,151.37) 43.14,151.59 43.21,151.67 43.46,151.67 43.62,151.52 43.62,150.72 43.47,150.57 43.47,147.76 44.57,146.67 48.16,146.67 48.54,147.05 53,147.05 54.27,148.32 57.69,148.32 60.98,145.03 60.98,144.03 62.84,142.16 62.84,136.31 65.08,134.07 65.08,128.4 64.83,128.15 64.83,117.31 69.78,112.36 69.78,110.07 71.42,108.44 71.42,106.32 71.3,106.21 v1(71.13,106.21)
MXM_DPC_P2_C: length 2.7
  TOP w0.102: U629.6 39.23,151.4 39.3,151.46 40.49,151.46 40.64,151.61 40.92,151.61 C527.2
MXM_DPC_P3: length 76.4
  TOP w0.102: v1(69.71,103.46) 69.86,103.62 69.86,104.13 69.75,104.23 JMXM1.249 ; C529.1 42.15,153.43 42.22,153.5 42.6,153.5 42.88,153.78 43.23,153.78 43.4,153.61 43.4,153.38 43.33,153.3 v1(43.18,153.3)
  IN1 w0.117: v1(43.18,153.3) 43.35,153.12 43.35,152.99 43.21,152.85 42.66,152.85 42.22,152.41 42.22,147.23 43.44,146.01 43.73,146.01 43.88,145.85 48.7,145.85 49.04,146.2 53.28,146.2 54.14,147.06 57.84,147.06 60.11,144.78 60.11,143.16 61.47,141.8 61.47,138.48 61.88,138.06 61.88,135.66 64.3,133.24 64.3,128.72 64.04,128.47 64.04,116.98 68.99,112.03 68.99,109.41 69.86,108.55 69.86,103.61 v1(69.71,103.46)
MXM_DPC_P3_C: length 3
  TOP w0.102: C529.2 40.92,153.39 40.73,153.39 40.01,152.66 39.28,152.66 39.21,152.6 U629.9
MXM_EDP_AUX+: length 69.1
  TOP w0.102: C500.2 37.07,137.65 37.07,138.14 v1(37.25,138.31) ; JMXM1.260 66.5,96.11 66.64,95.97 66.64,95.31 66.89,95.06 67.22,95.06 v1(67.37,94.91)
  IN1 w0.117: v1(37.25,138.31) 37.07,138.49 37.07,138.68 37.21,138.82 37.75,138.82 39.25,137.31 39.25,136.74 40.7,135.29 54.24,135.29 59.01,130.52 59.01,113.37 60.44,111.94 60.44,111.47 62.24,109.66 62.24,104.94 64.98,102.2 64.98,102.15 66.6,100.52 66.6,95.32 66.87,95.05 67.22,95.05 v1(67.37,94.91)
MXM_EDP_AUX+_C: length 4
  TOP w0.102: JEPWR1.4 37.45,134.59 37.07,134.97 37.07,135.29 v1(37.25,135.47) 37.07,135.65 37.07,136.13 C500.1
  BOTTOM w0.102: v1(37.25,135.47) 37.07,135.65 37.07,136.13 C500.1
MXM_EDP_AUX-: length 69.1
  TOP w0.102: JMXM1.258 67,96.06 66.91,95.97 66.91,95.42 67,95.32 67.2,95.32 v1(67.37,95.49) ; v1(36.61,138.31) 36.8,138.12 36.8,137.67 C501.2
  IN1 w0.117: v1(67.37,95.49) 67.22,95.34 66.99,95.34 66.89,95.44 66.89,100.64 65.26,102.27 65.26,102.32 62.52,105.06 62.52,109.78 60.72,111.58 60.72,112.06 59.29,113.49 59.29,130.64 54.35,135.58 40.82,135.58 39.54,136.86 39.54,137.43 37.87,139.1 37.09,139.1 36.79,138.8 36.79,138.49 v1(36.61,138.31)
MXM_EDP_AUX-_C: length 4
  TOP w0.102: JEPWR1.3 36.45,134.61 36.8,134.96 36.8,135.32 v1(36.65,135.47) 36.8,135.62 36.8,136.12 C501.1
  BOTTOM w0.102: C501.1 36.81,136.1 36.81,135.63 v1(36.65,135.47)
MXM_EDP_HPD: length 136.9
  TOP w0.102: JEPWR1.1 34.45,135.19 35.28,136.01 R222.2 35.28,138.94 33.32,140.89 v1(33.32,141.4) ; JMXM1.264 65.5,95.45 66.68,94.27 v1(67.34,94.27)
  IN1 w0.109: v1(46.08,150.56) 46.38,150.26 46.81,150.26 50.85,154.31 56.9,154.31 58.58,155.99 63.66,155.99 64.15,156.48 66.12,156.48 67.96,154.63 68.63,154.63 74.3,148.96 74.3,145.58 75.42,144.46 75.42,132.01 79.66,127.77 79.66,126.56 81.78,124.44 81.78,122.14 81.29,121.65 81.29,116.85 79.89,115.46 79.89,111.57 80.66,110.8 80.66,108.93 79.89,108.16 79.89,106.65 80.24,106.3 80.24,99.2 80.94,98.5 80.94,97.38 79.25,95.69 75.21,95.69 73.29,93.76 67.85,93.76 v1(67.34,94.27)
  BOTTOM w0.102: v1(33.32,141.4) v2(33.32,142.33) 33.32,142.63 35.28,144.59 37.69,144.59 38.38,145.27 41.33,145.27 41.7,145.64 42.29,145.64 43.25,146.6 44.65,146.6 46.09,148.04 46.09,150.55 v1(46.08,150.56)
MXM_EDP_TX0+: length 58
  TOP w0.102: JMXM1.236 72.5,96.15 72.62,96.03 72.62,95.56 72.74,95.43 v1(72.74,95.17) ; v1(55.74,141.51) 55.56,141.69 54.39,141.69 C312.2
  IN1 w0.117: v1(55.74,141.51) 55.91,141.69 56.19,141.69 57.03,140.86 57.03,140.74 60.36,137.41 60.36,135.05 62.79,132.62 62.79,129.35 62.51,129.07 62.51,128.55 62.19,128.23 62.19,116.68 67.22,111.65 67.22,104.84 72.5,99.56 72.5,95.61 72.74,95.37 v1(72.74,95.17)
MXM_EDP_TX0-: length 58
  TOP w0.102: v1(55.74,142.15) 55.55,141.96 54.4,141.96 C305.2 ; JMXM1.234 73,96.12 72.88,96 72.88,95.67 72.95,95.6 v1(73.17,95.6)
  IN1 w0.117: v1(73.17,95.6) 72.91,95.6 72.78,95.73 72.78,99.68 67.5,104.96 67.5,111.77 62.47,116.8 62.47,128.11 62.8,128.43 62.8,128.95 63.08,129.23 63.08,132.74 60.64,135.17 60.64,137.53 57.31,140.86 57.31,140.98 56.31,141.98 55.91,141.98 v1(55.74,142.15)
MXM_EDP_TX1+: length 58.2
  TOP w0.102: C316.2 54.39,139.91 56.07,139.91 v1(56.24,139.74) ; v1(71.88,94.3) 71.88,94.55 71.14,95.29 71.14,95.97 71,96.11 JMXM1.242
  IN1 w0.117: v1(56.24,139.74) 56.42,139.91 56.74,139.91 59.57,137.08 59.57,134.73 62.01,132.29 62.01,129.67 61.73,129.39 61.73,128.88 61.4,128.56 61.4,116.35 66.38,111.37 66.38,104.57 70.98,99.97 70.98,95.41 71.88,94.5 v1(71.88,94.3)
MXM_EDP_TX1-: length 58.2
  TOP w0.102: v1(72.31,94.75) 72.05,94.75 71.41,95.4 71.41,95.97 71.5,96.06 JMXM1.240 ; C314.2 54.4,140.18 56.05,140.18 v1(56.24,140.37)
  IN1 w0.117: v1(56.24,140.37) 56.42,140.19 56.86,140.19 59.86,137.2 59.86,134.85 62.29,132.41 62.29,129.56 62.01,129.27 62.01,128.76 61.68,128.44 61.68,116.47 66.66,111.49 66.66,104.69 71.26,100.09 71.26,95.52 72.03,94.75 v1(72.31,94.75)
MXM_EDP_TX2+: length 54
  TOP w0.102: JMXM1.248 69.5,96.11 69.64,95.97 69.64,95.66 69.87,95.43 v1(69.87,95.17) ; C320.2 54.39,138.14 55.56,138.14 v1(55.74,137.96)
  IN1 w0.117: v1(55.74,137.96) 55.9,138.12 57.42,138.12 58.78,136.76 58.78,134.41 61.23,131.97 61.23,130 60.94,129.71 60.94,129.21 60.61,128.89 60.61,116.02 65.54,111.09 65.54,104.3 69.43,100.41 69.43,95.88 69.87,95.43 v1(69.87,95.17)
MXM_EDP_TX2-: length 53.9
  TOP w0.102: v1(55.74,138.57) 55.57,138.4 54.4,138.4 C317.2 ; v1(70.3,95.63) 70.05,95.63 69.91,95.77 69.91,95.97 70,96.06 JMXM1.246
  IN1 w0.117: v1(70.3,95.63) 70.08,95.63 69.71,95.99 69.71,100.53 65.83,104.41 65.83,111.21 60.9,116.14 60.9,128.77 61.22,129.09 61.22,129.59 61.51,129.88 61.51,132.09 59.07,134.53 59.07,136.87 57.53,138.41 55.9,138.41 v1(55.74,138.57)
MXM_EDP_TX3+: length 52.2
  TOP w0.102: JMXM1.254 68,96.11 68.14,95.97 68.14,95.35 68.28,95.21 v1(68.28,94.93) ; v1(57.34,136.18) 57.16,136.36 54.39,136.36 C322.2
  IN1 w0.117: v1(68.28,94.93) 68.28,95.2 68.03,95.45 68.03,100.21 66.02,102.22 66.02,102.61 63.03,105.6 63.03,110.02 62.19,110.86 62.19,111.98 59.83,114.34 59.83,129.27 60.16,129.6 60.16,130.09 60.45,130.38 60.45,131.65 58,134.09 58,136.13 57.77,136.36 57.51,136.36 v1(57.34,136.18)
MXM_EDP_TX3-: length 52.2
  TOP w0.102: v1(68.71,95.39) 68.48,95.39 68.41,95.46 68.41,95.97 68.5,96.06 JMXM1.252 ; v1(57.34,136.82) 57.15,136.62 54.4,136.62 C321.2
  IN1 w0.117: v1(68.71,95.39) 68.49,95.39 68.31,95.57 68.31,100.33 66.3,102.34 66.3,102.73 63.31,105.72 63.31,110.14 62.47,110.97 62.47,112.1 60.11,114.46 60.11,129.15 60.44,129.48 60.44,129.97 60.73,130.26 60.73,131.76 58.28,134.21 58.28,136.25 57.89,136.64 57.51,136.64 v1(57.34,136.82)
MXM_ENVDD: length 116
  TOP w0.102: v1(115.68,116.44) 117.89,114.24 v2(117.89,111.55) 117.89,107.36 117.51,106.98 117.51,106.59 117.79,106.31 118.04,106.31 118.75,105.6 JMXM1.59
  IN3 w0.127: v1(43.32,142.63) 43.32,142.56 46.26,139.61 46.77,139.61 47.49,140.33 47.49,140.84 48.88,142.23 49.52,142.23 50.77,143.48 52.35,143.48 54.19,145.32 55.74,145.32 58.59,148.17 67.16,148.17 71.64,152.65 76.89,152.65 77.16,152.39 78.63,152.39 80.29,150.72 84.99,150.72 90.51,145.2 90.51,139.14 97.67,131.98 98.29,131.98 100.87,129.39 100.87,126.39 103.82,123.45 103.82,122.49 107.57,118.73 108.72,118.73 112.05,115.4 114.64,115.4 v1(115.68,116.44)
  BOTTOM w0.102: v1(43.32,142.63) 43.32,143.63 D6.3
