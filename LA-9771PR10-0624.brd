# Allegro board LA-9771PR10-0624.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SIO_SLP_LAN#: length 360.5
  TOP w0.102: v2(127.69,163.38) 127.68,163.4 v1(127.07,163.4) 127.07,164.53 126.76,164.84 U63.3 ; v1(26.58,91.55) 26.78,91.35 UH1.G5
  IN1 w0.109: v1(219.77,75.09) 219.77,75.14 220.41,75.78 222.33,75.78 222.44,75.67 223.13,75.67 224.54,77.09 224.54,78.19 224.29,78.45 223.02,78.45 222.97,78.4 221.65,78.4 221.4,78.65 221.4,78.98 219.52,80.86 219.52,85.53 218.54,86.51 212.17,86.51 211.03,87.64 202.35,87.64 198.94,91.04 198.94,93.91 193.2,99.65 186.29,99.65 177.21,108.74 177.21,109.45 175.68,110.98 175.27,110.98 172.86,113.4 172.86,120.13 171.28,121.7 171.28,124.72 173.95,127.39 173.95,134.68 173.25,135.38 166.97,135.38 165.75,134.16 160.59,134.16 160.03,134.72 159.23,134.72 156.73,137.21 156.73,140 154.89,141.85 153.47,141.85 152,143.31 152,145.43 152.72,146.15 152.72,149.5 151.91,150.31 151.2,150.31 149.06,152.46 149.06,154.16 148.58,154.63 146.16,154.63 141.32,159.47 137.74,159.47 134.76,162.45 129.01,162.45 128.06,163.4 v1(127.07,163.4)
  IN2 w0.127: v1(127.07,163.4) 126.74,163.07 125.28,163.07 121.52,166.83 117.82,166.83 117.39,166.39 116.11,166.39 112.87,169.63 106.63,169.63 105.8,168.79 103.29,168.79 102.65,168.16 98.35,168.16 93.51,163.31 88.22,163.31 87.08,164.45 82.34,164.45 81.64,165.15 79.09,165.15 78.37,165.87 74.49,165.87 73.74,165.13 73.74,164.07 69.99,160.31 69,160.31 65.5,156.82 56.93,156.82 54.9,154.79 53.87,154.79 50.03,150.95 50.03,147.74 47.73,145.44 47.73,143.54 45.86,141.67 44.2,141.67 41.7,139.17 41.7,138.89 40.04,137.22 40.04,135.62 35.8,131.38 29.18,131.38 26.09,128.29 26.09,124.62 25.07,123.59 25.07,119.49 22.85,117.27 22.46,117.27 20.27,115.07 20.27,114.78 19.67,114.19 19.67,111.85 16.96,109.14 16.96,106.93 16.16,106.12 16.16,102.02 17.43,100.74 17.43,97.58 17.94,97.08 17.94,95.44 18.18,95.2 18.69,95.2 19.08,94.81 19.08,94.03 20.53,92.59 22.67,92.59 24.9,90.36 25.84,90.36 26.07,90.59 26.07,91.12 26.5,91.55 v1(26.58,91.55)
  BOTTOM w0.102: U46.A5 219.67,75.19 v1(219.77,75.09) ; RH80.2 20.15,88.28 22.43,88.28 22.73,87.97 24.42,87.97 25,88.55 25,89.6 26.02,90.61 26.02,91.04 26.53,91.55 v1(26.58,91.55)
SIO_SLP_S3#: length 467.1
  TOP w0.102: 27.85,89.78 27.85,89.42 v1(27.72,89.29) ; v1(84.4,25.18) 82.98,26.6 JAPS1.2 ; JIO1.85 8.73,85.8 9.03,86.09 9.03,89.27 v1(9.69,89.93)
  IN1 w0.109: v1(84.4,25.18) 84.4,25.39 84.81,25.8 88.82,25.8 89.16,25.45 103.7,25.45 107.25,21.9 131.63,21.9 132.22,21.31 195.3,21.31 196.1,22.12 222.45,22.12 236.68,36.34 250.36,36.34 251.54,37.52 256.89,37.52 259.03,39.66 261.3,39.66 262.21,38.75 262.21,37.96 v1(262.31,37.86) 262.53,37.86 271.47,46.79 271.47,69.83 261.11,80.18 253.68,80.18 251.32,77.83 246.78,77.83 244.19,75.25 227.92,75.25 224.34,78.83 221.83,78.83 v1(221.83,78.83)
  IN3 w0.127: v1(9.69,89.93) 9.89,89.72 11.87,89.72 13.42,91.27 14.99,91.27 15.47,90.79 17.48,90.79 17.86,90.41 18.42,90.41 20.38,88.45 22.82,88.45 23.23,88.86 24.82,88.86 25.64,89.67 27.34,89.67 v1(27.72,89.29)
  IN4 w0.109: v1(84.4,25.18) 83.69,25.18 83.36,24.85 83.36,20.65 77.71,15.01 77.16,15.01 72.75,10.61 72.75,10.12 72.04,9.41 50.7,9.41 42.8,17.31 42.8,24.5 39.19,28.11 39.19,30.76 38.7,31.25 38.7,37.01 36.25,39.46 36.25,49.06 38.96,51.77 38.96,53.16 36.57,55.55 36.57,64.99 34.01,67.56 34.01,77.61 34.32,77.93 34.32,80.99 33.36,81.96 26.68,81.96 25.97,82.66 24.31,82.66 24.09,82.88 19.77,82.88 18.07,84.58 17.51,84.58 14.95,87.14 14.33,87.14 12.02,89.45 10.16,89.45 v1(9.69,89.93)
  BOTTOM w0.102: v1(221.83,78.83) 221.88,78.77 U46.B65 ; PR403.1 262.04,37.58 v1(262.31,37.86)
SIO_SLP_S4#: length 504.8
  TOP w0.102: JAPS1.5 84.48,28.35 84.78,28.05 84.78,27.7 85.52,26.96 v1(85.52,25.1) ; UH1.C6 24.97,92.15 24.75,91.93 24.37,91.93 22.97,90.53 22.97,88.35 22.64,88.02 20.36,88.02 20.02,88.36 20.02,89.2 T118.1 19.3,89.93 16.34,89.93 15.58,89.16 15.58,88.44 v1(15.28,88.14)
  IN1 w0.109: v1(224.73,79.52) 224.73,79.33 227.15,76.91 236.98,76.91 238.28,75.61 244.23,75.61 246.68,78.06 251.23,78.06 253.58,80.42 261.21,80.42 271.7,69.93 271.7,46.66 262.41,37.37 261.48,37.37 260.74,38.11 257.81,38.11 256.98,37.29 251.64,37.29 250.46,36.11 236.78,36.11 222.55,21.88 196.2,21.88 195.39,21.07 132.12,21.07 131.53,21.66 107.15,21.66 103.6,25.22 89.06,25.22 88.72,25.55 85.98,25.55 v1(85.52,25.1) 85.19,24.77 84.14,24.77 83.3,23.92 83.3,23.51 82.22,22.44 82.05,22.44 77.03,17.41 77.03,14.89 73.64,11.5 73.64,9.68 72.71,8.75 53.25,8.75 50.63,11.36 50.22,11.36 49.23,12.36 49.23,14.67 v1(49.41,14.84)
  IN3 w0.127: v1(224.73,79.52) 224.73,77.41 221.14,73.82 219.29,73.82 217.2,75.91 210.83,75.91 210.65,76.08 209.18,76.08 208.16,77.1 205.68,77.1 202.58,80.2 187.74,80.2 183.42,84.52 178.9,84.52 178.62,84.24 v1(178.62,84.26)
  IN4 w0.109: v1(49.41,14.84) 49.02,14.84 43.53,20.34 43.53,24.93 39.92,28.53 39.92,31.04 39.41,31.55 39.41,37.31 36.96,39.75 36.96,48.76 39.69,51.49 39.69,53.44 37.3,55.83 37.3,65.29 34.73,67.86 34.73,77.32 35.42,78 35.42,80.57 33.56,82.43 26.88,82.43 26.17,83.13 24.5,83.13 24.24,83.4 24.24,83.62 23.57,84.29 19.07,84.29 18.31,85.05 17.71,85.05 15.26,87.51 15.26,88.11 v1(15.28,88.14)
  BOTTOM w0.102: v1(224.73,79.52) 224.23,79.02 U46.A61 ; PR206.1 176.95,82.74 178.47,84.26 v1(178.62,84.26)
SIO_SLP_S5#: length 271.6
  TOP w0.102: UH1.Y7 32.37,92.6 32.28,92.6 32.24,92.64 v1(32.24,92.64) ; v1(84.37,27.65) 83.98,28.04 JAPS1.4
  IN1 w0.109: v1(105.55,106.67) 106.05,106.67 108.38,108.99 108.38,111.39 107.2,112.58 107.2,117.2 104.77,119.63 104.77,123.58 108.19,127 108.19,129.5 107.32,130.36 107.32,133.47 105.17,135.62 105.17,136.48 104.24,137.4 104.24,142.73 104.68,143.17 104.68,144.43 105.48,145.23 105.48,147.7 107.25,149.46 v1(107.25,149.49)
  IN2 w0.127: v1(105.55,106.67) 85.11,106.67 84.13,105.69 81.05,105.69 80.35,104.99 73.86,104.99 67.89,99.01 66.65,99.01 64.52,96.89 57.76,96.89 56.42,95.54 52.23,95.54 51.04,94.35 45.61,94.35 43.6,92.33 43.6,90.76 42.68,89.84 40.58,89.84 40.45,89.98 38.64,89.98 37.83,90.79 36.89,90.79 36.23,91.45 32.9,91.45 32.67,91.68 32.67,92.2 v1(32.24,92.64)
  IN4 w0.109: v1(34.76,79.94) 34.76,78.01 34.26,77.52 34.26,67.64 36.81,65.09 36.81,55.65 39.2,53.26 39.2,51.67 36.49,48.96 36.49,39.56 38.94,37.11 38.94,31.35 39.43,30.86 39.43,28.21 43.04,24.6 43.04,17.43 48.43,12.04 71.5,12.04 74.6,15.13 75.25,15.13 76.4,16.28 76.4,17.44 78.85,19.89 78.85,22.37 84.12,27.65 v1(84.37,27.65)
  BOTTOM w0.076: v1(32.24,92.64) 31.87,92.26 31.87,91.66
  BOTTOM w0.102: U51.A18 107,150.71 107.25,150.45 v1(107.25,149.49) ; v1(34.76,79.94) 34.76,80.58 34.25,81.09 34.25,84.4 34.37,84.52 34.37,86.23 32.38,88.22 T146.1 32.38,90.4 31.76,91.02 31.76,91.55 31.87,91.66
SIO_SLP_SUS#: length 236.8
  TOP w0.102: UH1.F1 26.98,89.65 26.98,89.09 v1(26.59,88.69)
  IN2 w0.127: v1(218.92,78) 218.47,77.56 218.47,74.37 216.98,72.87 216.98,71.99 215.75,70.76 208.28,70.76 205.24,73.81 205.24,81.25 201.86,84.63 201.86,92.88 199.09,95.65 196.03,95.65 195.09,96.59 192.61,96.59 191.93,97.27 189.22,97.27 182.94,103.54 143.02,103.54 141.39,105.17 131.39,105.17 129.89,103.67 129.49,103.67 127.2,101.38 122.3,101.38 120.84,102.84 108.05,102.84 107.16,101.95 91.98,101.95 91.83,102.11 81.53,102.11 79.69,100.26 74.79,100.26 73.74,99.22 73.74,98.81 70.75,95.82 70.75,95.44 70.34,95.03 70.34,94.32 66.74,90.71 64.92,90.71 64.19,91.45 55.74,91.45 55.05,90.76 49.17,90.76 46.57,88.17 46.57,87.99 45.11,86.54 40,86.54 39.88,86.42 38.16,86.42 37.49,87.09 35.92,87.09 35.31,87.7 30.91,87.7 30.24,87.03 29.25,87.03 28.23,88.05 27.23,88.05 v1(26.59,88.69)
  BOTTOM w0.102: v1(26.59,88.69) 26.58,88.68 T145.1 ; v1(218.92,78) 219.42,77.5 U46.B6
SIO_SLP_WLAN#: length 380.5
  TOP w0.102: v1(26.55,90.38) 26.06,90.38 UH1.D2 ; R815.1 123.49,170.1 v1(122.25,168.86)
  IN1 w0.109: v1(77.24,151.34) 77.24,151.84 73.19,155.89 70.2,155.89 67.29,158.8 v1(66.79,158.8)
  IN2 w0.127: v1(26.55,90.38) 26.25,90.08 24.82,90.08 22.57,92.33 20.42,92.33 18.83,93.92 18.83,94.7 18.59,94.94 18.08,94.94 17.68,95.34 17.68,96.97 17.18,97.48 17.18,100.64 15.91,101.91 15.91,106.23 16.71,107.03 16.71,109.24 19.42,111.95 19.42,114.3 20.01,114.89 20.01,115.18 22.36,117.52 22.74,117.52 24.81,119.59 24.81,123.7 25.84,124.72 25.84,128.4 29.08,131.63 35.32,131.63 38.6,134.92 38.6,136.02 39.52,136.94 39.52,137.06 41.45,138.99 41.45,139.27 44.1,141.92 45.75,141.92 47.48,143.65 47.48,145.54 49.78,147.85 49.78,151.06 53.76,155.04 54.8,155.04 56.83,157.07 63.52,157.07 63.88,157.43 65.76,157.43 66.79,158.46 v1(66.79,158.8) 67.13,158.8 68.99,160.67 69.83,160.67 73.49,164.32 73.49,165.23 74.38,166.13 78.47,166.13 79.2,165.4 81.75,165.4 82.44,164.7 87.19,164.7 88.32,163.57 93.4,163.57 98.33,168.49 102.62,168.49 103.18,169.05 105.69,169.05 106.53,169.89 112.98,169.89 116.21,166.65 117.29,166.65 117.72,167.08 120.47,167.08 v1(122.25,168.86)
  IN3 w0.127: v1(204.48,85.99) 199.37,85.99 192.24,93.13 179.74,93.13 178.15,94.71 173.63,94.71 159.63,108.71 150.28,108.71 144.65,114.34 130.5,114.34 129.93,114.91 124.58,114.91 124.01,114.34 112.33,114.34 108.87,117.79 106.56,117.79 103.26,121.09 103.26,123.28 98.46,128.08 98.46,130.37 89.98,138.86 89.98,143.98 85.07,148.88 81.36,148.88 79.31,150.94 77.64,150.94 v1(77.24,151.34)
  BOTTOM w0.102: U46.A14 215.17,74.66 213.57,73.06 213.57,72.53 211.9,70.85 210.46,70.85 210.22,71.09 v2(208.89,71.09) 207.74,71.09 204.86,73.98 204.86,78.86 205.42,79.42 205.42,80.37 204.91,80.88 204.91,85.56 v1(204.48,85.99)
SL_BAT_PRES#: length 5.2
  BOTTOM w0.102: PR1023.1 150.33,126.25 150.33,127.39 v2(150.05,127.67)
  BOTTOM w0.254: PU1001.21 150.7,124.13 149.77,125.07 PR1023.1
SLICE_BAT_ON: length 130.9
  TOP w0.102: v1(211.14,84.13) 211.14,89.09 210.3,89.93 210.3,91.7 209.81,92.19 v1(209.41,92.19)
  IN2 w0.127: v1(158.47,131.25) 158.47,136.88 151.6,143.76 151.6,149.08 v1(151.98,149.46)
  IN3 w0.127: v1(209.41,92.19) 207.96,93.64 203.01,93.64 196.91,99.73 181.24,99.73 173.49,107.48 173.49,117.04 168.87,121.66 167.06,121.66 166,122.72 166,127.29 163.99,129.3 160.42,129.3 v1(158.47,131.25)
  BOTTOM w0.102: PQ1082.2 151.56,148.21 152.05,148.7 152.58,148.7 PU1080.2 152.56,148.88 v1(151.98,149.46) ; U46.A31 211.53,84.52 v1(211.14,84.13) 210.99,83.98 209.83,83.98 209.48,83.63 208.16,83.63 R761.1 ; v1(158.47,131.25) 155.8,128.59 155.8,127.56 PR1016.2 ; RP8.3 217.59,90.69 217.36,90.46 217,90.46 216.57,90.89 216.57,92.57 216.21,92.92 213.28,92.92 v2(212.94,92.59) 212.91,92.56 209.77,92.56 v1(209.41,92.19)
SLICE_BAT_PRES#: length 382.7
  TOP w0.102: v1(257.67,63.08) 256.02,63.08 254.16,64.93 247.44,64.93 247.19,64.68 244.65,64.68 243.52,65.82 243.52,70.67 241.59,72.6 236.56,72.6 236.33,72.38 227.92,72.38 225,75.3 225,76.24 221.95,79.28 220.58,79.28 215.93,83.93 215.53,83.93 214.87,84.59 214.69,84.59 214.08,85.2 v1(214,85.2)
  TOP w0.254: R784.1 109.66,118.86 v1(110.42,119.62)
  IN2 w0.254: v1(146.95,134.96) 147.1,134.81 v1(147.1,127.21) 146.49,127.21 145.5,126.22 145.5,118.2 142.22,114.92 131.88,114.92 127.91,118.9 118.11,118.9 116.32,117.1 111.49,117.1 110.47,118.12 110.47,119.57 v1(110.42,119.62)
  IN3 w0.127: v1(147.1,127.21) 146.41,127.21 146.03,126.83 146.03,124.93 148.27,122.69 148.27,117.72 151.15,114.84 152.86,114.84 155.83,111.87 v1(156.45,111.87) 156.73,111.87 158.54,110.06 159.73,110.06 170.05,99.73 174.31,99.73 180.16,93.89 192.64,93.89 199.55,86.98 210.98,86.98 212.78,85.18 213.98,85.18 v1(214,85.2) ; v1(257.67,63.08) 259.72,63.08 260.23,63.59 268.18,63.59 269.76,62.01 269.76,46.22 264.29,40.75 252.25,40.75 248.17,36.66 237.87,36.66 228.33,27.13 199.46,27.13 196.05,23.71 189.9,23.71 186.6,27.01 186.6,27.93 v1(186.01,28.51)
  BOTTOM w0.102: PR1023.2 149.77,126.81 148.75,127.82 147.71,127.82 v1(147.1,127.21) ; PR33.1 176.95,29.37 177.33,28.99 177.33,27.78 178.32,26.78 183.06,26.78 184.43,28.15 185.66,28.15 v1(186.01,28.51) ; U46.B33 213.58,84.77 v1(214,85.2)
  BOTTOM w0.254: v1(146.95,134.96) 150.75,134.96 156.07,140.27 v2(156.07,145.17) 154.67,146.57 153.04,146.57 152.75,146.86 PU1080.1 ; JDOCK1.141 110.2,119.4 v1(110.42,119.62) 110.7,119.34 JDOCK1.143 ; v1(156.45,111.87) 156.45,111.88 161.85,106.48 PD1100.1
SLICE_BST_CHG_EN: length 73.7
  TOP w0.102: v1(230.69,71.84) 230.39,71.54 226.6,71.54 225.88,72.25 222.3,72.25 221.39,73.16 220.55,73.16 218.45,75.26 218.45,78.09 218.13,78.41 217.44,78.41 217.2,78.65 216.09,78.65 215.93,78.5 215.5,78.5 214.99,77.99 v1(214.84,77.99)
  IN4 w0.109: v1(205.9,85.53) 205.9,85.51 206.82,84.59 207.63,84.59 210.75,81.47 212.56,81.47 213.72,80.3 214.71,80.3 215.3,79.72 215.3,78.42 214.87,77.99 v1(214.84,77.99)
  IN4 w0.254: v1(230.69,71.84) 230.67,71.82 230.67,68.74 228.51,66.58 227.62,66.58 222.33,61.3 216.75,61.3 213.19,57.74 213.19,54.93 215.86,52.26 v1(216.14,52.26)
  BOTTOM w0.102: U46.B16 214.42,77.57 v1(214.84,77.99) ; v1(205.9,85.53) 205.9,84.47 v2(206.17,84.2) 206.77,83.6 R761.2
  BOTTOM w0.254: v1(216.14,52.26) 216.37,52.03 PR1098.1 PR1033.2 ; PQ1071.5 231.17,71.36 v1(230.69,71.84)
SLP_ME_CSW_DEV#: length 228.7
  TOP w0.102: v1(34.71,93.67) 34.66,93.67 34.25,94.09 UH1.AD11
  IN2 w0.127: v1(34.71,93.67) 35.05,93.67 35.39,94.02 35.39,94.63 35.62,94.85 36.08,94.85 36.23,94.7 36.23,93 37.14,92.09 37.14,91.86 38.72,90.28 40.65,90.28 40.84,90.09 42.57,90.09 43.32,90.84 43.32,92.41 45.51,94.6 50.93,94.6 52.12,95.79 56.31,95.79 57.66,97.14 64.29,97.14 67.39,100.24 68.54,100.24 71.87,103.57 71.87,104.81 73.59,106.54 76.26,106.54 77.3,105.5 80.14,105.5 80.84,106.2 83.66,106.2 84.82,107.35 115.38,107.35 116.99,105.74 119.6,105.74 119.82,105.95 119.82,106.77 120.46,107.41 126.07,107.41 126.79,106.69 156.6,106.69 158.23,108.32 175.58,108.32 177.65,106.25 182.04,106.25 188.43,99.86 195.38,99.86 198,97.24 199.82,97.24 204.92,92.14 206.58,92.14 212.81,85.91 219.26,85.91 219.59,85.58 219.59,83.48 220.35,82.71 220.76,82.71 220.8,82.75 v1(220.99,82.75)
  BOTTOM w0.102: v1(220.99,82.75) 221.46,82.27 U46.B58 ; RH222.1 RH223.1 36.86,85.27 v2(36.01,86.12) 33.26,88.87 33.26,91.16 33.82,91.72 33.82,92.86 34.63,93.67 v1(34.71,93.67)
SM_RCOMP0: length 9.8
  TOP w0.254: v1(105.12,73.75) 104.65,73.28 JCPU1.AP3
  BOTTOM w0.33: v1(105.12,73.75) 104.62,74.25 104.62,76.2
  BOTTOM w0.508: RC42.1 107.63,80.86 v2(106.6,79.83) 104.62,77.85 104.62,76.2
SM_RCOMP1: length 8.6
  TOP w0.305: v1(105.12,74.75) JCPU1.AR3
  BOTTOM w0.457: v1(105.12,74.75) v2(107.8,77.42) 108.06,77.69 108.06,79.61 109.3,80.86 RC55.1
SM_RCOMP2: length 8
  TOP w0.305: JCPU1.AP2 v1(106.12,73.75)
  BOTTOM w0.254: 107.81,74.28 107.81,73.77 107.3,73.26 106.61,73.26 v1(106.12,73.75) 106.12,73.97 106.43,74.28 107.81,74.28 ; 107.81,74.28 107.93,74.41
  BOTTOM w0.508: RC49.1 v2(108.7,74.41) 107.93,74.41
SML1_SMBCLK: length 158.7
  TOP w0.102: UH1.K6 28.43,91.72 v1(28.2,91.95)
  IN1 w0.109: v1(96.71,116.57) 96.88,116.74 96.88,117.26 96.17,117.98 96.17,123.45 96.52,123.81 96.52,127.08 97.47,128.03 97.47,130.66 97.04,131.1 97.04,137 97.44,137.4 97.44,138.73 97.04,139.13 97.04,147.05 98.55,148.57 98.55,152.23 99.75,153.43 100.87,153.43 101.1,153.66 101.1,154.6 102.61,156.11 104.52,156.11 106.46,158.06 107.07,158.06 107.27,158.26 107.27,158.33 v1(107.1,158.51) ; v1(23.63,87.56) 23.8,87.39 23.99,87.39 25.21,88.61 25.21,89.47 25.64,89.91 26.94,89.91 28.43,91.4 28.43,91.72 v1(28.2,91.95)
  IN3 w0.127: v1(96.71,116.57) 96.94,116.34 96.94,116.17 96.73,115.96 91.86,115.96 91.58,116.24 87.48,116.24 86.04,114.8 86.04,111.47 85.13,110.56 85.13,106.24 81.88,102.98 79.84,102.98 78.23,101.37 75.11,101.37 72.57,98.83 72.57,98.15 71.91,97.5 70.96,97.5 69.15,95.68 69.15,94.91 67.37,93.13 64.35,93.13 63.89,92.67 56.98,92.67 56.55,92.24 55.88,92.24 54.29,90.64 54.29,89.22 52.51,87.44 49.87,87.44 49.38,86.95 46.69,86.95 45.42,85.68 42.71,85.68 40.88,87.51 37.58,87.51 37.37,87.31 35.98,87.31 34.28,89.01 32.25,89.01 31.31,89.95 30.38,89.95 28.1,87.67 26.01,87.67 25.07,86.73 24.72,86.73 24.07,87.37 23.82,87.37 v1(23.63,87.56)
  BOTTOM w0.102: RPH5.3 21.8,86.65 21.93,86.52 22.65,86.52 22.92,86.8 22.92,87.08 23.22,87.39 23.45,87.39 v1(23.63,87.56) ; v1(107.1,158.51) 107.58,158.02 U51.B6
SML1_SMBDATA: length 162.8
  TOP w0.102: v1(29.29,93.75) 29.64,94.1 UH1.N11
  IN1 w0.109: v1(97.32,116.57) 97.11,116.77 97.11,117.36 96.4,118.07 96.4,123.35 96.76,123.71 96.76,126.99 97.7,127.93 97.7,130.76 97.27,131.19 97.27,136.9 97.67,137.3 97.67,138.83 97.27,139.23 97.27,146.95 98.79,148.47 98.79,152.13 99.85,153.19 100.97,153.19 101.34,153.56 101.34,154.5 102.71,155.87 104.62,155.87 106.56,157.82 107.17,157.82 107.43,158.07 109.64,158.07 v1(109.91,158.35) ; v1(29.29,93.75) 29.16,93.75 28.67,93.26 28.67,91.3 27.04,89.67 25.74,89.67 25.44,89.37 25.44,88.51 24.09,87.15 23.8,87.15 v1(23.63,86.98)
  IN3 w0.127: v1(97.32,116.57) 97.19,116.44 97.19,116.06 96.83,115.71 91.75,115.71 91.47,115.99 87.59,115.99 86.29,114.69 86.29,111.36 85.38,110.45 85.38,106.13 81.98,102.73 79.94,102.73 78.33,101.12 75.21,101.12 72.82,98.72 72.82,98.05 72.02,97.24 71.07,97.24 69.4,95.58 69.4,94.8 67.47,92.87 64.45,92.87 64,92.42 57.08,92.42 56.65,91.98 55.99,91.98 54.54,90.54 54.54,89.11 52.61,87.18 49.97,87.18 49.49,86.7 46.8,86.7 45.53,85.43 42.6,85.43 40.77,87.26 37.68,87.26 37.48,87.06 35.87,87.06 34.17,88.76 32.14,88.76 31.2,89.7 30.49,89.7 28.2,87.41 26.12,87.41 25.18,86.47 24.61,86.47 23.97,87.12 23.77,87.12 v1(23.63,86.98)
  BOTTOM w0.102: v1(23.63,86.98) 23.45,87.16 23.32,87.16 23.15,86.99 23.15,86.7 22.74,86.29 21.93,86.29 21.79,86.15 RPH5.4 ; v1(109.91,158.35) 109.84,158.27 U51.A5
SNB_CPU_P1: length 2.6
  TOP w0.102: v2(47.84,65.4) 48.48,64.76 PR554.1
SNB_CPU_P2: length 3.4
  TOP w0.102: PC523.2 v2(52.92,39.85)
  TOP w0.508: PC523.2 51.34,38.07 PR542.1
SNB_CPU_P3: length 1.4
  TOP w0.102: PC507.2 48.48,76.07 v2(48.78,76.36)
SNUB_1.5VSP: length 1.3
  BOTTOM w0.102: PR401.2 v2(255.63,27.53)
SNUB_1.35V: length 2.1
  BOTTOM w0.102: PR202.2 v2(187.17,76.68)
SNUB_3V: length 2.9
  BOTTOM w0.102: PC116.1 v2(249.47,57.54)
  BOTTOM w0.508: PC116.1 249.47,54.82 PR109.2
SNUB_5V: length 4.5
  BOTTOM w0.102: PC119.1 242.45,56.96 240.75,56.96 v2(240.64,56.84)
  BOTTOM w0.635: PC119.1 243.34,56.07 PR110.2
SNUB_CHG: length 2.8
  BOTTOM w0.102: v2(186.99,53.95) 187,53.93 PC717.1
  BOTTOM w0.635: PR724.2 189.12,53.93 PC717.1
SOFT_START_GC: length 165.3
  TOP w0.381: v1(20.35,72.55) 19.59,71.79 PR20.2
  IN3 w0.381: v1(59.9,86.6) 55.59,82.29 55.59,80.91 54.84,80.16 52.17,80.16 51.44,79.42 48.21,79.42 46.01,77.23 34.64,77.23 34.4,77.47 32.56,77.47 32.13,77.04 21.66,77.04 19.72,75.09 19.72,73.19 v1(20.35,72.55)
  IN4 w0.381: v1(146.82,115.78) 146.85,115.76 152.54,115.76 v1(153.2,116.42)
  BOTTOM w0.254: PU1001.2 v1(153.2,116.42)
  BOTTOM w0.381: v1(146.82,115.78) 145.67,115.78 141.75,111.86 132.3,111.86 127.75,116.41 123.1,116.41 117.75,111.06 117.75,108.91 115.57,106.73 113.58,106.73 110.91,104.05 100.29,104.05 v2(98.53,102.3) 94.22,97.98 94.22,97.72 93.1,96.61 92.69,96.61 87.98,91.9 87.98,91.23 87.51,90.76 83.02,90.76 79.76,94.02 75.45,94.02 68.03,86.6 v1(59.9,86.6)
SP_TPM_LPC_EN: length 83.7
  TOP w0.102: v1(221.26,88.11) 220.83,87.68 220.83,86.27 221.4,85.69 221.4,83.99 221.19,83.77 221.19,83.75 v1(221.22,83.73)
  IN3 w0.127: v1(221.26,88.11) 220.84,88.53 215.96,88.53 215.61,88.89 208.82,88.89 206.13,91.58 202.68,91.58 195.82,98.44 180.74,98.44 172.2,106.98 172.2,114.83 167.33,119.7 165.27,119.7 v1(165.07,119.9)
  BOTTOM w0.102: R2188.1 162.21,120.2 v2(163.42,120.2) 164.77,120.2 v1(165.07,119.9) ; U46.B56 221.67,83.27 v1(221.22,83.73)
SP_TPM_LPC_EN_R: length 4.5
  BOTTOM w0.102: U39.28 160.38,118.55 R2189.2 161.01,119.73 R2188.2 v2(161.01,120.95)
SPI_CLK32: length 12.7
  BOTTOM w0.102: U53.6 55.66,93.43 RE2.1 56.14,93.56 56.4,93.81 56.4,95.26 56.52,95.39 59.17,95.39 59.42,95.64 59.62,95.64 59.77,95.49 59.77,94.98 59.65,94.85 59.06,94.85 58.94,94.73 58.94,93.99 58.81,93.86 v2(58.49,93.86) 58.28,93.86 58.15,93.99 58.15,94.78 58.02,94.91 57.44,94.91 57.31,94.78 R897.1
SPI_CLK64: length 12.7
  BOTTOM w0.102: U52.6 48.8,92.44 48.73,92.52 48.73,92.77 48.83,92.87 48.98,92.87 49.13,93.03 49.13,93.41 48.98,93.56 RE1.1 49.13,94.02 49.13,94.8 48.78,95.16 48.78,95.31 48.88,95.41 49.23,95.41 49.51,95.13 49.69,95.13 50.02,95.46 50.02,95.59 49.87,95.74 49.87,96 49.97,96.1 v4(50.34,96.1) 50.79,96.1 51.63,96.94 51.79,96.94 52.05,96.67 52.05,96.52 51.05,95.51 50.76,95.51 49.72,94.47 R899.1
SPI_DIN32: length 12.8
  BOTTOM w0.102: U53.2 56.93,83.7 57.06,83.58 57.72,83.58 57.84,83.45 57.84,83.28 57.72,83.15 56.7,83.15 56.57,83.28 56.57,83.6 56.45,83.73 56.24,83.73 56.12,83.6 56.12,82.59 56.19,82.51 56.39,82.51 56.63,82.75 v2(56.97,82.75) 57.64,82.75 57.74,82.64 57.74,82.44 57.64,82.34 56.83,82.34 56.73,82.24 56.73,81.44 56.85,81.32 57.08,81.32 57.21,81.44 57.21,81.83 57.31,81.93 57.64,81.93 57.74,81.83 57.74,80.76 57.62,80.63 57.18,80.63 R895.2
SPI_DIN64: length 12.9
  BOTTOM w0.102: U52.2 50.07,83.58 50.53,83.12 50.53,81.67 50.94,81.27 51.8,81.27 51.93,81.39 51.93,82.1 52.05,82.23 52.41,82.23 52.54,82.1 52.54,81.58 52.48,81.52 v4(52.48,81.25) 52.48,80.8 52.41,80.73 49.49,80.73 49.34,80.88 49.34,82.31 49.69,82.66 R8.2
SPI_DO32: length 12.7
  BOTTOM w0.102: U53.5 54.39,92.59 54.95,93.15 54.95,93.28 54.77,93.46 54.77,93.66 54.9,93.79 55.15,93.79 55.28,93.91 55.28,94.07 55.15,94.19 54.9,94.19 v2(54.83,94.26) 54.77,94.32 54.77,94.47 54.9,94.6 55.13,94.6 55.25,94.73 55.25,94.88 55.03,95.11 54.48,95.11 54.36,94.99 54.36,93.25 54.24,93.13 53.91,93.13 53.78,93 53.78,92.01 53.65,91.88 53.35,91.88 53.22,92.01 53.22,93.49 53.06,93.65 53.06,93.75 53.32,94.02 53.76,94.02 53.88,93.89 R900.1
SPI_DO64: length 12.8
  BOTTOM w0.102: U52.5 47.53,91.3 46.29,90.05 45.22,90.05 45.09,89.93 v4(45.09,89.81) 45.09,89.6 45.22,89.47 46.9,89.47 48.12,90.69 48.12,92.62 47.86,92.87 46.52,92.87 46.21,93.18 46.21,93.69 46.54,94.02 R901.1
SPI_PCH_CLK: length 45.2
  TOP w0.102: v1(52.03,84.41) RH181.1 51.98,85.3 53.37,85.3 53.53,85.47 JSPI1.7
  IN4 w0.109: v1(52.03,84.41) 52.03,85.61 55.66,89.24 v1(55.66,89.88)
  BOTTOM w0.102: R897.2 57.31,93.38 57.44,93.25 60.59,93.25 60.71,93.13 60.71,92.9 60.59,92.77 v2(60.16,92.77) 56.4,92.77 56.27,92.64 56.27,90.49 v1(55.66,89.88) 56.07,89.88 56.42,89.52 56.42,88.71 56.3,88.58 56.04,88.58 55.91,88.71 55.91,88.96 55.79,89.09 55.56,89.09 55.43,88.96 55.43,88.71 55.3,88.58 55.08,88.58 54.95,88.71 54.95,90.31 54.82,90.43 54.59,90.43 54.46,90.31 54.46,88.68 54.36,88.58 53.21,88.58 52.78,89.01 51.42,89.01 51.27,88.86 51.27,88.33 51.16,88.22 50.83,88.22 50.71,88.35 50.71,88.81 50.58,88.94 50.33,88.94 50.2,88.81 50.2,88.35 50.07,88.22 49.77,88.22 49.67,88.33 49.67,88.89 49.28,89.27 48.5,89.27 48.27,89.49 48.27,89.98 49.41,91.12 49.41,92.31 50,92.9 50,93.38 49.82,93.56 R899.2
SPI_PCH_CS0#: length 13.7
  TOP w0.102: v1(50.45,86.24) 51.04,86.24 RH182.1 51.48,86.58 v2(53.31,86.58) 53.9,86.58 54.01,86.47 JSPI1.9
  BOTTOM w0.102: v1(50.45,86.24) 50.63,86.24 50.76,86.12 50.76,85.94 50.88,85.81 52.7,85.81 52.79,85.72 52.79,85.6 52.7,85.51 50.88,85.51 50.58,85.2 50.58,83.57 50.88,83.27 50.88,81.82 51.08,81.62 51.22,81.62 R7.1
SPI_PCH_CS0#_R: length 12.7
  BOTTOM w0.102: R7.2 51.24,82.76 51.24,83.2 51.34,83.3 51.75,83.3 51.88,83.17 51.88,82.73 51.99,82.61 52.16,82.61 52.28,82.73 52.28,83.12 52.41,83.25 v4(52.51,83.25) 52.64,83.25 52.76,83.12 52.76,82.4 52.88,82.28 53.05,82.28 53.17,82.4 53.17,83.02 53.3,83.14 54.03,83.14 54.14,83.25 54.14,83.5 53.81,83.83 53.81,84.52 53.68,84.64 53.45,84.64 53.32,84.52 53.32,83.72 53.2,83.6 53.04,83.6 52.92,83.72 52.92,84.19 52.79,84.31 52.56,84.31 52.43,84.19 52.43,83.81 52.31,83.68 51.47,83.68 51.34,83.81 U52.1
SPI_PCH_CS1#: length 11.8
  TOP w0.102: JSPI1.1 54.59,82.42 54.59,80.88 54.14,80.43 RH177.1 52.85,79.2 v1(52.57,79.2)
  BOTTOM w0.102: R936.1 58.2,80.42 56.98,79.2 v2(55.46,79.2) v1(52.57,79.2)
SPI_PCH_CS1#_R: length 12.8
  BOTTOM w0.102: U53.1 58.2,85.23 58.33,85.35 58.58,85.35 58.89,85.05 58.89,84.49 60,83.37 60,83.07 59.88,82.94 59.44,82.94 59.32,82.81 59.32,82.56 59.44,82.43 v2(59.7,82.43) 59.88,82.43 60,82.31 60,82.03 59.88,81.9 59.47,81.9 59.34,81.77 59.34,81.54 59.47,81.42 59.83,81.42 59.95,81.29 59.95,81.09 59.83,80.96 59.09,80.96 58.89,81.16 58.89,83.24 58.76,83.37 58.27,83.37 58.2,83.3 R936.2
SPI_PCH_DIN: length 16.8
  TOP w0.102: v1(56.07,80.55) v2(54.4,78.89) 53.93,78.42 52.26,78.42 49.87,80.81 v1(49.87,81.14) 49.87,81.94 50.5,82.57 RH179.1 51.44,82.93 51.87,82.93 53.27,84.33 53.76,84.33 53.9,84.47 JSPI1.5
  BOTTOM w0.102: R895.1 56.65,79.97 v1(56.07,80.55) ; v1(49.87,81.14) 50.07,81.34 R8.1
SPI_PCH_DO: length 37.8
  TOP w0.102: JSPI1.3 53.74,83.47 RH178.1 51.92,81.65 v2(51.92,79.27) 52.41,78.78 53.25,78.78 55.43,80.96 55.43,81.78 56.42,82.77 56.42,91.66 55.39,92.7 54.87,92.7 v1(53.17,94.4)
  IN4 w0.109: v1(46.72,92.03) 46.88,92.03 47.57,92.73 50.96,92.73 52.5,94.27 53.04,94.27 v1(53.17,94.4)
  BOTTOM w0.102: v1(46.72,92.03) 46.72,92.17 45.86,93.03 45.86,93.89 R901.2 ; R900.2 53.25,94.47 v1(53.17,94.4)
SPI_PCH_DO2: length 19.5
  TOP w0.102: v1(50.45,88.02) 50.5,87.97 RH183.1 51.3,87.76 v2(52.19,87.76) 53.64,87.76 53.92,87.47 JSPI1.11
  IN4 w0.109: v1(53.6,81.06) 51.29,83.37 51.29,87.13 50.45,87.97 v1(50.45,88.02)
  BOTTOM w0.102: R9.1 48.98,81.57 48.98,80.74 49.34,80.38 52.92,80.38 v1(53.6,81.06) 53.6,81.72 R3667.1
SPI_PCH_DO2_32: length 12.7
  BOTTOM w0.102: U53.3 55.66,85.38 55.79,85.51 57.92,85.51 58.05,85.63 58.05,85.89 57.92,86.02 55.03,86.02 54.85,85.84 54.85,85.53 55,85.38 55,83.35 55.13,83.22 55.53,83.22 55.66,83.09 R3665.2 RH186.1 R3667.2
SPI_PCH_DO2_64: length 12.8
  BOTTOM w0.102: U52.3 48.8,83.55 48.57,83.32 46.41,83.32 46.21,83.12 46.21,82.79 45.68,82.26 v4(44.6,82.26) 44.05,82.26 43.93,82.13 43.93,81.49 44.05,81.37 45.73,81.37 46.9,82.54 R3664.2 RH180.1 R9.2
SPI_PCH_DO3: length 23.3
  TOP w0.102: v1(51.88,88.61) 51.88,88.89 51.09,89.67 RH184.1 51.5,89.75 52.78,88.47 JSPI1.13
  IN3 w0.127: v1(51.88,88.61) 51.88,93.25 52.41,93.79 v1(52.41,95.08)
  BOTTOM w0.102: R3670.2 59.06,87.29 58.37,87.97 52.96,87.97 52.53,88.4 52.08,88.4 v1(51.88,88.61) ; v1(52.41,95.08) 52.41,95.44 52.23,95.62 v4(52.03,95.62) 51.32,94.91 51.01,94.91 R3669.2
SPI_PCH_DO3_32: length 12.8
  BOTTOM w0.102: R3670.1 v2(61.76,87.29) 62.14,87.29 62.26,87.41 62.26,87.79 62.14,87.92 61.76,87.92 61.63,88.05 61.63,88.68 61.5,88.81 61.25,88.81 61.12,88.68 61.12,88.05 60.99,87.92 60.71,87.92 60.59,88.05 60.59,88.23 60.47,88.35 60.3,88.35 60.18,88.23 60.18,88.05 60.05,87.92 59.77,87.92 59.65,88.05 R3666.2 59.65,89.22 59.47,89.39 57.72,89.39 56.93,90.18 U53.7
SPI_PCH_DO3_64: length 12.8
  BOTTOM w0.102: U52.7 50.07,90.49 49.97,90.38 49.59,90.38 49.44,90.23 49.44,90.1 49.79,89.75 50.25,89.75 50.35,89.85 50.35,90.26 50.45,90.36 50.68,90.36 50.78,90.26 50.78,89.65 50.88,89.55 51.11,89.55 51.22,89.65 51.22,89.93 51.33,90.05 51.5,90.05 51.62,89.93 51.62,89.75 51.75,89.62 52.02,89.62 52.13,89.73 52.13,90.03 51.49,90.66 50.91,90.66 50.76,90.82 50.76,92.85 R3668.2 R3669.1
SPI_WP#_SEL: length 211.6
  IN2 w0.127: v1(177.94,91.91) 177.94,91.86 176.34,93.46 162.15,93.46 158.72,96.89 154.89,96.89 154.21,97.57 139.62,97.57 138.56,98.64 134.85,98.64 133.73,97.52 133.73,96.77 131.1,94.14 118.28,94.14 117.06,95.36 115.7,95.36 115.1,94.77 113.88,94.77 113.84,94.8 92.35,94.8 92.31,94.77 90.11,94.77 88.3,92.95 86.42,92.95 85.39,91.92 85.39,89.15 80.53,84.29 69.37,84.29 67.51,82.42 55.27,82.42 54.19,81.34 v1(54.19,81.06)
  BOTTOM w0.102: RH180.2 47.94,81.75 48.62,81.06 48.62,80.59 v2(48.81,80.41) 49.19,80.02 53.22,80.02 54.19,80.99 v1(54.19,81.06) 54.19,81.29 RH186.2 ; v1(177.94,91.91) 182.74,96.71 191.71,96.71 196.36,92.06 202.9,92.06 204.54,90.43 204.54,88.43 204,87.89 204,82.76 204.25,82.51 204.25,73.9 207.78,70.37 212.53,70.37 213.86,71.7 215.49,71.7 215.86,72.07 215.86,74.05 215.93,74.13 215.93,75.25 216.17,75.48 U46.A12
SPKR: length 43
  TOP w0.102: v1(37.67,93.69) 37.49,93.51 UH1.AL10 ; JIO1.76 14.01,88.8 v1(14.28,88.53)
  IN3 w0.127: v1(37.67,93.69) 38.16,93.2 38.16,91.25 37.52,90.61 30.23,90.61 27.87,88.25 23.53,88.25 22.94,87.67 22.94,86.85 22.69,86.6 22.28,86.6 21.27,87.62 19.57,87.62 17.26,89.93 16.57,89.93 15.96,89.32 15.1,89.32 14.31,88.53 v1(14.28,88.53)
  BOTTOM w0.102: v1(37.67,93.69) 37.67,93.68 37.26,93.27 37.26,91.85 36.81,91.4 36.81,88.96 37.75,88.02 37.75,87.01 v2(38.41,86.35) 39.68,85.08 RH34.2
SRTCRST#: length 9.4
  TOP w0.102: v1(22.82,93.52) 22.82,93.44 23.2,93.06 23.6,93.06 23.95,93.41 24.33,93.41 24.43,93.51 25,93.51 UH1.B9
  BOTTOM w0.102: v1(22.82,93.52) 22.79,93.5 v2(21.26,93.5) 19.93,93.5 CH6.2 19.41,94.02 18.14,94.02 17.76,93.64 RH42.2 ME1.2
STSTART_DCBLOCK_GC: length 2.5
  BOTTOM w0.254: PU1001.16 146.57,121.28 PR1002.1
SUS_ON: length 421.8
  TOP w0.102: U57.5 44.68,30.62 44.85,30.45 44.85,29.45 43.89,28.48 43.48,28.48 43.24,28.24 43.24,26.79 44.51,25.52 44.51,18.1 45.1,17.51 v2(45.38,17.23) 45.53,17.08 46.19,17.08 v1(46.58,16.69) ; v1(221.19,81.77) 221.19,81.77 221.65,81.32 222.03,81.32 223.4,79.94 224.9,79.94 225.15,79.69 225.15,78.29 230.29,73.16 v1(230.74,73.16)
  IN1 w0.109: v1(50.35,15.59) 52.45,17.69 55.16,17.69 60.55,12.3 71.61,12.3 75.07,15.75 75.07,19.21 83.07,27.21 88.66,27.21 89.43,27.99 95.39,27.99 96.11,27.26 104.64,27.26 108.04,23.86 132.39,23.86 132.96,23.29 194.23,23.29 195.56,24.62 201.13,24.62 201.74,24.01 220.88,24.01 221.52,24.65 222.62,24.65 236.57,38.6 250.28,38.6 253.93,42.25 264.58,42.25 269.67,47.33 269.67,69.27 260.5,78.44 255.28,78.44 251.33,74.48 245.77,74.48 244.83,73.54 234.37,73.54 233.71,72.88 231.02,72.88 v1(230.74,73.16)
  IN3 w0.127: v1(50.35,15.59) 49.97,15.97 47.8,15.97 47.09,16.69 v1(46.58,16.69)
  IN4 w0.109: v1(202.29,69.51) 203.04,69.51 209.41,63.13 220.15,63.13 220.51,62.77 223.37,62.77 227.36,66.76 227.36,68.44 228.9,69.98 228.9,70.85 230.74,72.69 v1(230.74,73.16)
  BOTTOM w0.102: PR240.2 177.96,82.91 179.79,84.73 181.93,84.73 189.55,77.11 196.71,77.11 200.33,73.49 200.33,72.12 202.29,70.15 v1(202.29,69.51) ; RP4.4 229.46,69.95 229.9,70.39 229.9,72.35 230.72,73.16 v1(230.74,73.16) ; v1(221.19,81.77) 221.69,81.27 U46.B60
SUS_STAT#/LPCPD#: length 8.4
  TOP w0.102: v1(31.12,92.05) 31.39,92.31 UH1.U7
  BOTTOM w0.102: v1(31.12,92.05) 31.12,89.95 31.4,89.67 31.4,86.73 31.38,86.7 31.38,85.02 T103.1
SUSACK#: length 238.4
  TOP w0.102: v1(21.95,81.14) 21.9,81.19 RH101.1 ; v1(223.67,92.7) 224.71,91.66 224.71,89.01 223.15,87.45 223.15,81.58 224.09,80.64 v1(224.09,80.6)
  IN2 w0.127: v1(194.19,96.07) 192.77,96.07 191.83,97.01 189.11,97.01 182.84,103.29 142.91,103.29 141.29,104.91 131.71,104.91 130.11,103.31 129.49,103.31 127.26,101.08 122.24,101.08 120.73,102.59 109.67,102.59 108.78,101.7 91.87,101.7 91.72,101.85 81.79,101.85 79.7,99.76 76.94,99.76 76.37,99.19 74.7,99.19 71,95.49 71,95.33 70.62,94.95 70.62,94.24 66.49,90.1 63,90.1 62.82,89.93 61.73,89.93 v1(61.12,89.32)
  IN3 w0.127: v1(61.12,89.32) 59.34,89.32 56.66,86.64 56.4,86.64 51.65,81.89 47.21,81.89 45.36,80.05 38.73,80.05 37.69,79 34.98,79 34.33,79.65 32.4,79.65 31.81,79.06 28.59,79.06 27.77,79.88 23.15,79.88 21.95,81.07 v1(21.95,81.14)
  BOTTOM w0.102: v1(224.09,80.6) 224.02,80.52 U46.A58 ; v1(194.19,96.07) 194.22,96.1 205.01,96.1 207.81,93.3 223.43,93.3 223.67,93.06 v1(223.67,92.7) 225.62,92.7 v4(225.74,92.58)
SUSACK#_R: length 14.6
  TOP w0.089: UH1.R6 30.49,91.72 v1(30.2,92.01)
  TOP w0.102: RH101.2 21.9,83.94 RH91.2 22.17,84.47 v2(22.89,85.19) 23.59,85.89 24.05,85.89 24.9,86.74 v1(24.9,87.23)
  IN1 w0.109: v1(30.2,92.01) 30.19,92.01 29.57,91.4 29.57,89.96 27.03,87.42 25.09,87.42 v1(24.9,87.23)
SUSCLK: length 1.1
  TOP w0.102: UH1.Y6 32.55,91.72 v1(32.24,92.03)
  BOTTOM w0.089: v1(32.24,92.03) 32.17,91.96 T68.1
SW1: length 8.7
  IN1 w0.762: 239.3,52.49 239.3,55.79 239.58,56.07 239.58,56.98 242.45,59.85
  vias: v2(239.56,52.89) v3(239.3,51.73) v3(239.3,50.84) v3(243.06,60.44) v3(243.7,60.44)
SW2: length 12.3
  IN1 w0.762: 250.86,59.22 251.88,59.22 253.09,58 253.09,51.67 v3(253.83,50.94)
  BOTTOM w0.102: v2(254.48,44.02) 254.14,44.36 254.14,46.07
  vias: v3(249.37,59.64) v3(250.01,59.64)
SW_1.35V: length 14.5
  IN3 w0.762: v3(187.99,67.09) v3(187.99,67.85) 182.94,67.85 182.18,68.62 182.18,71.69 v3(180.17,73.7) v3(180.17,74.46)
  BOTTOM w0.508: PC206.1 180.11,73.63 v3(180.17,73.7)
  vias: v2(182.91,76.06)
SW_+1.05VSP: length 9
  IN1 w0.762: 21.43,141.7 21.12,141.39 21.12,133.04 20.95,132.88
  vias: v2(24.82,131.4) v3(17.47,134.02) v3(17.45,133.32) v3(17.42,132.65) v3(17.69,132.01) v3(18.2,134.02) v3(18.16,133.27) v3(18.13,132.57) v3(18.45,131.98) v3(18.87,133.26) v3(18.83,132.56) v3(19.48,132.47) v3(19.54,133.17) v3(20.18,132.45) v3(20.23,133.17) v3(22.01,142.78) v3(22.01,142.15)
SW_LAN_TX0+: length 37.1
  TOP w0.089: v1(157.01,143.4) 157.27,143.66 157.27,144 156.82,144.45 T156.1
  BOTTOM w0.089: v1(157.01,143.4) 157.01,143.47 157.26,143.72 157.41,143.72 157.46,143.67 157.46,142.69 157.39,142.61 157.39,142.29 157.46,142.22 157.46,141.95 157.39,141.87 157.39,141.56 157.46,141.48 157.46,139.99 151.47,134 133.18,134 131.33,135.85 131.33,136.26 131.43,136.36 U32.24
SW_LAN_TX0-: length 37.3
  TOP w0.089: T156.2 158.09,144.45 157.61,143.98 157.61,143.68 v1(157.88,143.41)
  BOTTOM w0.089: v1(157.88,143.41) 157.81,143.33 157.81,139.85 151.61,133.65 133.04,133.65 130.99,135.71 130.99,136.3 130.93,136.36 U32.25
SW_LAN_TX1+: length 44.8
  TOP w0.089: T156.5 161.9,144.45 162.38,143.97 162.38,143.76 v1(162.11,143.5)
  BOTTOM w0.089: v1(162.11,143.5) 162.11,143.75 162.21,143.85 162.47,143.85 162.58,143.74 162.58,142.87 162.35,142.64 161.26,142.64 161.02,142.4 160.91,142.4 160.7,142.18 160.7,142.08 160.51,141.89 160.41,141.89 160.2,141.68 160.2,141.58 159.14,140.52 159.14,139.43 152.56,132.85 131.5,132.85 129.35,135 129.35,136.26 129.43,136.33 U32.28
SW_LAN_TX1-: length 44.8
  TOP w0.089: T156.6 163.17,144.45 162.72,144.01 162.72,143.8 v1(163.03,143.5)
  BOTTOM w0.089: v1(163.03,143.5) 162.92,143.39 162.92,142.73 162.49,142.3 161.4,142.3 159.48,140.38 159.48,139.29 152.7,132.51 131.36,132.51 129.01,134.86 129.01,136.26 128.93,136.33 U32.29
SW_LAN_TX2+: length 49.9
  TOP w0.089: v1(164.68,143.52) 164.93,143.77 164.93,144.03 164.44,144.52 T156.7
  BOTTOM w0.089: U32.33 126.93,136.34 126.88,136.28 126.88,135.83 131,131.71 154.16,131.71 161.2,138.75 161.2,139.36 163.37,141.53 163.37,141.66 163.59,141.87 163.71,141.87 163.9,142.06 163.9,142.18 164.11,142.4 164.24,142.4 164.69,142.85 164.94,142.85 165.17,143.08 165.17,143.66 164.93,143.9 164.78,143.9 164.68,143.8 v1(164.68,143.52)
SW_LAN_TX2-: length 49.9
  TOP w0.089: T156.8 165.71,144.5 165.27,144.07 165.27,143.84 v1(165.59,143.52)
  BOTTOM w0.089: U32.34 126.43,136.38 126.53,136.27 126.53,135.69 130.86,131.37 154.3,131.37 161.54,138.6 161.54,139.22 164.83,142.5 165.08,142.5 165.52,142.94 165.52,143.44 v1(165.59,143.52)
SW_LAN_TX3+: length 60.3
  TOP w0.089: T156.11 169.52,144.45 169.96,144.01 169.96,143.39 169.71,143.14 v1(169.68,143.14)
  BOTTOM w0.089: v1(169.68,143.14) 169.68,143.37 169.81,143.5 169.99,143.5 170.19,143.29 170.19,142.57 169.99,142.36 169.36,142.36 169.02,142.03 168.9,142.03 168.69,141.82 168.69,141.69 168.5,141.5 168.37,141.5 168.16,141.29 168.16,141.16 167.89,140.89 164.51,140.89 163.32,139.7 163.32,138.58 161.91,137.17 161.91,135.21 161.55,134.86 159.19,134.86 154.9,130.57 128.96,130.57 124.85,134.68 124.85,136.23 124.93,136.31 U32.37
SW_LAN_TX3-: length 60.3
  TOP w0.089: T156.12 170.79,144.47 170.3,143.99 170.3,143.43 v1(170.6,143.14)
  BOTTOM w0.089: v1(170.6,143.14) 170.53,143.08 170.53,142.43 170.13,142.02 169.5,142.02 168.03,140.55 164.65,140.55 163.66,139.56 163.66,138.44 162.25,137.03 162.25,135.07 161.69,134.52 159.33,134.52 155.04,130.22 128.82,130.22 124.51,134.54 124.51,136.23 124.43,136.31 U32.38
SW_LVDS_A0+: length 19.1
  TOP w0.089: JLVDS1.22 49.69,144.95 49.61,145.03 49.32,145.03 v1(49.18,144.89)
  BOTTOM w0.089: v1(49.18,144.89) 49.32,145.03 51.23,145.03 52.99,146.8 54.49,146.8 54.72,147.03 55.3,147.03 56.63,148.35 56.63,151.88 59.04,154.29 59.88,154.29 60.23,153.93 60.23,153.52 U11.9
SW_LVDS_A0-: length 19.1
  TOP w0.089: v1(49.18,145.48) 49.28,145.37 49.61,145.37 49.69,145.45 JLVDS1.21
  BOTTOM w0.089: U11.10 60.43,154.22 60.02,154.63 58.9,154.63 v3(57.29,153.03) 56.28,152.02 56.28,148.49 55.16,147.37 54.58,147.37 54.35,147.14 52.85,147.14 51.09,145.37 49.28,145.37 v1(49.18,145.48)
SW_LVDS_A1+: length 15.2
  TOP w0.089: v1(51.47,143.9) 51.34,144.03 50.99,144.03 50.91,143.95 JLVDS1.24
  BOTTOM w0.089: v1(51.47,143.9) 51.58,144.02 52.22,144.02 54.06,145.86 v3(54.83,145.86) 55.48,145.86 57.69,148.07 57.69,151.19 58.91,152.41 59.37,152.41 59.46,152.32 U11.7
SW_LVDS_A1-: length 15.2
  TOP w0.089: v1(51.47,144.49) 51.35,144.37 50.97,144.37 50.9,144.45 JLVDS1.23
  BOTTOM w0.089: U11.8 59.43,152.82 59.36,152.75 58.77,152.75 57.35,151.33 57.35,148.21 55.34,146.2 53.92,146.2 52.08,144.36 51.6,144.36 v1(51.47,144.49)
SW_LVDS_A2+: length 16
  TOP w0.089: JLVDS1.26 49.68,142.95 49.59,143.04 49.31,143.04 v1(49.18,142.91)
  BOTTOM w0.089: U11.2 59.43,149.82 59.35,149.91 59.13,149.91 58.64,149.43 58.64,147.65 55.9,144.9 54.54,144.9 52.68,143.04 49.31,143.04 v1(49.18,142.91)
SW_LVDS_A2-: length 16.1
  TOP w0.089: v1(49.18,143.55) 49.35,143.38 49.6,143.38 49.67,143.45 JLVDS1.25
  BOTTOM w0.089: U11.3 59.46,150.32 59.39,150.25 58.98,150.25 58.3,149.57 v3(58.3,148.27) 58.3,147.79 55.76,145.25 54.4,145.25 52.53,143.38 49.35,143.38 v1(49.18,143.55)
SW_LVDS_ACLK+: length 14.5
  TOP w0.089: JLVDS1.28 50.86,141.95 50.94,142.02 51.15,142.02 52.84,143.71 53.03,143.71 53.17,143.57 C1323.1 53.68,143.67 55.23,143.67 v1(55.41,143.5)
  BOTTOM w0.089: U11.36 60.51,148.42 60.02,147.93 60.02,147.38 v3(58.16,145.52) 56.31,143.67 55.58,143.67 v1(55.41,143.5)
SW_LVDS_ACLK-: length 14.5
  TOP w0.089: JLVDS1.27 50.84,142.45 50.92,142.36 51.01,142.36 52.7,144.05 53.04,144.05 53.17,144.18 C1327.1 53.72,144.02 55.24,144.02 v1(55.41,144.18)
  BOTTOM w0.089: v1(55.41,144.18) 55.57,144.02 56.17,144.02 59.67,147.52 59.67,148.07 60.23,148.63 60.23,149.13 U11.1
SW_LVDS_B0+: length 8.7
  BOTTOM w0.089: U13.9 60.99,142.48 61.2,142.68 61.2,142.96 60.97,143.19 v3(59.22,143.19) 58.68,143.19 58.05,142.56 55.56,142.56 54.67,141.67 54.36,141.67 R230.2
SW_LVDS_B0-: length 8.7
  BOTTOM w0.089: U13.10 61.41,143.24 61.11,143.53 58.54,143.53 57.91,142.9 v3(57.21,142.9) 55.42,142.9 54.53,142.01 54.35,142.01 R227.2
SW_LVDS_B1+: length 7.7
  BOTTOM w0.089: R232.2 54.36,139.89 55.18,139.89 56.69,141.4 v3(57.34,141.4) 60.35,141.4 60.41,141.34 U13.7
SW_LVDS_B1-: length 7.7
  BOTTOM w0.089: U13.8 60.38,141.84 60.29,141.74 v3(58.59,141.74) 56.55,141.74 55.04,140.23 54.35,140.23 R231.2
SW_LVDS_B2+: length 7.7
  BOTTOM w0.089: U13.2 60.38,138.84 60.31,138.91 58.89,138.91 58.54,138.55 v3(57.18,138.55) 56.33,138.55 55.91,138.97 55.55,138.97 54.7,138.12 54.38,138.12 R234.2
SW_LVDS_B2-: length 7.7
  BOTTOM w0.089: R233.2 54.34,138.47 54.56,138.47 55.41,139.32 56.06,139.32 56.48,138.9 58.39,138.9 58.75,139.25 v3(59.13,139.25) 60.33,139.25 60.41,139.34 U13.3
SW_LVDS_BCLK+: length 9.9
  BOTTOM w0.089: R236.2 54.09,136.13 54.38,136.42 54.83,136.42 54.95,136.31 C1325.1 55.41,136.51 56.19,136.51 56.55,136.15 56.55,135.87 56.99,135.43 v3(57.96,135.43) 59.46,135.43 61.47,137.44 U13.36
SW_LVDS_BCLK-: length 9.9
  BOTTOM w0.089: U13.1 60.99,138.19 61.17,138.01 61.17,137.63 v3(59.65,136.11) 59.32,135.77 57.13,135.77 56.89,136.01 56.89,136.3 56.34,136.85 55.42,136.85 C1324.1 54.95,136.99 54.72,136.76 54.26,136.76 R235.2
SYS_LED_MASK#: length 401.4
  TOP w0.102: Q328.2 14.35,149.91 v1(15.16,150.72) ; v1(220.33,85.2) 220.33,86.68 219.72,87.29 219.72,89.8 219.66,89.86 v1(219.66,90.4) ; Q325.2 Q325.5 131.62,148.41 v2(131.5,148.53) 130.95,149.08 130.95,150.99 Q327.2 132.59,152.3 v1(133.04,151.85) ; v1(17.28,80.4) 17.28,79.69 14.99,77.4 JIO1.114
  IN1 w0.109: v1(133.04,151.85) 132.99,151.9 132.99,156.28 129.94,159.33 126.51,159.33 118.32,167.52 114.32,167.52 110.72,171.12 104.49,171.12 102.22,168.85 100.65,168.85 97.87,166.08 97.87,165.47 95.33,162.93 86.31,162.93 85.71,163.54 72.91,163.54 72.2,162.82 67.21,162.82 66,161.62 64.41,161.62 62.75,159.95 61.1,159.95 v1(60.92,160.13)
  IN2 w0.127: v1(60.92,160.13) 60.92,159.93 60.71,159.73 54.53,159.73 51.79,156.98 49.98,156.98 49.31,156.31 47.84,156.31 46.58,155.05 43.6,155.05 40.85,152.31 40.85,148.74 38.6,146.49 24.52,146.49 20.29,150.72 v1(15.16,150.72) 12.56,153.33 10.17,153.33 8.31,151.47 8.31,150.66 8.54,150.43 8.54,149.16 7.81,148.42 7.81,145.12 8.43,144.5 8.81,144.5 12.35,140.96 12.35,135.56 9.36,132.57 9.36,127.85 10.55,126.66 10.55,126.07 13.39,123.23 13.39,117.03 10.6,114.23 9.31,114.23 7.88,112.81 7.88,93.05 10.12,90.82 10.12,89.72 9.86,89.47 9.13,89.47 8.52,88.86 8.52,84.94 13.99,79.46 16.34,79.46 v1(17.28,80.4) ; v1(219.66,90.4) 219.66,91.13 217.64,93.15 205.54,93.15 200.26,98.44 199.68,98.44 196.12,101.99 187.74,101.99 182.47,107.26 178.17,107.26 176.69,108.74 176.69,120.56 171.48,125.77 171.48,127.93 171.08,128.33 165.98,128.33 164.53,129.78 156.88,129.78 155.67,130.99 155.67,134.49 147.56,142.6 147.56,144.23 143.91,147.87 135.23,147.87 133.9,149.2 133.9,150.99 v1(133.04,151.85)
  BOTTOM w0.102: Q84.2 v1(15.16,150.72) 15.63,151.19 15.63,152.28 16.97,153.63 U58.1 16.97,154.34 17.28,154.65 18.96,154.65 19.2,154.4 19.2,152.07 19.67,151.6 20.33,151.6 20.61,151.32 Q344.2 ; U46.B48 220.42,85.29 v1(220.33,85.2) ; R775.2 219.74,90.49 v1(219.66,90.4)
SYS_PWROK: length 407.5
  TOP w0.102: v1(34.7,91.91) 34.69,91.92 34.65,91.92 UH1.AD7 ; v1(232.42,73.57) 231.48,74.51 229.47,74.51 225.38,78.59 225.38,79.79 224.99,80.17 223.68,80.17 222.54,81.32 222.54,82.07 v1(221.83,82.77) ; v1(70.65,24.03) 71.13,24.51 75.1,24.51 77.33,22.29 77.33,17.3 74.66,14.63 v1(74.66,14.56)
  IN1 w0.109: v1(74.66,14.56) 74.66,14.59 75.38,15.3 75.38,18.96 83.39,26.98 88.75,26.98 89.36,27.58 90.48,27.58 91.41,26.66 104.85,26.66 107.95,23.56 132.35,23.56 132.95,22.96 194.61,22.96 196.03,24.38 201.01,24.38 201.62,23.77 221.43,23.77 v1(221.65,23.99)
  IN3 w0.127: v1(232.42,73.57) 232.52,73.57 239.78,66.3 244.13,66.3 245.2,65.24 254.94,65.24 255.14,65.44 258.78,65.44 259.44,64.78 268.87,64.78 270.91,62.74 270.91,45.68 263.58,38.34 261.78,38.34 261.45,38.01 260,38.01 258.19,39.81 253.38,39.81 249.13,35.56 238.04,35.56 228.23,25.74 228.23,24.62 227.59,23.99 v1(221.65,23.99) ; v1(49.26,78.5) 55.48,78.5 56.52,77.46 56.52,74.81 56.64,74.69 56.64,71.02 57.56,70.1 57.56,50.97 61.83,46.7 61.83,38.03 63.2,36.66 63.2,32.24 70.65,24.8 v1(70.65,24.03)
  BOTTOM w0.102: v1(74.66,14.56) 74.84,14.39 RC9.1 ; v1(49.26,78.5) 48.65,79.11 48.53,79.11 46.96,80.68 37.73,80.68 37.25,81.16 37.25,82.28 38.29,83.32 38.29,83.75 37.88,84.16 37.88,85.53 37.02,86.4 36.67,86.4 34.83,88.23 34.83,88.59 v4(34.2,89.23) 33.51,89.91 33.51,91.15 34.27,91.91 v1(34.7,91.91) ; U46.B57 v1(221.83,82.77)
SYS_PWROK_XDP: length 4.1
  TOP w0.102: v1(73.2,10.45) JXDP1.47
  BOTTOM w0.102: v1(73.2,10.45) v2(73.6,10.86) 73.95,11.2 RC124.2 RC9.2
SYS_RESET#: length 312.8
  TOP w0.102: v1(71.05,21.73) 73.2,19.58 JXDP1.48 ; UH1.AM1 37.6,89.62 37.8,89.42 37.8,88.65 39.23,87.23 39.23,86.65 40.24,85.63 40.24,83.74 40.27,83.71 40.27,81.18 40.53,80.91 41.25,80.91 41.54,81.2 v1(41.54,81.39) 42.69,81.39 43.72,80.36 44.24,80.36 45.98,78.62 v1(45.98,77.99) ; JXDP2.48 20.8,119.41 20.01,120.2 18.12,120.2 v1(17.94,120.03) ; JAPS1.13 88.48,30.01 87.99,30.49 84.93,30.49 84.42,31 83.89,31 83.43,31.46 83.43,33.12 79.15,37.4 v1(59.52,37.4)
  IN4 w0.109: v1(17.94,120.03) 17.53,120.03 16.14,118.63 16.14,116.98 14.46,115.31 14.46,114.92 13,113.46 13,112.39 12.65,112.03 12.65,111.67 12.2,111.23 12.2,108.68 10.84,107.33 10.84,103.84 11.65,103.04 11.65,101.1 12.38,100.37 12.38,93.47 13.94,91.91 15.46,91.91 17.51,89.86 17.51,89.27 21.76,85.01 25.13,85.01 26.09,84.05 30.99,84.05 31.33,83.71 31.33,83.34 31.53,83.14 33.85,83.14 35.5,81.49 36.2,81.49 36.86,82.15 40.98,82.15 41.54,81.6 v1(41.54,81.39) 41.54,81.38 41.12,80.96 39.76,80.96 37.68,78.88 37.68,78.67 35.74,76.73 35.74,68.22 38.28,65.68 38.28,56.21 40.65,53.84 40.65,51.09 37.93,48.36 37.93,40.15 40.37,37.71 40.37,33.56 41.36,32.57 41.36,28.57 44.64,25.29 44.64,22.06 50.05,16.65 60.46,16.65 65.54,21.73 v1(71.05,21.73) ; v1(59.52,37.4) 59.52,38.29 57.67,40.14 57.67,52.11 56.79,52.99 56.79,77.43 55.53,78.7 52.49,78.7 51.84,79.34 47.34,79.34 v1(45.98,77.99)
  BOTTOM w0.102: v1(45.98,77.99) 46.64,77.99 v4(46.67,78.01) ; v1(41.54,81.39) 42.02,80.91 47.05,80.91 48.55,79.41 51.77,79.41 52.41,78.78 57.06,78.78 58,79.72 61.07,79.72 61.88,78.9 67.22,78.9 70.06,76.06 RC26.1
SYSPWR_PRES: length 8.3
  BOTTOM w0.102: U51.A59 105,162.31 104.76,162.55 104.76,163.04 105.96,164.25 v2(105.96,165.67) 105.96,166.6 R876.1 105.83,167.47 105.83,168.62 R874.1
SYSTEM_ID: length 6
  BOTTOM w0.102: U51.A10 109.63,155.77 109.66,155.74 110.7,155.74 R871.2 ; v2(111.62,157.17) 111.21,156.77 R871.2 ; R871.2 111.72,155.74 112.99,155.74 C742.1
TEMP_ALERT#: length 240.6
  TOP w0.102: UH1.H6 27.55,91.72 v1(27.31,91.96) ; v1(216.92,77.37) 216.92,76.48 216.26,75.83 216.26,74.92 v1(216.67,74.51)
  IN2 w0.127: v1(27.31,91.96) 27.31,91.52 27.24,91.45 27.24,91.29 27.21,91.27 27.21,90.99 28.12,90.09 31.1,90.09 31.67,89.52 36.94,89.52 38.48,87.98 42.91,87.98 43.15,88.22 45.19,88.22 49.56,92.59 63,92.59 66.86,96.45 67.86,96.45 69.37,97.96 69.55,97.96 72.89,101.3 76.28,101.3 76.95,101.97 79.48,101.97 81.48,103.96 84.04,103.96 84.5,103.51 85.57,103.51 86.23,104.16 111.35,104.16 112.06,103.45 114.6,103.45 115.1,103.95 120.58,103.95 121.82,102.7 123.88,102.7 125.36,104.18 129.68,104.18 131.17,105.67 141.6,105.67 143.23,104.05 183.16,104.05 188.39,98.82 194.98,98.82 197.64,96.16 199.31,96.16 203.62,91.86 203.62,89.32 205.37,87.57 205.37,81.85 205.77,81.44 205.77,74.99 209.02,71.74 211.06,71.74 211.34,72.02 212.63,72.02 212.87,71.78 215.74,71.78 v1(216.26,72.3)
  BOTTOM w0.102: v1(216.67,74.51) 216.67,72.71 v1(216.26,72.3) ; RH171.2 22.31,85.51 23.12,85.51 24.27,86.66 24.27,87.49 25.23,88.46 25.23,89.11 25.8,89.69 26.41,89.69 27.07,90.35 v2(27.07,90.88) 27.07,91.72 v1(27.31,91.96) ; v1(216.92,77.37) U46.B11
THERM_STP#: length 121.3
  TOP w0.102: v1(172.69,123.91) 172.69,124.1 169.02,127.77 v2(168.52,127.77) 168.22,128.08 R395.1 167.98,129.06 167.98,129.96 168.32,130.3 U29.19
  IN1 w0.109: v1(172.69,123.91) 174.07,122.53 174.07,113.55 174.89,112.73 175.88,112.73 187.77,100.85 194.5,100.85 202.31,93.04 202.31,90.68 v1(202.32,90.66)
  BOTTOM w0.102: PR111.1 240.66,62.69 238.11,65.24 228.43,65.24 225.48,68.18 221.51,68.18 221.29,68.4 221.08,68.4 219.41,70.06 215.36,70.06 214.06,68.77 207.02,68.77 202.19,73.59 202.19,90.54 v1(202.32,90.66)
THERMATRIP2#: length 72.9
  TOP w0.102: v1(150.19,137.12) 150.17,137.11 v2(154.48,137.11) Q28.1 158.06,137.15 C327.1 R396.2
  IN3 w0.127: v1(99.22,151.97) 98.45,151.2 98.45,149.92 100.62,147.75 107.62,147.75 107.92,147.46 109.09,147.46 110.65,149.02 111.59,149.02 114.65,145.96 120.84,145.96 122.01,144.79 131.66,144.79 133.14,146.28 136.38,146.28 139.47,143.19 140.74,143.19 146.19,137.74 149.56,137.74 v1(150.19,137.12)
  BOTTOM w0.102: U51.B34 99.27,151.92 v1(99.22,151.97)
THSEL_STRAP: length 13.4
  TOP w0.102: v1(102.4,147.23) 102.4,147.44 v2(103.19,148.24) 103.64,148.68 103.64,151.42 102.8,152.26 102.8,153.63 103.03,153.86 104.12,153.86 v1(104.33,153.66)
  BOTTOM w0.102: R1069.1 102.33,147.17 v1(102.4,147.23) ; U51.B29 102.25,153.21 102.88,153.84 104.14,153.84 v1(104.33,153.66)
TMDS_DDCBUF: length 7.2
  TOP w0.102: v2(27.09,166.7) 26.63,166.24 R68.2 R66.2 26.2,164.32 26.2,163.57 25.84,163.22 25.84,162.99 24.46,161.61 U9.2
TMDS_PRE: length 5.7
  TOP w0.102: v1(17.89,157.69) 17.93,157.74 U9.20
  BOTTOM w0.102: v2(15.57,157.97) R65.2 17.18,158.23 18.7,158.23 R67.2 18.72,157.74 17.93,157.74 v1(17.89,157.69)
TMDS_RT: length 5.1
  TOP w0.102: U9.23 v1(17.89,156.54)
  BOTTOM w0.102: R71.2 17.28,154.93 18.6,154.93 R57.2 18.72,155.52 18.41,155.52 v2(17.92,156.02) 17.89,156.04 v1(17.89,156.54)
TMDSE_CON_CLK: length 16.6
  TOP w0.102: R451.2 19.29,164.17 L19.3 19.29,164.86 19.48,165.05 19.48,165.5 C1333.1 19.49,166 19.49,166.38 v5(19.28,166.59)
  IN4 w0.117: v5(19.28,166.59) 19.28,165.9 19.55,165.64 21.06,165.64 23.05,167.63 23.05,169.36 21.88,170.54 18.51,170.54 17.93,169.95 17.93,169.6 JHDMI1.10
TMDSE_CON_CLK#: length 16.6
  TOP w0.102: R452.2 20.14,164.17 L19.2 20.14,164.81 19.7,165.26 19.7,165.64 19.83,165.77 C1334.1 20.17,165.78 19.92,166.02 19.8,166.02 19.71,166.11 19.71,166.48 19.84,166.62 v1(20.04,166.62)
  IN4 w0.117: JHDMI1.12 18.41,169.08 18.24,169.08 18.16,169.16 18.16,169.86 18.61,170.3 21.78,170.3 22.82,169.26 22.82,167.73 20.96,165.87 19.65,165.87 19.52,166 19.52,166.2 19.76,166.43 19.76,166.55 19.82,166.62 v1(20.04,166.62)
TMDSE_CON_N0: length 6.2
  TOP w0.089: 16.54,167.55 16.54,167.42
  TOP w0.102: R454.2 17.4,162.97 L23.2 17.4,163.57 17.07,163.9 17.07,164.23 C1335.1 17.22,164.74 v3(17.22,165.69) 17.22,166.74 16.54,167.42 ; JHDMI1.9 16.54,167.72 16.54,167.55
TMDSE_CON_N1: length 16.8
  TOP w0.102: R456.2 15.44,162.9 L24.2 15.44,163.57 15.12,163.89 15.12,165.69 C1337.1 15.11,166.12 15.11,166.44 15.05,166.51 15.05,167.16 v1(15.23,167.35)
  IN4 w0.117: v1(15.23,167.35) 15.19,167.3 15.19,166.52 14.73,166.06 12.48,166.06 12.01,166.54 12.01,169.35 12.87,170.21 15.14,170.21 15.39,169.96 15.39,169.41 JHDMI1.6
TMDSE_CON_N2: length 9
  TOP w0.102: JHDMI1.3 13.66,167.84 13.66,167.56 12.97,166.86 11.79,166.86 11.48,166.55 11.48,165.97 C1339.1 11.46,165.37 11.46,165.16 11.58,165.03 12.26,165.03 12.62,164.68 v3(12.62,164.37) 12.62,164.15 12.24,163.76 11.83,163.76 11.51,163.44 L25.2 10.89,163.44 R458.2
TMDSE_CON_P0: length 6.2
  TOP w0.089: 16.54,167.11 16.33,167.33 16.33,167.55
  TOP w0.102: R453.2 16.55,163 L23.3 16.55,163.62 16.86,163.92 16.86,164.23 C1336.1 17.01,165.05 17.01,165.31 16.99,165.32 16.99,166 17.01,166.01 17.01,166.65 16.54,167.11 ; JHDMI1.7 16.33,167.98 16.33,167.55
TMDSE_CON_P1: length 16.8
  TOP w0.102: v1(14.47,167.3) 14.76,167.3 14.83,167.23 14.83,166.42 14.89,166.35 14.89,165.97 14.83,165.91 C1338.1 14.69,165.67 14.79,165.67 14.91,165.56 14.91,163.88 14.6,163.57 L24.3 14.6,162.9 R455.2
  IN4 w0.117: JHDMI1.4 14.67,169.14 14.85,169.14 14.97,169.25 14.97,169.5 15.15,169.69 15.15,169.86 15.04,169.97 12.97,169.97 12.24,169.25 12.24,166.64 12.58,166.3 14.63,166.3 14.95,166.62 14.95,167.04 14.82,167.17 14.82,167.3 14.72,167.4 14.56,167.4 v1(14.47,167.3)
TMDSE_CON_P2: length 8.9
  TOP w0.102: JHDMI1.1 13.35,168.24 13.45,168.15 13.45,167.65 12.88,167.08 11.71,167.08 11.26,166.63 11.26,166.03 C1340.1 11.08,165.69 11.24,165.54 11.24,165.07 11.49,164.82 12.17,164.82 12.39,164.6 12.39,164.22 12.15,163.98 11.9,163.98 11.59,164.29 L25.3 10.89,164.29 R459.2
