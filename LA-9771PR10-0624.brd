# Allegro board LA-9771PR10-0624.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3.3V_ALW on TOP (solid shape): 126.29,167.04 126.29,166.51 126.29,166.51 126.29,165.99 126.23,165.94 125.57,165.94 125.51,166 125.51,166.55 125.26,166.8 125.26,167.03 125.41,167.18 126.14,167.18
+3.3V_ALW on TOP (solid shape): 175.59,121 175.59,119.24 175.5,119.15 174.37,119.15 174.23,119.02 174.23,114.37 174.46,114.15 174.46,112.55 173.91,112 172.2,112 172.04,112.15 172.04,112.71 172.14,112.81 173.54,112.81 173.66,112.93 173.66,113.79 173.66,114.08 173.6,114.13 172.07,114.13 172,114.2 172,115.73 172.6,116.33 172.6,118.53 172.02,119.11 172.02,120.52 172.73,121.24 175.34,121.24
+3.3V_ALW on BOTTOM (solid shape): 120.2,110.47 120.2,109.45 120.12,109.37 119.45,109.37 119.36,109.46 119.36,110.09 119.86,110.58 120.08,110.58
+3.3V_ALW on BOTTOM (solid shape): 56.47,109.01 56.98,109.01 57.14,108.85 57.14,108.16 56.84,107.85 56.34,107.85 56,108.18 55.68,108.18 55.63,108.23 55.63,109.08 55.72,109.16 56.32,109.16
+3.3V_ALW on BOTTOM (solid shape): 57.23,111.84 57.23,110.64 57.11,110.51 55.67,110.51 55.62,110.56 55.62,111.1 56.49,111.98 57.1,111.98
+3.3V_ALW on BOTTOM (solid shape): 208.07,78.01 208.07,77.04 208,76.97 207.39,76.97 207.37,76.99 206.54,76.99 206.54,77 206.41,77 206.16,77.25 206.16,78.01 206.41,78.27 207.82,78.27
+3.3V_ALW on BOTTOM (solid shape): 262.54,27.6 262.54,24.8 262.29,24.55 256.32,24.55 256.07,24.8 256.07,26.2 256.32,26.45 259.24,26.45 259.5,26.71 259.5,27.6 259.75,27.85 262.29,27.85
+3.3V_ALW on BOTTOM (solid shape): 111.54,145.71 111.92,145.7 112.05,145.58 112.07,145.57 112.81,145.57 112.94,145.45 112.94,144.31 112.68,144.05 110.27,144.05 110.09,144.24 110.09,145.65 110.7,146.26 110.98,146.26
+3.3V_ALW on BOTTOM (solid shape): 86.1,136 86.1,134.72 85.89,134.5 84.34,134.5 84.31,134.52 84.27,134.54 83.69,135.12 83.69,135.99 83.71,136.02 84.43,136.02 84.5,136.08 84.51,136.08 84.51,136.1 84.54,136.12 85.99,136.12
+3.3V_ALW on BOTTOM (solid shape): 224.19,70.27 224.19,70.15 224.18,70.14 224.14,69.96 224.19,69.78 224.19,69.08 224.11,69 222.84,69 222.78,69.06 222.78,70.25 222.87,70.34 224.11,70.34
+3.3V_ALW on BOTTOM (solid shape): 227.24,85 227.24,82.84 226.98,82.59 226.12,82.59 225.97,82.74 225.97,84.43 226.12,84.72 225.97,85.01 225.97,85.71 226.53,85.71
+3.3V_ALW on BOTTOM (solid shape): 45.25,153.71 45.25,152.18 44.99,151.93 44.23,151.93 43.98,152.18 43.98,152.98 44.17,153.3 43.98,153.62 43.98,153.71 44.23,153.96 44.99,153.96
+3.3V_ALW on BOTTOM (solid shape): 109.84,169.89 109.91,169.89 109.99,169.81 109.99,169.55 109.43,169.55 109.43,169.48 109.41,169.45 109.41,169.15 109.43,169.12 109.43,169.11 109.45,169.11 109.46,169.1 109.97,169.1 109.99,169.07 109.99,168.7 109.99,168.59 109.81,168.41 108.37,168.41 108.35,168.43 108,168.43 107.86,168.57 107.86,169.71 108.11,169.96 109.76,169.96
+3.3V_ALW on BOTTOM (solid shape): 268,55.92 268,44.11 267.88,43.98 265.34,43.98 264.88,44.44 264.88,47.03 264.91,47.05 265.44,47.05 265.44,47.81 264.88,47.81 264.88,48.12 264.91,48.14 265.41,48.14 265.44,48.17 265.44,49.03 264.88,49.03 264.88,52.36 264.91,52.39 265.41,52.39 265.44,52.41 265.44,53.12 265.41,53.15 264.91,53.15 264.88,53.17 264.88,53.55 264.91,53.58 265.41,53.58 265.44,53.6 265.44,54.34 265.41,54.37 264.91,54.37 264.88,54.39 264.88,55.08 265.69,55.89 265.69,57.29 265.77,57.36 266.56,57.36
+3.3V_ALW on VCC (solid shape): outline of 45831 points within 24.42,46.77 268.51,171.87
+3.3V_ALW on IN2 (solid shape): outline of 108 points within 55.03,107.74 57.82,112.02
+3.3V_ALW on IN2 (solid shape): outline of 146 points within 83.2,134.43 93.81,140.82
+3.3V_ALW on IN2 (solid shape): outline of 198 points within 255.3,25.82 267.12,55.03
+3.3V_ALW on IN4 (solid shape): outline of 327 points within 11.21,143.8 18.83,151.42
+3.3V_ALW on IN1: 165.61,83.57 165.62,83.6 168.58,83.6 168.67,83.55 168.68,83.46 168.78,83.01 169.24,83.04 169.31,83.06 169.38,83.04 169.83,83.01 169.94,83.46 169.94,83.55 170.03,83.6 170.98,83.6 171.23,83.35 171.23,80.58 171.2,80.57 171,80.25 171.2,79.93 171.23,79.92 171.23,79.03 170.98,78.78 162.59,78.78 162.34,79.03 162.34,79.67 162.39,79.76 162.49,79.76 163.03,80.07 162.49,80.38 162.39,80.38 162.34,80.47 162.34,83.35 162.56,83.57
+3.3V_ALW_PCH on TOP (solid shape): 27.54,84.42 27.54,83.68 27.16,83.3 26.5,83.3 26.2,83.6 25.81,83.6 25.69,83.73 25.69,84.49 25.82,84.62 27.34,84.62
+3.3V_ALW_PCH on BOTTOM (solid shape): 55.3,104.94 55.3,103.19 55,102.89 53.62,102.89 53.09,103.42 53.09,105.08 53.26,105.25 54.99,105.25
+3.3V_ALW_PCH on BOTTOM (solid shape): 20.99,87.54 20.99,85.13 21.5,84.62 22.01,84.62 22.26,84.36 22.26,81.95 21.5,81.19 21.12,81.19 20.86,81.44 20.86,82.59 21.5,83.22 21.5,83.24 21.52,83.26 21.68,83.57 21.49,83.86 21.49,83.86 21.37,83.98 20.48,83.98 19.87,84.59 19.87,87.56 20.1,87.79 20.74,87.79
+3.3V_ALW_PCH on IN2 (solid shape): outline of 207 points within 20.86,81.06 36.1,84.46
+3.3V_ALW_PCH on IN2 (solid shape): outline of 1484 points within 19.86,95.16 43.34,102.53
+3.3V_ALW_PCH_U34 on BOTTOM (solid shape): 54.38,109.05 54.38,108.36 54.63,108.11 54.63,107.54 54.58,107.33 54.66,107.12 54.69,107.06 54.66,106.99 54.61,106.63 54.91,106.41 54.91,106.03 54.85,105.97 53.57,105.97 53.5,106.04 53.5,106.26 53.38,106.43 53.38,109.08 53.45,109.14 54.29,109.14
+3.3V_ALW_U46 on BOTTOM (solid shape): 208.62,76.24 208.7,76.24 209.2,75.73 209.2,74.84 209.1,74.74 206.94,74.74 206.87,74.81 206.87,76.16 207,76.28 208.58,76.28
+3.3V_ALW_U46 on IN2 (solid shape): outline of 1429 points within 208.06,75.47 226.35,82.84
+3.3V_ALW_VTR on BOTTOM (solid shape): 111.79,169.71 111.79,168.69 111.54,168.44 110.4,168.44 110.14,168.69 110.14,169.5 110.17,169.53 110.17,169.81 110.14,169.84 110.27,169.96 111.54,169.96
+3.3V_ALW_VTR on BOTTOM (solid shape): 98.21,149.36 98.21,148.12 97.95,147.86 94.9,147.86 94.55,148.22 94.55,149.41 94.75,149.62 94.82,149.62 94.88,149.64 97.92,149.64
+3.3V_ALW_VTR on IN4 (solid shape): outline of 1337 points within 95.16,147.99 114.97,161.96
+3.3V_LAN on TOP (solid shape): outline of 275 points within 117.18,155.48 150.53,173.67
+3.3V_LAN on BOTTOM (solid shape): 154.97,166.79 154.97,165.77 154.59,165.39 152.43,165.39 151.93,164.88 149.77,164.88 149.64,165.01 149.64,166.91 149.89,167.17 154.59,167.17
+3.3V_LAN on IN2 (solid shape): outline of 1463 points within 115.48,135.8 134.27,159.93
+3.3V_LAN_OUT on BOTTOM (solid shape): 121.83,155.74 121.83,153.58 121.32,153.58 121.19,153.71 121.19,155.74 121.32,155.87 121.7,155.87
+3.3V_LAN_OUT on IN2 (solid shape): outline of 515 points within 119.8,146.98 126.78,155.87
+3.3V_LAN_U63 on TOP (solid shape): 122.14,164.53 124.2,164.53 124.25,164.49 124.25,163.54 124.43,163.36 124.43,162.39 124.26,162.22 123.54,162.22 123,162.76 120.08,162.76 120.08,163.09 120.63,163.09 120.63,163.64 120.08,163.64 120.08,163.89 120.63,163.89 120.63,164.44 120.08,164.44 120.08,164.81 120.19,164.92 121.75,164.92
+3.3V_M on BOTTOM (solid shape): 51.09,99.1 51.09,98.08 50.38,97.37 49.77,97.37 49.56,97.57 49.56,99.1 49.82,99.35 50.83,99.35
+3.3V_M on BOTTOM (solid shape): 73.06,112.81 73.06,111.03 72.81,110.78 71.28,110.78 71.15,110.91 71.15,112.81 71.41,113.07 72.81,113.07
+3.3V_M on BOTTOM (solid shape): 126.1,114.67 126.1,113.29 126.01,113.2 126.01,111.55 125.74,111.28 125.65,111.28 125.34,110.96 124.68,110.96 124.68,111.43 124.13,111.43 124.13,111.72 124.68,111.72 124.68,112.23 124.13,112.23 124.13,112.52 124.69,112.52 124.69,114.37 125.24,114.92 125.84,114.92
+3.3V_M on IN2 (solid shape): 169.33,127.04 169.33,125.64 169.03,125.34 167,125.34 166.66,125.68 166.66,127.04 166.91,127.29 169.07,127.29
+3.3V_M on IN2 (solid shape): 127.27,115.01 127.27,113.98 126.85,113.56 124.23,113.56 123.77,114.02 123.77,114.71 123.89,114.83 124.16,114.83 124.64,115.31 126.97,115.31
+3.3V_M on IN3 (solid shape): outline of 988 points within 161.2,125.64 172.75,140.63
+3.3V_M on IN4 (solid shape): 172.63,140.63 172.63,139.61 172.5,139.48 169.13,139.48 169.07,139.54 169.07,140.54 169.14,140.61 170.22,140.61 170.49,140.88 172.37,140.88
+3.3V_M_U35 on BOTTOM (solid shape): 124.52,112.98 124.56,112.98 124.56,112.65 124.01,112.65 124.01,112.1 124.55,112.1 124.55,111.85 124,111.85 124,111.3 124.55,111.3 124.55,110.02 124.42,109.89 122.81,109.89 122.29,109.37 121.54,109.37 121.47,109.45 121.47,110.31 121.07,110.71 121.07,111.7 121.23,111.86 122.81,111.86 123.06,112.11 123.06,112.66 123.38,112.98 124.51,112.98
+3.3V_MXM on TOP (solid shape): 55.12,97.61 55.12,97.59 55.15,97.56 55.15,96.18 55.03,96.05 53.76,96.05 53.48,96.32 53.45,96.42 53.52,96.49 53.77,96.93 53.33,97.18 53.26,97.19 53.21,97.24 53.12,97.38 52.99,97.47 52.99,97.7 53.12,97.83 54.08,97.83 54.9,97.83
+3.3V_MXM on BOTTOM (solid shape): 52.96,104.42 52.96,103.03 52.38,102.45 51.77,102.45 51.19,103.03 51.19,103.13 50.86,103.46 50.86,104.45 51.15,104.73 52.65,104.73
+3.3V_MXM on BOTTOM (solid shape): 54.8,101.07 54.8,101.04 55.14,100.65 55.51,101.02 55.54,101.1 55.61,101.13 56.68,101.13 56.93,100.87 56.93,99.73 57.18,99.48 57.18,98.97 56.93,98.72 56.56,98.72 56.46,98.77 56.48,98.88 56.16,99.45 55.96,98.83 55.99,98.75 55.96,98.68 55.84,98.44 55.91,98.19 55.91,96.05 55.79,95.92 53.88,95.92 53.43,96.37 53.56,96.51 53.57,96.51 53.76,96.96 53.33,97.18 53.26,97.19 53.21,97.24 53.17,97.32 53.11,97.39 52.99,97.51 52.99,98.08 53.84,98.92 54,99.05 54.13,99.21 54.39,99.48 54.39,100.87 54.64,101.13 54.74,101.13
+3.3V_MXM_U34 on BOTTOM (solid shape): 54.36,112.96 54.36,110.56 54.3,110.5 52.6,110.5 52.31,110.2 52.31,107.51 52.27,107.41 52.26,107.3 52.26,106.69 52.3,106.49 52.43,106.33 52.43,105.52 52.37,105.46 51.21,105.46 51.14,105.54 51.14,108.77 51.16,108.8 51.16,111.57 53.04,113.45 53.88,113.45
+3.3V_PCIE_FLASH on BOTTOM (solid shape): outline of 557 points within 92.48,133.62 118.39,146.64
+3.3V_PCIE_WWAN on BOTTOM (solid shape): outline of 95 points within 259.48,65.65 267.4,77
+3.3V_PCIE_WWAN on IN2 (solid shape): outline of 1244 points within 247.18,65.82 263.05,89.32
+3.3V_PCIE_WWAN_U43 on BOTTOM (solid shape): 272.17,71.91 272.17,59.24 271.74,58.8 265.79,58.8 265.67,58.92 265.67,60.09 266.07,60.49 267.68,60.49 268,60.82 268,68.79 267.52,69.27 266.2,70.59 266.2,71.15 266.75,71.15 266.75,71.7 266.2,71.7 266.2,71.95 266.75,71.95 266.75,72.49 266.2,72.49 266.2,72.9 266.29,72.99 271.1,72.99
+3.3V_RUN on TOP (solid shape): 70.01,141.39 70.01,137.96 69.76,137.7 68.49,137.7 68.23,137.96 68.23,141.13 68.74,141.64 69.76,141.64
+3.3V_RUN on TOP (solid shape): 133.64,34.96 133.64,33.31 133.38,33.06 131.73,33.06 131.48,33.31 131.48,34.83 131.86,35.22 133.38,35.22
+3.3V_RUN on TOP (solid shape): 170.09,62.77 172.75,62.77 173.01,62.52 173.01,60.74 172.75,60.49 171.36,60.49 171.1,60.23 171.1,59.98 171.36,59.73 195.74,59.73 196,59.47 196,56.42 195.74,56.17 191.04,56.17 190.28,56.93 168.56,56.93 168.31,57.19 168.31,60.51 167.91,60.91 167.28,60.91 167.22,60.96 167.22,63.25 167.27,63.3 169.56,63.3
+3.3V_RUN on TOP (solid shape): 88.43,155.1 88.43,154.21 89.19,153.45 89.19,143.42 90.69,141.92 90.69,138.91 93.51,136.1 93.51,132.75 92.87,132.12 92.62,132.12 91.73,133.01 91.73,135.67 89,138.4 89,141.23 87.54,142.69 87.54,152.69 86.52,153.71 86.52,155.1 86.78,155.36 88.17,155.36
+3.3V_RUN on TOP (solid shape): outline of 88 points within 11.97,71.79 19.21,80.43
+3.3V_RUN on TOP (solid shape): outline of 3707 points within 226.73,65.95 249.34,93.25
+3.3V_RUN on BOTTOM (solid shape): 209.2,80.17 209.2,78.65 208.95,78.4 208.6,78.4 207.96,79.03 207.93,79.03 207.81,79.16 207.81,80.17 208.06,80.43 208.95,80.43
+3.3V_RUN on BOTTOM (solid shape): 91.86,144.44 91.86,142.94 91.69,142.77 88.33,142.77 88.19,142.91 88.19,143.58 88.19,143.78 88.19,144.13 88.58,144.52 91.79,144.52
+3.3V_RUN on BOTTOM (solid shape): 254.63,109.29 254.63,107.88 254.44,107.68 253.85,107.68 253.25,107.08 252.31,107.08 251.79,107.61 251.79,108.38 252.83,109.42 254.5,109.42
+3.3V_RUN on BOTTOM (solid shape): 157.72,117.13 157.72,116.9 157.69,116.88 157.16,116.88 157.16,116.42 157.18,116.39 157.69,116.39 157.72,116.37 157.72,116.11 157.46,115.86 156.37,115.86 156.12,116.11 156.12,117.04 156.46,117.38 157.46,117.38
+3.3V_RUN on BOTTOM (solid shape): 247.28,93.76 247.28,91.43 245.95,90.11 244.58,90.11 244.2,90.11 244,90.3 244,90.72 244,90.72 244,90.84 244.48,91.32 244.48,91.35 244.64,91.51 244.64,93.58 244.87,93.82 247.22,93.82
+3.3V_RUN on BOTTOM (solid shape): 27.47,160.31 27.47,158.66 26.96,158.15 26.93,158.17 26.67,158.19 26.47,158.02 25.82,158.02 25.56,158.28 25.56,160.44 25.94,160.82 26.96,160.82
+3.3V_RUN on BOTTOM (solid shape): 36.78,137.62 36.78,137.12 36.74,137.07 36.17,137.07 35.59,136.5 35.59,135.39 36.3,134.68 37.56,134.68 39.06,136.18 39.4,136.18 39.66,135.93 39.66,135.55 38.26,134.15 38.03,133.92 35.1,133.92 34.83,134.19 34.83,137.02 35.52,137.7 36.7,137.7
+3.3V_RUN on BOTTOM (solid shape): 261.83,149.91 261.83,148.25 264.31,145.77 264.31,142.63 263.32,141.64 262.14,141.64 262.01,141.67 261.88,141.64 261.88,141.64 260.64,141.64 260,142.28 260,142.46 260.02,142.56 260,142.65 260,145.06 260.63,145.68 260.63,147.39 260.31,147.71 260.31,150 260.59,150.28 261.46,150.28
+3.3V_RUN on BOTTOM (solid shape): 45.5,84.49 46.01,84.49 46.26,84.24 46.26,83.6 45.9,83.24 45.87,83.25 45.72,83.27 45.57,83.22 45.23,83.22 45.04,83.27 44.86,83.22 44.07,83.22 43.85,83.3 43.63,83.22 42.96,83.22 42.71,83.48 42.71,84.49 42.96,84.75 45.25,84.75
+3.3V_RUN on BOTTOM (solid shape): 16.48,107.59 16.48,106.23 16.93,105.79 16.93,103.92 16.8,103.8 16.34,103.8 16.23,103.68 16.23,102.41 16.18,102.36 15.42,102.36 15.33,102.45 15.33,103.51 15.02,103.82 15.02,104.43 14.88,104.57 14.87,104.58 14.81,104.66 14.74,104.71 14.73,104.72 14.65,104.8 12.39,104.8 12.18,105.01 12.18,106.8 12.27,106.89 12.53,106.89 12.91,106.51 12.91,106.14 13.45,105.6 14.31,105.6 14.63,105.27 15.49,105.27 15.57,105.28 15.65,105.31 15.66,105.32 15.78,105.32 15.91,105.45 15.91,105.83 15.56,106.18 15.49,106.18 15.46,106.21 15.46,107.64 15.54,107.73 16.34,107.73
+3.3V_RUN on BOTTOM (solid shape): 86.01,155.61 87.01,155.61 87.03,155.61 88.3,155.61 88.68,155.23 88.68,153.2 88.05,152.56 87.03,152.56 86.39,151.93 86.39,151.29 87.28,150.4 87.28,148.75 87.03,148.5 85.12,148.5 85.1,148.53 85.09,148.54 85.07,148.63 85.03,148.71 85,148.75 84.97,148.79 84.87,148.89 84.87,149.26 85.25,149.64 85.26,149.64 85.38,149.72 85.45,149.84 85.46,149.85 85.51,149.9 85.51,150.15 84.62,151.04 83.47,151.04 83.22,151.29 83.22,152.69 83.47,152.94 83.98,152.94 85.23,154.19 85.23,155.24 85.23,155.28 85.23,156.07 85.23,156.1 85.33,156.2 85.43,156.2
+3.3V_RUN on BOTTOM (solid shape): outline of 147 points within 86.36,132.3 94.01,140.09
+3.3V_RUN on BOTTOM (solid shape): outline of 200 points within 24.04,109.71 27.21,115.1
+3.3V_RUN on IN1 (solid shape): 43.04,142.4 43.06,142.38 43.1,142.35 43.14,142.32 43.19,142.3 43.24,142.28 43.29,142.28 43.34,142.28 43.47,142.15 43.47,139.86 43.09,139.48 42.33,139.48 41.06,140.75 40.55,140.75 40.17,140.37 40.17,138.97 39.91,138.72 38.9,138.72 38.64,138.97 38.64,140.12 40.27,141.74 41.94,141.74 41.94,141.69 41.95,141.64 41.97,141.59 41.99,141.54 42.02,141.49 42.06,141.46 42.1,141.42 42.14,141.4 42.19,141.38 42.25,141.36 42.3,141.36 42.35,141.36 42.4,141.38 42.45,141.4 42.5,141.42 42.54,141.46 42.58,141.49 42.61,141.54 42.63,141.59 42.65,141.64 42.66,141.69 42.66,141.74 42.65,141.8 42.63,141.85 42.61,141.9 42.58,141.94 42.54,141.98 42.5,142.01 42.45,142.04 42.4,142.06 42.35,142.07 42.3,142.07 42.25,142.07 42.19,142.06 42.14,142.04 42.1,142.01 42.06,141.98 42.02,141.94 41.99,141.9 41.97,141.85 41.95,141.8 41.94,141.74 40.27,141.74 40.44,141.92 40.49,141.92 40.54,141.94 40.59,141.96 40.64,141.99 40.68,142.02 40.72,142.07 40.75,142.11 40.77,142.16 40.78,142.22 40.79,142.26 40.93,142.4
+3.3V_RUN on IN1 (solid shape): outline of 1203 points within 15.78,150.67 30.01,166.15
+3.3V_RUN on VCC (solid shape): outline of 46222 points within 14.64,33.95 268.51,146.98
+3.3V_RUN on IN2 (solid shape): outline of 169 points within 34.83,136.94 39.4,144.82
+3.3V_RUN on IN2 (solid shape): outline of 700 points within 25.56,99.22 31.28,110.27
+3.3V_RUN on IN2 (solid shape): outline of 880 points within 107.73,133.01 118.78,157.9
+3.3V_RUN on IN2 (solid shape): outline of 3738 points within 15.78,147.61 40.55,165.9
+3.3V_RUN on IN3 (solid shape): 39.15,148.22 39.15,144.44 37.88,143.17 36.23,143.17 35.91,143.48 35.91,144.94 35.98,145.04 36.09,145.01 36.7,145.33 36.01,145.34 36,145.3 35.91,145.3 35.91,145.39 35.85,145.45 35.85,146.15 38.33,148.63 38.74,148.63
+3.3V_RUN on IN4 (solid shape): 256.14,110.54 256.14,108.31 255.51,107.68 253.66,107.68 253.5,107.83 253.5,110.32 254,110.82 255.86,110.82
+3.3V_RUN on IN4 (solid shape): 262.67,144.82 262.67,142.15 262.16,141.64 262.14,141.64 262.01,141.67 261.88,141.64 261.88,141.64 260.64,141.64 260,142.28 260,144.82 260.51,145.32 262.16,145.32
+3.3V_RUN on IN4 (solid shape): outline of 349 points within 237.63,89.25 245.92,94.34
+3.3V_RUN on IN4 (solid shape): outline of 4031 points within 129.7,26.33 172.88,61.38
+3.3V_RUN on BOTTOM: 10.4,95.01 10.19,95.22 10.19,99.53 10.65,99.99 10.65,101.74 10.8,101.89 12.61,101.89 12.86,101.64 12.86,100.11 13.12,99.86 14.89,99.86 14.91,99.87 16.04,101 16.93,101 17.18,100.75 17.18,98.84 16.93,98.59 15.15,98.59 14.51,99.22 14.49,99.22 14.48,99.23 14.3,99.27 14.12,99.22 12.23,99.22 11.97,98.97 11.97,98.92 11.97,98.91 11.96,98.83 11.97,98.75 11.97,98.74 11.97,98.59 12.1,98.46 12.73,98.46 12.86,98.33 12.86,94.55 12.74,94.43 12.13,94.43 12.06,94.5 12.06,94.88 11.93,95.01 11.88,95.01 11.87,95.02 11.67,95.07 11.48,95.01
+3.3V_RUN_TPM on BOTTOM (solid shape): 158.66,117 158.66,116.62 158.78,116.5 160.31,116.5 160.56,116.24 160.56,115.86 160.44,115.73 159.17,115.73 158.53,115.1 158.53,113.45 158.78,113.19 160.18,113.19 160.44,112.94 160.44,112.56 160.32,112.45 160.29,112.45 160.14,112.3 158.15,112.3 157.87,112.58 157.87,116.52 157.84,116.55 157.34,116.55 157.31,116.57 157.31,116.67 157.34,116.7 157.87,116.7 157.9,116.72 157.9,117.13 158.02,117.26 158.4,117.26
+3.3V_RUN_TPM on IN2 (solid shape): outline of 121 points within 158.15,112.44 170.55,117.77
+3.3V_RUN_U38 on BOTTOM (solid shape): 86.78,139.34 86.78,138.96 86.23,138.96 86.23,138.41 86.78,138.41 86.78,138.17 86.23,138.17 86.23,137.61 86.78,137.61 86.78,137.29 86.77,137.3 83.75,137.3 83.65,137.4 83.65,140.1 83.86,140.32 85.81,140.32
+3.3V_SUS on TOP (solid shape): 44.35,27.22 44.37,27.22 44.37,27.22 44.88,27.22 44.88,27.22 44.9,27.22 44.9,27.74 45.15,27.74 45.15,27.22 45.17,27.22 45.17,27.22 46.18,27.22 46.27,27.13 46.27,26.89 46.17,26.8 46.17,25.89 45.85,25.57 44.75,25.57 43.5,26.82 43.5,27.12 43.59,27.22 44.08,27.22 44.08,27.22 44.1,27.22 44.1,27.74 44.35,27.74
+3.3V_SUS on BOTTOM (solid shape): outline of 129 points within 49.56,2.32 53.88,8.93
+3.3V_SUS_U57 on TOP (solid shape): 47.78,34.06 47.78,30.58 47.19,29.98 46.87,29.98 46.52,29.63 46.52,27.62 46.25,27.35 45.28,27.35 45.28,27.87 44.77,27.87 44.77,27.35 44.48,27.35 44.48,27.87 43.97,27.87 43.97,27.35 43.56,27.35 43.5,27.41 43.5,28.16 43.63,28.28 43.96,28.28 45.71,30.03 45.9,30.23 45.9,31.5 45.7,31.7 45.65,31.7 45.65,32.76 45.08,32.76 44.97,32.87 44.97,34.21 45.13,34.37 47.48,34.37
+3.3V_WLAN on TOP (solid shape): 124.49,168.33 124.49,166.8 124.25,166.56 124.25,166 124.18,165.93 123.5,165.93 123.31,166.13 123.31,168.2 123.51,168.4 124.41,168.4
+3.3V_WLAN on TOP (solid shape): outline of 1201 points within 138.34,138.85 153.96,163.87
+3.3V_WLAN on BOTTOM (solid shape): 150.15,146.21 151.13,146.21 151.19,146.16 151.85,146.16 152.05,145.96 152.05,143.55 151.93,143.42 150.28,143.42 150.02,143.67 150.02,144.82 148.88,145.96 148.5,145.96 148.24,146.21 148.24,146.85 148.5,147.1 149.26,147.1
+3.3V_WLAN on BOTTOM (solid shape): 137.05,157.87 137.05,156.76 136.92,156.63 135.04,156.63 134.53,156.12 133.74,156.12 130.46,156.12 130.44,156.14 130.44,157.36 130.59,157.52 130.97,157.52 131.1,157.39 132.73,157.39 132.75,157.39 133.64,157.39 133.66,157.39 134.53,157.39 135.19,158.05 136.87,158.05
+3.3V_WLAN on IN2 (solid shape): outline of 118 points within 130.08,152.31 139.61,157.52
+3.3V_WLAN on IN2 (solid shape): outline of 253 points within 123.31,158.93 143.62,167.64
+3VALWP on BOTTOM (solid shape): 263.81,55.54 264.06,55.54 264.06,55.53 264.45,55.53 264.7,55.28 264.7,43.47 264.45,43.22 259.11,43.22 258.86,43.47 258.86,57.31 259.11,57.57 261.78,57.57
+5V_ALW on TOP (solid shape): 22.64,144.44 22.64,143.29 22.51,143.17 22.26,143.17 22.13,143.29 21.62,143.29 21.5,143.42 21.5,144.44 21.62,144.56 22.51,144.56
+5V_ALW on TOP (solid shape): 43.6,31.41 43.6,30.67 43.83,30.43 43.83,29.95 44.1,29.69 44.1,29.27 43.89,29.07 43.19,29.07 42.96,29.29 42.96,30.65 42.96,30.65 42.96,31.48 43.01,31.53 43.47,31.53
+5V_ALW on TOP (solid shape): 68.23,163.43 68.23,157.9 67.98,157.64 65.06,157.64 64.8,157.9 64.8,158.83 66.43,158.83 66.43,158.77 66.44,158.72 66.45,158.67 66.48,158.62 66.51,158.58 66.54,158.54 66.58,158.5 66.63,158.48 66.68,158.46 66.73,158.45 66.79,158.44 66.84,158.45 66.89,158.46 66.94,158.48 66.99,158.5 67.03,158.54 67.06,158.58 67.09,158.62 67.12,158.67 67.13,158.72 67.14,158.77 67.14,158.83 67.13,158.88 67.12,158.93 67.09,158.98 67.06,159.02 67.03,159.06 66.99,159.09 66.94,159.12 66.89,159.14 66.84,159.15 66.79,159.16 66.73,159.15 66.68,159.14 66.63,159.12 66.58,159.09 66.54,159.06 66.51,159.02 66.48,158.98 66.45,158.93 66.44,158.88 66.43,158.83 64.8,158.83 64.8,162.09 65.06,162.34 67.09,162.34 67.41,162.66 67.41,163.37 67.52,163.49 68.18,163.49
+5V_ALW on TOP (solid shape): 4.73,84.64 4.73,83.9 5.03,83.6 6.38,83.6 7,84.22 7.85,84.22 7.91,84.22 7.97,84.24 8.67,84.24 8.92,83.98 8.92,78.65 8.67,78.4 5.24,78.4 5.03,78.61 5.03,78.63 4.93,78.95 4.62,79.05 4.59,79.05 4.48,79.16 4.48,79.79 4.76,80.07 4.78,80.06 5.24,80.34 4.91,80.76 4.87,80.77 4.86,80.81 4.86,82.46 4.61,82.71 4.1,82.71 3.84,82.97 3.84,83.48 4.23,83.86 4.23,84.66 4.34,84.77 4.6,84.77
+5V_ALW on TOP (solid shape): 123.48,27.34 123.48,23.91 123.73,23.66 131.48,23.66 134.78,20.36 134.78,15.78 134.57,15.57 131.82,15.57 131.61,15.78 131.61,19.05 130.17,20.48 120.56,20.48 120.3,20.74 120.3,24.55 120.05,24.8 102.81,24.8 102.63,24.81 102.45,24.8 102.32,24.8 102.32,24.81 102.21,24.81 101.89,24.8 101.86,24.77 101.84,24.77 99.61,23.64 98.48,21.41 98.48,21.39 98.46,21.37 98.43,20.8 98.46,20.1 98.21,19.85 96.82,19.85 96.7,19.98 96.7,21.39 95.28,22.8 95.28,25.69 96.6,27.01 96.63,27 98.79,26.83 100.82,27.6 123.22,27.6
+5V_ALW on BOTTOM (solid shape): 120.2,107.91 120.2,106.61 119.41,105.83 117.89,105.83 117.64,106.08 117.64,107.73 117.89,107.99 120.12,107.99
+5V_ALW on BOTTOM (solid shape): 181.44,78.27 182.91,78.27 183.17,78.01 183.17,77.51 182.93,77.26 180.76,77.26 180.37,77.65 180.37,78.27 180.58,78.47 181.24,78.47
+5V_ALW on BOTTOM (solid shape): 220.25,58.58 220.25,57.82 220.13,57.69 218.09,57.69 217.38,56.98 216.77,56.98 216.7,57.06 216.7,57.57 216.57,57.69 215.81,57.69 215.55,57.95 215.55,58.46 215.81,58.71 220.13,58.71
+5V_ALW on BOTTOM (solid shape): 230.62,42.38 230.62,41.87 230.64,41.84 231.35,41.84 231.38,41.87 231.38,42.38 231.4,42.4 231.81,42.4 231.83,42.38 231.83,41.87 231.86,41.84 232.57,41.84 232.6,41.87 232.6,42.38 232.62,42.4 236.28,42.4 236.28,41.84 237.04,41.84 237.04,42.4 237.5,42.4 237.5,41.84 238.24,41.84 238.24,42.4 239.86,42.4 240.06,42.2 240.06,40.3 239.81,40.04 229.78,40.04 229.52,40.3 229.52,42.35 229.57,42.4 230.59,42.4
+5V_ALW on BOTTOM (solid shape): 257.46,99.22 257.46,98.33 257.84,97.95 257.84,93.76 257.59,93.51 255.81,93.51 255.56,93.76 255.56,94.91 255.05,95.41 255.05,96.83 255.34,97.12 255.84,97.12 256.06,97.35 256.43,97.35 256.51,97.42 256.52,97.43 256.69,97.67 256.55,97.93 256.5,98 256.53,98.09 256.57,98.13 256.57,98.29 256.58,98.3 256.58,98.53 256.59,98.57 256.59,98.61 256.59,99.12 256.83,99.35 257.34,99.35
+5V_ALW on BOTTOM (solid shape): outline of 102 points within 49.18,68.49 53.89,75.09
+5V_ALW on VCC (solid shape): outline of 45112 points within 1.02,9.56 274.53,163.99
+5V_ALW on IN2 (solid shape): 265.08,25.18 265.08,22.52 264.83,22.26 256.07,22.26 255.81,22.52 255.81,25.18 256.07,25.44 264.83,25.44
+5V_ALW on IN2 (solid shape): 260.57,97.52 260.54,97.46 260.52,97.41 260.51,97.35 260.51,97.3 260.52,97.24 260.53,97.19 260.56,97.14 260.59,97.09 260.62,97.05 260.66,97.01 260.71,96.98 260.76,96.96 260.82,96.94 260.87,96.94 260.93,96.94 260.98,96.95 261.03,96.96 261.09,96.99 264.58,93.51 264.58,90.14 263.56,89.13 261.97,89.13 261.27,89.83 260,89.83 255.43,94.4 255.43,95.67 260,95.67 260.01,95.61 260.02,95.56 260.04,95.5 260.07,95.46 260.1,95.41 260.14,95.37 260.19,95.34 260.23,95.32 260.29,95.3 260.34,95.29 260.4,95.29 260.45,95.29 260.51,95.31 260.56,95.33 260.61,95.36 260.65,95.39 260.69,95.43 260.72,95.48 260.74,95.53 260.76,95.58 260.77,95.64 260.77,95.69 260.76,95.75 260.74,95.8 260.72,95.85 260.69,95.9 260.65,95.94 260.61,95.98 260.56,96.01 260.51,96.03 260.45,96.04 260.4,96.05 260.34,96.05 260.29,96.04 260.23,96.02 260.19,95.99 260.14,95.96 260.1,95.92 260.07,95.88 260.04,95.83 260.02,95.78 260.01,95.72 260,95.67 255.43,95.67 255.43,96.15 257.32,98.04 257.32,98.07 257.59,98.33 259.75,98.33
+5V_ALW on IN4 (solid shape): 108.62,24.29 135.16,24.29 135.42,24.04 135.42,15.78 135.21,15.57 131.82,15.57 131.61,15.78 131.61,18.96 131.6,18.97 131.6,19.14 130.26,20.48 106.59,20.48 103.67,23.4 100.62,23.4 99.22,22.01 99.22,21.37 97.89,20.04 97.89,20.04 97.67,19.81 96.85,19.81 96.69,19.97 96.69,21.77 95.47,22.99 95.47,24.23 98.46,27.21 105.7,27.21
+5V_ALW2 on BOTTOM (solid shape): 246.71,58.29 246.71,57.03 246.71,57.03 246.71,56.81 246.25,56.35 246.25,55.87 246.21,55.83 245.36,55.83 245.32,55.87 245.32,56.5 245.5,56.68 246.13,56.68 246.19,56.73 246.2,56.73 246.29,56.79 246.36,56.87 246.4,56.92 246.45,57 246.46,57.05 246.48,57.08 246.48,58.02 246.48,58.08 246.45,58.16 246.45,58.27 246.53,58.35 246.65,58.35
+5V_ESATA_PWR on TOP (solid shape): 67.44,167.58 67.41,167.54 67.37,167.3 67.53,167.11 67.54,167.11 67.61,167.04 67.98,167.04 68.23,166.79 68.23,165.64 68.11,165.52 67.53,165.52 67.41,165.64 67.41,166.34 67.21,166.53 66.2,166.53 65.95,166.28 65.95,165.39 65.69,165.14 64.3,165.14 64.04,165.39 64.04,167.68 64.3,167.93 67.09,167.93
+5V_ESATA_PWR on BOTTOM (solid shape): outline of 130 points within 62.52,159.37 66.96,167.93
+5V_ESATA_PWR on IN3 (solid shape): outline of 782 points within 42.71,155.74 67.85,172.5
+5V_HDD on TOP (solid shape): 172.88,71.41 172.88,68.49 172.63,68.24 169.33,68.24 168.95,68.62 168.95,71.21 169.4,71.66 172.63,71.66
+5V_HDD on BOTTOM (solid shape): 170.65,71.77 170.65,71.18 171.1,71.18 171.1,70.9 170.65,70.9 170.65,70.39 171.1,70.39 171.1,70.11 170.65,70.11 170.65,68.67 170.34,68.36 168.69,68.36 168.44,68.62 168.44,70.39 168.18,70.65 167.55,70.65 167.29,70.9 167.29,71.54 167.55,71.79 170.62,71.79
+5V_MOD on TOP (solid shape): 42.88,36.05 42.88,34.91 43.6,34.2 43.6,32.93 43.47,32.8 42.91,32.8 42.83,32.8 42.58,33.06 42.58,33.31 42.07,33.82 41.06,33.82 40.67,34.2 38.64,34.2 38.41,34.43 35.3,34.43 35.12,34.61 35.12,35.96 35.39,36.23 38.13,36.23 38.39,36.49 42.45,36.49
+5V_MXM on TOP (solid shape): 124.37,107.61 124.37,104.3 124.24,104.18 122.21,104.18 122.08,104.3 122.08,106.34 121.83,106.59 121.83,107.86 121.95,107.99 123.99,107.99
+5V_MXM on BOTTOM (solid shape): outline of 209 points within 122.03,105.14 127.73,108.53
+5V_MXM_U35 on BOTTOM (solid shape): 127.72,111.02 127.74,110.99 127.74,108.19 127.66,108.1 127.28,108.1 127.28,108.65 126.72,108.65 126.72,108.1 126.48,108.1 126.48,108.65 125.92,108.65 125.92,108.11 125.92,108.1 125.49,108.1 124.67,107.29 121.6,107.29 121.47,107.42 121.47,107.91 121.57,108.01 124.4,108.01 124.45,108.06 124.47,108.06 124.47,108.08 125.41,109.02 125.41,110.86 125.7,111.15 127.59,111.15
+5V_RUN on TOP (solid shape): 184.06,113.57 184.06,113.32 183.8,113.07 176.06,113.07 175.8,113.32 175.8,113.57 176.06,113.83 183.8,113.83
+5V_RUN on TOP (solid shape): 93,156.63 93,155.1 92.74,154.85 91.73,154.85 91.22,155.36 91.22,156.5 91.6,156.88 92.74,156.88
+5V_RUN on TOP (solid shape): 174.66,143.29 174.66,141.62 174.66,140.75 174.28,140.37 172.42,140.37 172.11,140.68 172.11,142.34 172.33,142.56 172.33,143.54 172.46,143.67 174.28,143.67
+5V_RUN on TOP (solid shape): 6.04,72.81 8.67,72.81 8.92,72.55 8.92,71.41 8.67,71.16 6.26,71.16 6,70.9 4.35,70.9 3.59,71.66 3.59,72.43 3.84,72.68 4.48,72.68 4.7,72.9 5.94,72.9
+5V_RUN on TOP (solid shape): outline of 95 points within 11.56,127.16 16.29,134.28
+5V_RUN on BOTTOM (solid shape): 56.51,76.52 56.51,73.04 56.38,72.91 54.8,72.91 54.46,73.25 54.46,76.17 54.91,76.62 56.42,76.62
+5V_RUN on BOTTOM (solid shape): 174.02,73.19 174.02,71.79 173.9,71.66 173.77,71.66 172.25,70.14 172.25,68.36 172.12,68.24 170.87,68.24 170.77,68.34 170.77,68.61 170.77,68.61 170.77,69.99 171.23,69.99 171.31,69.99 171.31,70.52 171.23,70.52 170.77,70.52 170.77,70.77 171.23,70.77 171.31,70.78 171.31,71.31 170.77,71.31 170.77,71.82 170.77,71.82 170.77,72.98 171.1,73.32 173.9,73.32
+5V_RUN on BOTTOM (solid shape): 81.31,161.96 81.31,161.07 80.43,160.18 80.43,159.93 80.68,159.68 80.99,159.68 81.06,159.65 81.13,159.65 81.47,159.65 81.62,159.5 81.62,159.47 81.57,159.42 80.68,159.42 80.55,159.55 79.76,159.55 79.5,159.28 79.49,159.28 79.26,159.07 79.28,158.75 79.28,158.53 78.77,158.02 78.52,158.02 78.39,158.15 78.39,160.31 78.52,160.44 79.66,160.44 79.79,160.56 79.79,161.83 80.02,162.06 81.21,162.06
+5V_RUN on BOTTOM (solid shape): 175.44,145.45 175.44,145.07 175.18,144.82 174.04,144.82 173.71,144.49 173.71,141.03 173.71,140.48 173.47,140.24 172.98,140.24 171.28,140.24 171.11,140.41 171.11,143.61 171.29,143.61 171.29,143.56 171.3,143.5 171.32,143.45 171.34,143.41 171.37,143.36 171.41,143.32 171.45,143.29 171.49,143.26 171.54,143.24 171.6,143.23 171.65,143.23 171.7,143.23 171.75,143.24 171.8,143.26 171.85,143.29 171.89,143.32 171.93,143.36 171.96,143.41 171.98,143.45 172,143.5 172,143.56 172,143.61 172,143.66 171.98,143.71 171.96,143.76 171.93,143.81 171.89,143.85 171.85,143.88 171.8,143.91 171.75,143.92 171.7,143.94 171.65,143.94 171.6,143.94 171.54,143.92 171.49,143.91 171.45,143.88 171.41,143.85 171.37,143.81 171.34,143.76 171.32,143.71 171.3,143.66 171.29,143.61 171.11,143.61 171.11,145.36 171.46,145.71 175.18,145.71
+5V_RUN on BOTTOM (solid shape): 10.36,154.84 10.39,154.76 10.34,154.68 10.18,154.53 10.12,154.32 10.12,154.27 10.28,153.94 10.64,153.88 10.67,153.89 10.91,153.66 10.91,152.9 10.85,152.83 10.81,152.74 10.81,152.73 10.7,152.63 9.29,152.63 8.83,153.09 8.8,153.18 8.85,153.25 9.02,153.4 9.08,153.62 9.08,153.67 8.98,153.94 8.73,154.07 8.68,154.08 8.68,154.62 9.05,154.99 10.22,154.99
+5V_RUN on BOTTOM (solid shape): outline of 95 points within 81.57,157.39 96.43,173.65
+5V_RUN on BOTTOM (solid shape): outline of 247 points within 24.42,163.23 37.5,166.28
+5V_RUN on BOTTOM (solid shape): outline of 291 points within 173.26,89.06 184.06,123.1
+5V_RUN on BOTTOM (solid shape): outline of 351 points within 3.97,93.64 16.66,132.62
+5V_RUN on VCC (solid shape): outline of 1460 points within 91.96,137.85 179,174.58
+5V_RUN on VCC (solid shape): outline of 7259 points within 53.88,69.63 160.44,95.54
+5V_RUN on IN2 (solid shape): outline of 199 points within 156.63,88.05 175.93,93.64
+5V_RUN on IN2 (solid shape): outline of 388 points within 172.46,121.32 179.87,143.8
+5V_RUN on IN2 (solid shape): outline of 637 points within 7.15,154.34 96.55,174.28
+5V_RUN on IN2 (solid shape): outline of 743 points within 78.14,155.48 91.98,159.8
+5V_RUN on IN2 (solid shape): outline of 6048 points within 1.69,34.96 57.18,94.78
+5V_RUN on IN3 (solid shape): outline of 471 points within 7.27,127.16 15.66,155.23
+5V_RUN on IN4 (solid shape): outline of 206 points within 1.18,71.54 6.53,95.29
+5V_RUN on IN3: 172.5,71.16 172.25,71.41 172.25,73.82 170.34,75.73 170.34,76.74 169.83,77.25 167.69,77.25 167.39,77.4 167.1,77.25 161.71,77.25 161.16,77.8 161.17,77.82 161.07,78.14 160.75,78.24 160.72,78.23 159.05,79.9 159.05,82.06 158.66,82.45 158.66,89.95 158.29,90.31 158.29,90.33 158.22,90.51 158.1,90.67 157.13,91.65 156.96,91.65 156.63,91.98 156.63,93.51 156.88,93.76 159.55,93.76 163.36,89.95 163.36,83.19 163.31,83.18 163.03,82.69 163.58,82.55 163.62,82.58 164.25,81.95 169.07,81.95 173.61,77.41 173.63,77.31 173.56,77.24 173.3,76.7 173.89,76.58 173.96,76.61 174.03,76.58 174.23,76.49 174.45,76.53 174.48,76.54 175.04,75.98 175.04,71.41 174.79,71.16
+5V_RUN_U37 on BOTTOM (solid shape): 54.31,78.1 54.31,75.45 54.28,75.43 53.76,75.43 53.76,75.42 53.76,74.88 53.76,74.87 54.31,74.87 54.31,74.87 54.31,74.63 54.31,74.63 53.76,74.63 53.76,74.08 53.77,74.07 54.3,74.07 54.31,74.06 54.31,73.75 54.3,73.75 52.59,73.75 52.44,73.89 52.44,76.19 52.15,76.48 51.41,76.48 51.3,76.59 51.3,77.29 51.63,77.62 51.63,78.01 51.91,78.29 54.12,78.29
+5V_USB_PWR1 on TOP (solid shape): outline of 261 points within 255.69,102.65 270.04,110.65
+5V_USB_PWR1 on BOTTOM (solid shape): 257.02,104.35 257.02,102.59 256.96,102.53 256.96,101.51 256.89,101.45 256.76,101.45 256.7,101.51 256.7,102.27 256.19,102.78 255.94,102.78 255.81,102.91 255.81,104.34 255.92,104.44 256.93,104.44
+5V_USB_PWR1 on BOTTOM (solid shape): 261.27,118.27 261.27,117.51 261.19,117.37 261.17,117.2 261.17,117.17 261.13,117.15 260.79,116.76 261.06,116.32 261.06,116.05 261.27,115.83 261.27,114.64 261.06,114.42 256.8,114.42 255.7,115.53 255.7,118.1 256.13,118.53 261.02,118.53
+5V_USB_PWR1 on IN4 (solid shape): outline of 120 points within 255.09,102.78 265.2,115.86
+5V_USB_PWR2 on BOTTOM (solid shape): 259.57,103.63 259.57,102.79 259.25,102.46 257.78,102.46 257.53,102.21 257.53,101.57 257.4,101.45 257.21,101.45 257.15,101.51 257.15,103.8 257.46,104.11 259.09,104.11
+5V_USB_PWR2 on BOTTOM (solid shape): outline of 222 points within 257.72,128.69 265.91,136.31
+5V_USB_PWR2 on IN3 (solid shape): outline of 710 points within 257.08,102.72 266.21,133.43
+5VALWP on BOTTOM (solid shape): 235.49,57.44 235.49,44.99 235.75,44.74 239.56,44.74 239.81,44.49 239.81,42.71 239.66,42.56 238.08,42.56 238.08,42 237.65,42 237.65,42.56 236.89,42.56 236.89,42 236.46,42 236.46,42.53 236.43,42.56 232.44,42.56 232.42,42.53 232.42,42.05 232.39,42.02 232.01,42.02 231.99,42.05 231.99,42.53 231.96,42.56 231.25,42.56 231.22,42.53 231.22,42.07 231.17,42.02 230.82,42.02 230.79,42.05 230.79,42.53 230.77,42.56 229.6,42.56 229.52,42.63 229.52,57.44 229.78,57.69 235.24,57.69
+AVCC33 on BOTTOM (solid shape): 83.73,147.99 86.52,147.99 86.78,147.74 86.78,147.1 86.52,146.85 82.97,146.85 82.2,147.61 80.17,147.61 79.92,147.86 79.92,148.37 80.17,148.63 83.09,148.63
+DVCC33 on TOP (solid shape): 75.85,144.18 75.85,143.42 75.47,143.04 74.74,143.04 74.56,143.09 74.37,143.04 73.75,143.04 73.74,143.04 73.62,143.06 73.49,143.04 73.48,143.04 73.31,143.04 71.92,141.64 71.92,140.12 71.79,139.99 70.65,139.99 70.52,140.12 70.52,144.05 70.77,144.31 75.73,144.31
+VCC_CORE on TOP (solid shape): outline of 2678 points within 49.95,44.99 91.6,69.89
+VCC_CORE on BOTTOM (solid shape): outline of 2035 points within 49.95,45.12 91.6,70.52
+VCC_CORE on IN1 (solid shape): 56.04,54.9 56.04,48.3 55.91,48.17 53.63,48.17 52.99,48.8 52.49,48.8 51.34,47.66 50.07,47.66 49.82,47.92 49.82,52.49 52.49,55.15 55.79,55.15
+VCC_CORE on IN1 (solid shape): 52.61,67.47 54.9,67.47 55.79,66.58 55.79,65.38 55.75,65.37 55.51,65.01 55.75,64.65 55.79,64.64 55.79,62.18 55.75,62.17 55.51,61.81 55.75,61.45 55.79,61.44 55.79,59.33 55.75,59.32 55.51,58.96 55.75,58.61 55.79,58.59 55.79,58.33 55.53,58.08 55.15,58.08 53.5,59.73 52.36,59.73 51.47,58.84 50.07,58.84 49.82,59.09 49.82,67.73 50.07,67.98 52.1,67.98
+VCC_CORE on IN1 (solid shape): outline of 1304 points within 72.81,54.52 82.58,69.25
+VCC_CORE on VCC (solid shape): outline of 14280 points within 49.95,35.34 93.38,71.03
+VCC_CORE on IN2 (solid shape): 56.04,54.9 56.04,48.3 55.91,48.17 53.63,48.17 52.99,48.8 52.49,48.8 51.34,47.66 50.07,47.66 49.82,47.92 49.82,52.49 52.49,55.15 55.79,55.15
+VCC_CORE on IN3 (solid shape): 56.04,54.9 56.04,48.3 55.91,48.17 53.63,48.17 52.99,48.8 52.49,48.8 51.34,47.66 50.07,47.66 49.82,47.92 49.82,52.49 52.49,55.15 55.79,55.15
+VCC_CORE on IN3 (solid shape): 52.61,67.47 54.9,67.47 55.79,66.58 55.79,65.38 55.75,65.37 55.51,65.01 55.75,64.65 55.79,64.64 55.79,62.18 55.75,62.17 55.51,61.81 55.75,61.45 55.79,61.44 55.79,59.33 55.75,59.32 55.51,58.96 55.75,58.61 55.79,58.59 55.79,58.33 55.53,58.08 55.15,58.08 53.5,59.73 52.36,59.73 51.47,58.84 50.07,58.84 49.82,59.09 49.82,67.73 50.07,67.98 52.1,67.98
+VCC_CORE on IN4 (solid shape): 56.02,54.92 56.02,52.67 56.04,52.64 56.04,48.3 55.91,48.17 53.63,48.17 52.99,48.8 52.49,48.8 51.34,47.66 50.07,47.66 49.82,47.92 49.82,52.49 52.49,55.15 55.79,55.15
+VCC_CORE on IN4 (solid shape): 52.61,67.47 54.9,67.47 55.79,66.58 55.79,65.38 55.75,65.37 55.51,65.01 55.75,64.65 55.79,64.64 55.79,62.18 55.75,62.17 55.51,61.81 55.75,61.45 55.79,61.44 55.79,59.33 55.75,59.32 55.51,58.96 55.75,58.61 55.79,58.59 55.79,58.33 55.53,58.08 55.15,58.08 53.5,59.73 52.36,59.73 51.47,58.84 50.07,58.84 49.82,59.09 49.82,67.73 50.07,67.98 52.1,67.98
+VCC_CORE on IN4 (solid shape): outline of 598 points within 71.98,59.22 79.28,69
+VCCST on BOTTOM (solid shape): 67.92,75.12 67.92,71.28 67.72,71.08 66.72,71.08 66.64,71.16 66.64,75.41 66.8,75.57 67.47,75.57
GND on TOP (solid shape): 20.86,130.85 20.86,127.8 20.74,127.67 16.93,127.67 16.67,127.93 16.67,130.85 16.93,131.1 20.61,131.1
GND on TOP (solid shape): 24.29,78.4 24.29,75.22 23.91,74.84 20.99,74.84 20.61,75.22 20.61,78.4 20.79,78.57 24.11,78.57
GND on TOP (solid shape): 70.14,161.96 70.14,158.15 69.88,157.9 68.74,157.9 68.49,158.15 68.49,161.96 68.74,162.22 69.88,162.22
GND on TOP (solid shape): 77.89,149.52 77.89,144.69 77.76,144.56 72.68,144.56 72.55,144.69 72.55,149.64 72.81,149.9 77.5,149.9
GND on TOP (solid shape): 122.34,160.82 122.34,160.56 121.95,160.18 119.29,160.18 119.03,160.44 119.03,161.33 119.29,161.58 121.57,161.58
GND on TOP (solid shape): 132.37,139.74 132.37,137.45 132.11,137.2 124.49,137.2 124.24,137.45 124.24,139.74 124.49,139.99 132.11,139.99
GND on TOP (solid shape): 173.64,38.39 173.64,36.36 173.39,36.1 169.33,36.1 169.07,36.36 169.07,38.39 169.33,38.64 173.39,38.64
GND on TOP (solid shape): 47.88,36.2 47.88,35.05 47.75,34.92 46.24,34.92 46.23,34.92 45.87,34.92 45.64,35.15 45.64,36.31 45.83,36.5 47.59,36.5
GND on TOP (solid shape): 131.23,34.96 131.23,33.31 130.97,33.06 129.7,33.06 129.45,32.8 129.45,31.41 129.32,31.28 121.19,31.28 121.19,35.09 121.32,35.22 130.97,35.22
GND on TOP (solid shape): 166.62,73.25 166.62,69.68 166.4,69.47 164.55,69.47 164.19,69.83 164.19,73.07 164.53,73.42 166.45,73.42
GND on TOP (solid shape): 167.04,84.48 167.04,79.34 166.81,79.12 164.36,79.12 164.12,79.36 164.12,84.46 164.31,84.66 166.86,84.66
GND on TOP (solid shape): 24.04,71.41 24.04,66.33 24.04,66.33 24.04,65.23 23.92,65.11 20.56,65.11 20.35,65.32 20.35,71.41 20.61,71.66 23.78,71.66
GND on TOP (solid shape): 69.95,165.07 69.95,164.06 69.57,163.68 67.41,163.68 67.22,163.49 67.22,162.89 67.01,162.68 64.17,162.68 64.06,162.8 64.06,164.7 64.23,164.88 65.95,164.88 66.39,165.33 69.69,165.33
GND on TOP (solid shape): 125,153.45 125,148.88 124.75,148.63 122.72,148.63 122.59,148.5 119.8,148.5 119.67,148.63 119.67,149.64 120.05,150.02 120.05,152.06 119.67,152.44 119.67,153.58 119.8,153.71 124.75,153.71
GND on TOP (solid shape): 39.9,122.35 39.91,122.18 39.91,121.7 39.66,121.45 37.7,121.45 37.7,121.47 37.09,121.47 36.86,121.7 36.86,122.34 37.12,122.59 39.66,122.59
GND on TOP (solid shape): 47.3,137.92 47.3,136.34 49.46,134.18 49.89,134.18 50.03,134.04 50.03,133.1 49.9,132.97 46.55,132.97 46.12,133.4 46.12,135.24 46.11,135.25 46.11,135.27 45.65,135.73 45.65,137.93 45.76,138.03 47.18,138.03
GND on TOP (solid shape): 136.43,90.45 136.43,69.63 136.18,69.38 135.8,69.38 135.04,70.14 135.04,82.97 134.91,83.09 134.91,83.6 134.88,83.63 134.88,83.66 134.26,84.29 134.22,84.29 134.15,84.36 134.15,89.06 135.67,90.59 136.3,90.59
GND on TOP (solid shape): 22.64,146.59 22.64,145.96 22.89,145.71 24.44,145.71 24.55,145.6 24.55,144.94 24.44,144.84 19.11,144.84 18.93,145.02 18.93,145.5 19.13,145.7 19.85,145.71 20.15,146.01 20.15,146.62 20.2,146.67 22.56,146.67
GND on TOP (solid shape): 142.27,104.18 146.34,104.18 146.59,103.92 146.59,101.13 146.97,100.75 153.2,100.75 153.45,100.49 153.45,95.92 153.2,95.67 151.55,95.67 148.12,99.1 140.62,99.1 140.37,99.35 140.37,103.54 139.99,103.92 138.72,103.92 138.59,104.05 138.59,104.94 138.72,105.07 141.39,105.07
GND on TOP (solid shape): 163.86,65.01 163.86,64.71 164.59,63.98 166.66,63.98 166.9,63.74 166.9,60.85 167,60.74 167.82,60.74 167.93,60.63 167.93,59.22 167.67,58.96 166.53,58.96 166.28,58.71 166.28,51.73 166.02,51.47 164.88,51.47 164.63,51.73 164.63,63.62 164.26,63.98 163.57,63.98 163.28,64.27 163.28,64.99 163.32,65.03 163.84,65.03
GND on TOP (solid shape): 166.53,44.36 166.53,42.74 166.49,42.73 166.19,42.38 166.49,42.03 166.53,42.02 166.53,41.18 166.28,40.93 164.37,40.93 164.12,41.18 164.12,44.23 164.5,44.61 166.28,44.61
GND on TOP (solid shape): 46.01,76.24 46.01,74.97 46.64,74.33 47.28,74.33 47.56,74.05 47.56,60.77 47.53,60.74 47.53,54.39 47.15,54.01 47.15,52.87 49.06,50.96 49.06,40.04 49.18,39.91 49.18,37.25 48.93,36.99 48.17,36.99 47.41,37.76 45.75,37.76 45.5,38.01 45.5,52.87 43.98,54.39 43.98,59.85 43.72,60.11 43.72,62.52 41.56,64.68 41.56,66.97 43.98,69.38 43.98,74.2 43.6,74.59 42.96,74.59 42.83,74.71 42.83,76.24 42.86,76.26 45.98,76.26
GND on TOP (solid shape): 50.13,158.43 50.13,157.22 49.19,156.28 48.64,156.28 48.15,155.79 48.15,155.69 48.09,155.63 48.09,154.47 47.02,153.39 45.73,153.39 45.59,153.54 45.59,154.53 45.95,154.89 45.95,155.62 46.1,155.77 46.1,156.11 46.19,156.19 46.24,156.25 46.28,156.33 46.59,156.64 46.6,156.64 46.84,156.94 46.68,157.29 46.68,158.39 46.85,158.56 50,158.56
GND on TOP (solid shape): 131.73,71.79 131.73,65.7 132.24,65.19 132.24,64.43 132.11,64.3 132.11,62.9 132.24,62.77 132.24,59.47 132.37,59.35 132.37,58.71 132.24,58.58 132.24,56.93 132.37,56.81 132.37,56.17 132.24,56.04 132.24,54.52 132.37,54.39 132.37,53.63 132.11,53.38 132.11,50.73 132.3,50.54 136.28,50.54 136.43,50.39 136.43,29.79 136.39,29.75 135.93,29.75 133.94,31.73 133.94,44.22 132.02,46.15 132.02,47.94 132.06,47.98 133.01,47.98 133.17,48.15 133.17,48.98 133.02,49.13 131.4,49.13 130.45,50.07 128.69,50.07 128.43,50.33 128.43,66.84 126.27,69 126.27,71.79 126.53,72.05 131.48,72.05
GND on TOP (solid shape): 48.69,144.64 48.99,144.37 49.4,144.38 49.43,144.39 49.49,144.33 49.49,144.03 49.34,143.88 49.32,143.88 49.19,143.9 49.06,143.88 49.05,143.88 48.98,143.88 48.89,143.78 48.89,143.75 48.88,143.73 48.83,143.54 48.89,143.35 48.89,143.14 48.69,142.94 48.69,142.67 48.81,142.5 48.98,142.4 49.02,142.38 49.02,142.09 49.52,141.58 49.52,136.53 49.4,136.41 48.96,136.41 48.52,136.84 48.52,138.69 48.06,139.15 48.06,144.43 48.27,144.64
GND on TOP (solid shape): 157.27,175.35 157.46,175.27 157.65,175.25 158.15,175.25 158.32,175.17 158.4,175 158.4,174.34 158.4,168.62 158.38,168.58 158.34,168.57 155.99,168.57 155.74,168.82 155.74,170.72 151.62,174.84 95.33,174.84 94.78,174.28 93.13,174.28 89.82,170.98 85.76,170.98 85.51,171.23 85.51,174.28 85.52,174.3 84.91,174.3 84.88,174.3 84.86,174.32 84.74,174.49 84.59,174.62 84.56,174.74 84.65,174.81 91.41,174.81 91.76,174.93 91.95,175.26 92,175.35 156.74,175.35
GND on TOP (solid shape): 150.01,50.54 150.01,29.53 149.44,29.53 149.19,29.27 147.17,29.27 146.95,29.49 146.95,33.91 147.02,34.01 147.13,33.98 147.25,33.86 147.24,33.84 147.85,33.54 147.55,34.15 147.52,34.14 147.02,34.65 146.95,34.65 146.95,44.06 146.99,44.14 147.08,44.16 147.51,44.53 147.05,44.85 147.04,44.85 146.95,44.85 146.95,49.99 147.56,50.6 149.96,50.6
GND on TOP (solid shape): 150.01,90.34 150.01,69.06 149.92,68.96 147.09,68.96 146.93,69.12 146.93,69.97 148.11,71.15 148.11,71.55 147.91,72.2 147.72,71.55 147.72,71.31 147.11,70.7 147,70.68 146.93,70.78 146.93,74.79 147,74.88 147.11,74.86 147.59,74.38 147.59,74.35 148.19,74.05 147.89,74.66 147.87,74.66 147.07,75.45 146.93,75.45 146.93,90.41 147.02,90.5 149.85,90.5
GND on TOP (solid shape): 168.49,75.47 168.57,75.43 168.58,75.34 168.57,75.15 168.66,74.97 168.68,74.9 168.66,74.84 168.94,74.2 169.23,74.84 169.21,74.9 169.23,74.97 169.32,75.15 169.3,75.34 169.32,75.43 169.4,75.47 173.14,75.47 173.39,75.22 173.39,74.84 173.14,74.59 170.34,74.59 169.2,73.44 169.2,72.55 169.33,72.43 169.71,72.43 169.8,72.52 169.86,72.56 169.92,72.62 169.94,72.66 170.21,72.93 172.63,72.93 172.88,72.68 172.88,72.17 172.75,72.05 170.21,72.05 170.09,71.92 167.55,71.92 167.29,72.17 167.29,75.22 167.55,75.47
GND on TOP (solid shape): 48.29,90.21 48.29,89.88 48.3,89.45 48.68,89.24 48.88,89.24 48.96,89.32 49.03,89.32 49.04,89.31 49.47,89.29 49.7,89.65 49.71,89.7 49.82,89.7 50.04,89.47 50.04,89.44 50.02,89.34 50.03,89.24 50.02,89.15 49.94,89.11 49.44,89.11 49.17,88.85 49.16,88.85 48.95,88.68 48.92,88.41 48.92,88.4 48.92,88.34 48.87,88.34 48.65,88.13 48.59,88.03 48.57,87.92 48.56,87.87 47.58,87.87 47.48,87.97 47.48,88.43 47.41,88.43 47.41,88.74 47.48,88.88 47.51,89.04 47.57,89.08 47.64,89.14 47.7,89.2 47.82,89.38 47.86,89.6 47.86,89.96 47.66,90.16 47.64,90.27 47.73,90.33 48.17,90.33
GND on TOP (solid shape): outline of 107 points within 4.35,66.28 16.3,88.3
GND on TOP (solid shape): outline of 222 points within 118.82,96.05 129.32,112.18
GND on TOP (solid shape): outline of 510 points within 85.51,47.03 93.58,68.11
GND on TOP (solid shape): outline of 1472 points within 0.26,0.26 94.84,178.45
GND on TOP (solid shape): outline of 2246 points within 96.99,13.2 275.3,175.35
GND on BOTTOM (solid shape): 43.6,98.21 43.6,97.19 43.34,96.94 41.82,96.94 41.56,97.19 41.56,98.21 41.82,98.46 43.34,98.46
GND on BOTTOM (solid shape): 44.23,114.21 44.23,110.53 43.98,110.27 42.07,110.27 41.82,110.53 41.82,114.21 42.07,114.46 43.98,114.46
GND on BOTTOM (solid shape): 72.23,162.12 72.23,158.95 71.89,158.61 70.32,158.61 69.31,159.63 69.31,162.08 69.49,162.26 72.08,162.26
GND on BOTTOM (solid shape): 200.82,61.12 200.82,58.33 199.81,57.31 197.14,57.31 196.88,57.57 196.88,59.98 198.28,61.38 200.57,61.38
GND on BOTTOM (solid shape): 210.27,46.21 210.27,45.32 209.99,45.04 208.24,45.04 208.02,45.26 208.02,46.11 208.17,46.26 210.22,46.26
GND on BOTTOM (solid shape): 212.23,39 212.23,37.73 211.97,37.48 209.08,37.48 208.85,37.7 208.85,39 208.97,39.13 212.1,39.13
GND on BOTTOM (solid shape): 220.13,92.75 220.13,91.86 219.87,91.6 217.71,91.6 217.46,91.86 217.46,92.75 217.71,93 219.87,93
GND on BOTTOM (solid shape): 227.24,57.19 227.24,55.54 226.98,55.28 225.59,55.28 225.33,55.54 225.33,57.06 225.59,57.31 227.11,57.31
GND on BOTTOM (solid shape): 239.43,56.81 239.43,54.39 239.18,54.14 236.13,54.14 235.87,54.39 235.87,56.81 236.13,57.06 239.18,57.06
GND on BOTTOM (solid shape): 252,38.52 252,34.33 251.75,34.07 250.99,34.07 250.73,34.33 250.73,38.52 250.99,38.77 251.75,38.77
GND on BOTTOM (solid shape): 257.34,56.68 257.34,54.27 257.08,54.01 254.29,54.01 253.65,54.65 253.65,56.68 253.91,56.93 257.08,56.93
GND on BOTTOM (solid shape): 261.53,97.95 261.53,94.65 261.27,94.4 258.35,94.4 258.1,94.65 258.1,97.95 258.35,98.21 261.27,98.21
GND on BOTTOM (solid shape): 24.55,146.47 24.55,144.94 24.44,144.84 18.93,144.84 18.9,144.87 18.9,145.39 19.34,145.83 19.34,146.21 19.64,146.52 24.49,146.52
GND on BOTTOM (solid shape): 179.23,52.11 179.23,51.19 178.88,50.84 178.88,49.77 178.8,49.69 178.65,49.69 178.6,49.74 178.6,52.11 178.72,52.23 179.1,52.23
GND on BOTTOM (solid shape): 248.7,67.85 248.7,67.22 247.94,66.46 247.94,65.44 247.81,65.31 246.41,65.31 246.16,65.57 246.16,67.22 246.92,67.98 248.57,67.98
GND on BOTTOM (solid shape): 66.45,74.08 66.45,71.54 66.23,71.31 64.65,71.31 64.04,71.92 63.53,71.92 63.28,72.17 63.28,74.08 63.53,74.33 66.2,74.33
GND on BOTTOM (solid shape): 110.23,30.21 110.23,26.78 110.12,26.67 106.86,26.67 105.55,27.98 103.78,27.98 103.51,28.25 103.51,30.48 103.74,30.7 109.74,30.7
GND on BOTTOM (solid shape): 169.96,118.97 169.96,116.62 169.8,116.46 168.8,116.46 168.7,116.37 166.91,116.37 166.79,116.5 166.79,119.02 167.1,119.34 169.59,119.34
GND on BOTTOM (solid shape): 267.88,82.61 267.88,77.63 267.62,77.38 263.18,77.38 262.92,77.63 262.92,82.9 263.7,83.68 266.81,83.68
GND on BOTTOM (solid shape): 59.39,113.31 59.39,112.33 59.27,112.2 56.36,112.2 55.96,111.81 54.99,111.81 54.93,111.86 54.93,113.4 55.11,113.57 59.13,113.57
GND on BOTTOM (solid shape): 67.22,47.92 67.22,47.15 67.85,46.52 67.85,45.25 67.6,44.99 66.2,44.99 65.95,45.25 65.95,46.52 65.57,46.9 65.57,47.92 65.82,48.17 66.96,48.17
GND on BOTTOM (solid shape): 41.69,73.65 41.69,71.84 41.61,71.77 39.43,71.77 39.38,71.82 39.38,72.63 39.41,72.66 40.76,72.66 40.83,72.73 40.83,73.65 40.9,73.72 41.61,73.72
GND on BOTTOM (solid shape): 182.15,71.16 182.15,67.85 181.9,67.6 175.17,67.6 174.91,67.85 174.91,68.62 176.06,69.76 176.06,71.16 176.31,71.41 181.9,71.41
GND on BOTTOM (solid shape): 259.56,101.07 259.56,98.97 259.56,98.78 259.24,98.46 257.78,98.46 257.72,98.52 257.72,99.22 257.4,99.54 255.24,99.54 254.86,99.92 254.86,101 255.11,101.26 259.37,101.26
GND on BOTTOM (solid shape): 267.88,63.16 267.88,60.87 267.62,60.62 264.32,60.62 264.07,60.87 264.07,63.16 264.32,63.41 267.62,63.41
GND on BOTTOM (solid shape): 33.68,73.76 33.68,71.05 33.56,70.94 32.56,70.94 32.39,71.11 32.39,72.18 32.24,72.34 32.24,73.76 32.51,74.03 33.41,74.03
GND on BOTTOM (solid shape): 50.57,78.49 50.57,76.57 50.9,76.24 51.99,76.24 52.02,76.21 52.02,75.3 51.94,75.22 49.95,75.22 49.69,75.47 49.69,77.13 49.95,77.38 49.95,78.4 50.07,78.52 50.54,78.52
GND on BOTTOM (solid shape): 26.13,141.43 26.13,139.56 25.96,139.4 25.24,139.4 25.02,139.18 25.02,136.99 24.87,136.85 23.39,136.85 21.88,138.35 21.75,138.35 21.72,138.39 21.72,141.55 21.75,141.58 25.97,141.58
GND on BOTTOM (solid shape): 128.93,113 128.93,111.28 128.6,110.95 127.94,110.95 127.86,111.03 127.83,111.09 127.65,111.28 127.61,111.28 127.06,111.82 126.4,111.82 126.26,111.96 126.26,112.93 126.5,113.17 128.75,113.17
GND on BOTTOM (solid shape): 187.49,51.34 187.49,48.93 187.74,48.68 190.15,48.68 190.41,48.42 190.41,46.39 190.28,46.26 187.23,46.26 186.34,45.38 184.82,45.38 184.69,45.5 184.69,48.52 185.45,49.28 185.45,51.34 185.71,51.6 187.23,51.6
