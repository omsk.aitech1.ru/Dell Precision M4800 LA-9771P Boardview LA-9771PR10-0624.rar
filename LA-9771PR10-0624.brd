# Allegro board LA-9771PR10-0624.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D56: length 89.3
  TOP w0.102: v1(92.12,43.75) JCPU1.E15
  TOP w0.14: v1(153.83,31.78) 152.06,33.56 JDIMM3.183
  IN3 w0.089: v1(92.12,43.75) 92.61,43.26 92.61,42.69 92.96,42.35 93.36,42.35 93.72,41.98 93.72,41.58 93.97,41.34 94.37,41.34 94.71,40.99 94.71,39.62 95.56,38.77
  IN3 w0.127: 95.56,38.77 97.42,36.91 100.13,36.91 100.97,36.07 108.07,36.07 114.67,29.47 133.97,29.47 136.05,27.39 136.23,27.39 136.62,27.78 136.8,27.78 136.98,27.6 136.98,27.42 136.59,27.03 136.59,26.85 136.77,26.67 136.95,26.67 137.51,27.23 137.69,27.23 137.87,27.05 137.87,26.87 137.31,26.31 137.31,26.13 137.49,25.95 137.67,25.95 138.18,26.47 138.36,26.47 138.54,26.28 138.54,26.11 138.41,25.97 138.41,25.81 138.81,25.41 139.04,25.41 139.31,25.68 139.56,25.68 139.69,25.55 139.69,24.77 139.82,24.64 140.07,24.64 140.2,24.77 140.2,26.13 140.33,26.25 140.58,26.25 140.71,26.13 140.71,24.77 140.83,24.64 142.05,24.64 142.99,25.58 144.4,25.58 147.22,28.4 149.76,28.4 153.14,31.78 v1(153.83,31.78)
  BOTTOM w0.14: JDIMM4.182 151.96,33.86 153.83,31.99 v1(153.83,31.78)
DDR_B_D57: length 90.5
  TOP w0.102: v1(92.12,42.75) JCPU1.D15
  TOP w0.14: v1(155.37,31.78) 154.76,32.4 153.77,32.4 152.62,33.54 152.62,33.73 152.19,34.16 JDIMM3.181
  IN3 w0.089: 94.95,38.77 94.52,39.2 94.52,40.91 94.29,41.15 93.83,41.15 93.82,41.15 93.52,41.45 93.52,41.91 93.28,42.16 92.88,42.16 92.29,42.75 v1(92.12,42.75)
  IN3 w0.127: v1(155.37,31.78) 154.59,31 152.83,31 149.9,28.07 147.36,28.07 145.47,26.17 145.47,25.99 145.87,25.6 145.87,25.42 145.69,25.24 145.51,25.24 145.11,25.63 144.93,25.63 144.53,25.24 144.34,25.24 144.21,25.11 144.21,24.48 144.08,24.36 143.83,24.36 143.7,24.48 143.7,25.11 143.58,25.24 143.13,25.24 142.19,24.3 139.43,24.3 138.91,24.82 138.73,24.82 138.53,24.62 138.35,24.62 138.17,24.8 138.17,24.98 138.37,25.18 138.37,25.36 138.12,25.61 137.94,25.61 137.73,25.41 137.55,25.41 133.83,29.13 114.53,29.13 107.93,35.73 100.83,35.73 99.99,36.58 97.15,36.58 94.95,38.77
  BOTTOM w0.14: v1(155.37,31.78) 155.37,31.79 154.62,32.55 153.73,32.55 152.56,33.72 152.56,34 152.11,34.45 151.21,34.45 JDIMM4.180
DDR_B_D58: length 91.4
  TOP w0.102: v1(92.12,39.75) JCPU1.A15
  TOP w0.14: v1(154.97,28.43) 154.47,27.93 153.35,27.93 152.73,28.55 152.73,30.07 152.24,30.56 JDIMM3.193
  IN3 w0.089: 92.08,38.77 92.08,39.7 v1(92.12,39.75)
  IN3 w0.127: v1(154.97,28.43) 154.01,27.47 153.83,27.47 153.53,27.78 153.35,27.78 153.17,27.6 153.17,27.42 153.48,27.11 153.48,26.93 153.3,26.75 153.12,26.75 152.81,27.06 152.63,27.06 152.45,26.88 152.45,26.7 152.57,26.58 152.57,26.4 152.39,26.22 152.21,26.22 152.09,26.35 151.91,26.35 147.78,22.22 137.8,22.22 132.97,27.05 113.66,27.05 112.48,28.23 96.6,28.23 94.44,30.38 94.44,35.47 92.08,37.83 92.08,38.77
  BOTTOM w0.14: v1(154.97,28.43) 154.49,27.95 152.82,27.95 152.51,28.26 152.51,30 152.25,30.26 JDIMM4.194
DDR_B_D59: length 89.3
  TOP w0.102: v1(92.12,40.75) JCPU1.B15
  TOP w0.14: JDIMM3.191 152.49,31.16 153.49,30.16 153.49,28.47 v1(153.45,28.43)
  IN3 w0.089: v1(92.12,40.75) 92.12,40.44 92.52,40.04 92.52,39.41 92.41,39.3 92.41,38.77
  IN3 w0.127: v1(153.45,28.43) 147.57,22.55 137.94,22.55 133.11,27.38 113.8,27.38 112.62,28.56 111.7,28.56 111.58,28.69 111.58,29.45 111.45,29.58 111.2,29.58 111.07,29.45 111.07,28.69 110.94,28.56 110.69,28.56 110.56,28.69 110.56,29.8 110.43,29.93 110.18,29.93 110.05,29.8 110.05,28.69 109.93,28.56 96.74,28.56 94.78,30.52 94.78,35.65 92.41,38.01 92.41,38.77
  BOTTOM w0.14: JDIMM4.192 152.34,30.86 153.65,29.56 153.65,28.63 v1(153.45,28.43)
DDR_B_D60: length 89
  TOP w0.102: JCPU1.E14 93.59,44.28 v1(93.12,43.75)
  TOP w0.14: JDIMM3.180 161.32,34.46 v1(162.35,33.42)
  IN3 w0.089: v1(93.12,43.75) 93.66,43.21 94.19,43.21 94.67,42.73 94.67,42.67 95.07,42.27 95.13,42.27 95.71,41.69 95.71,39.63 96.57,38.77
  IN3 w0.127: v1(162.35,33.42) 161.81,33.97 159.08,33.97 158.95,33.84 158.95,32.99 158.82,32.87 158.48,32.87 158.35,32.99 158.35,33.26 158.23,33.39 155.25,33.39 154.69,32.83 153.01,32.83 149.88,29.69 149.14,29.69 148.52,29.07 146.86,29.07 144.71,26.92 138.94,26.92 137.42,28.45 135.94,28.45 134.25,30.14 114.95,30.14 108.35,36.74 101.25,36.74 100.4,37.58 97.76,37.58 96.57,38.77
  BOTTOM w0.14: JDIMM4.181 161.62,34.16 v1(162.35,33.42)
DDR_B_D61: length 86.5
  TOP w0.102: v1(93.12,42.75) JCPU1.D14
  TOP w0.14: v1(160.83,33.45) 160.83,33.6 160.57,33.86 JDIMM3.182
  IN3 w0.089: v1(93.12,42.75) 93.23,42.75 93.83,42.15 94.29,42.15 94.52,41.91 94.52,41.45 94.83,41.15 95.29,41.15 95.52,40.91 95.52,39.32 96.07,38.77
  IN3 w0.127: 96.07,38.77 97.6,37.25 100.27,37.25 101.11,36.4 108.21,36.4 114.81,29.8 134.11,29.8 135.8,28.11 137.28,28.11 138.8,26.59 144.85,26.59 146.99,28.74 148.72,28.74 149.3,29.31 149.97,29.31 153.15,32.49 155.13,32.49 155.26,32.62 155.26,32.9 155.39,33.03 155.64,33.03 155.77,32.9 155.77,32.62 155.89,32.49 156.15,32.49 156.27,32.62 156.27,32.9 156.4,33.03 156.66,33.03 156.78,32.9 156.78,32.46 156.91,32.33 157.16,32.33 157.29,32.46 157.29,32.9 157.42,33.03 157.67,33.03 157.8,32.9 157.8,32.31 157.93,32.18 159.28,32.18 159.41,32.31 159.41,33.32 159.53,33.45 v1(160.83,33.45)
  BOTTOM w0.14: v1(160.83,33.45) 160.9,33.53 160.9,33.74 160.78,33.87 160.55,33.87 160.24,33.56 JDIMM4.183
DDR_B_D62: length 88.5
  TOP w0.102: v1(93.12,39.75) JCPU1.A14
  TOP w0.14: JDIMM3.194 158.32,30.26 157.99,29.93 157.99,28.73 158.02,28.7 v1(158.02,28.44)
  IN3 w0.089: 93.12,38.77 v1(93.12,39.75)
  IN3 w0.127: 93.12,38.77 93.12,38.65 96.27,35.5 99.54,35.5 100.38,34.65 107.48,34.65 114.08,28.05 133.39,28.05 138.21,23.22 147.29,23.22 149.98,25.92 149.98,26.49 152.68,29.19 156.48,29.19 156.61,29.31 156.61,29.68 156.74,29.8 156.99,29.8 157.12,29.68 157.12,29.31 157.25,29.19 157.5,29.19 157.63,29.31 157.63,29.68 157.75,29.8 158.01,29.8 158.14,29.68 158.14,29.31 158.26,29.19 159.83,29.19 159.95,29.06 159.95,28.57 159.83,28.44 v1(158.02,28.44)
  BOTTOM w0.14: v1(158.02,28.44) 158.02,30.11 158.47,30.56 JDIMM4.193
DDR_B_D63: length 89.9
  TOP w0.102: v1(93.12,40.75) JCPU1.B14
  TOP w0.14: JDIMM3.192 157.91,30.86 157.51,30.47 157.51,29.99 156.8,29.28 156.8,28.74 v1(156.5,28.43)
  IN3 w0.089: v1(93.12,40.75) 93.12,40.6 92.75,40.22 92.75,38.77
  IN3 w0.127: 92.75,38.77 92.75,38.51 96.12,35.14 99.42,35.14 100.24,34.32 105.1,34.32 105.22,34.19 105.22,33.2 105.35,33.07 105.6,33.07 105.73,33.2 105.73,34.19 105.86,34.32 106.11,34.32 106.24,34.19 106.24,33.2 106.37,33.07 106.62,33.07 106.75,33.2 106.75,34.19 106.87,34.32 107.34,34.32 113.94,27.72 133.25,27.72 138.07,22.89 147.43,22.89 150.32,25.78 150.32,26.35 152.82,28.85 156.08,28.85 v1(156.5,28.43)
  BOTTOM w0.14: JDIMM4.191 158.04,31.16 157.44,30.55 157.44,29.88 156.67,29.11 156.67,28.63 156.5,28.46 v1(156.5,28.43)
DDR_B_DQS0: length 91.8
  TOP w0.102: JCPU1.AP17 v1(91.12,73.75)
  TOP w0.14: JDIMM3.12 158.01,87.26 157.48,87.79 157.13,87.79 156.75,87.41 155.6,87.41 155.28,87.73 155.28,88.36 v1(155.2,88.44)
  IN3 w0.089: v1(91.12,73.75) 91.07,73.7 90.65,73.7 90.57,73.77 90.57,74.07 90.67,74.17 92.44,74.17 92.73,74.46 92.73,75.94 93.61,76.82 93.61,76.85 93.82,77.06 93.82,77.06 93.86,77.09 93.89,77.09 93.9,77.1
  IN3 w0.127: v1(155.2,88.44) 155.37,88.44 155.63,88.71 155.63,88.92 155.54,89.02 154.38,89.02 154.1,88.73 152.87,88.73 150.05,91.55 144.61,91.55 142.67,93.5 140.71,93.5 136.89,89.67 134.3,89.67 131.67,87.04 100.24,87.04 97.24,84.04 97.24,80.44 93.9,77.1
  BOTTOM w0.14: v1(155.2,88.44) 155.37,88.44 155.61,88.68 155.61,88.84 155.53,88.91 153.94,88.91 152.63,87.6 152.42,87.6 152.33,87.51 152.33,87.36 152.23,87.26 JDIMM4.12
DDR_B_DQS1: length 78.8
  TOP w0.102: JCPU1.AP12 v1(96.12,73.75)
  TOP w0.14: JDIMM3.29 152.7,82.16 153.23,82.69 153.52,82.69 154.06,82.15 155.08,82.15 155.48,82.55 155.48,83.05 v1(155.62,83.19)
  IN3 w0.089: 100.99,77.25 100.9,77.16 100.9,77.14 100.44,76.68 100.42,76.68 100.1,76.36 99.86,76.36 99.53,76.03 99.53,75.5 99.35,75.32 98.83,75.32 98.55,75.03 98.55,74.62 98.28,74.34 96.76,74.34 96.44,74.02 96.44,73.99 96.2,73.75 v1(96.12,73.75)
  IN3 w0.127: v1(155.62,83.19) 155.62,83.19 155.44,83.37 155.44,83.6 155.2,83.84 152.97,83.84 150.53,86.28 147.08,86.28 146.78,86.58 138.58,86.58 136.41,84.41 134.11,84.41 130.35,80.65 114.54,80.65 113.35,79.46 107.23,79.46 105.4,77.64 102.87,77.64 102.73,77.5 101.24,77.5 100.99,77.25
  BOTTOM w0.14: v1(155.62,83.19) 155.39,83.19 155.28,83.3 155.28,83.45 155.45,83.63 157.2,83.63 157.63,83.2 157.63,83.06 158.26,82.42 158.26,82.27 158.37,82.16 JDIMM4.29
DDR_B_DQS2: length 69.7
  TOP w0.102: JCPU1.AP6 v1(102.12,73.75)
  TOP w0.14: JDIMM3.47 152.28,76.76 152.3,76.78 152.81,76.78 153.34,77.31 153.87,77.31 154.27,76.91 154.82,76.91 155.32,77.41 v1(155.32,78.06)
  IN3 w0.089: v1(102.12,73.75) 102.22,73.75 102.42,73.95 102.42,74.03 102.74,74.34 106.24,74.34 106.25,74.34 106.52,74.62 106.52,74.95 106.9,75.32 108.66,75.32 108.66,75.33 108.68,75.33
  IN3 w0.127: 108.68,75.33 115.16,75.33 116.96,77.13 132.51,77.13 135.64,80.26 137.5,80.26 138.1,80.86 147.35,80.86 147.49,80.72 150.22,80.72 152.24,78.7 154.85,78.7 155.13,78.42 155.13,78.26 v1(155.32,78.06)
  BOTTOM w0.14: JDIMM4.47 158.6,76.76 156.77,78.6 155.04,78.6 154.88,78.44 154.88,78.34 155.16,78.06 v1(155.32,78.06)
DDR_B_DQS3: length 67.1
  TOP w0.102: v1(105.12,69.75) JCPU1.AK3
  TOP w0.14: JDIMM3.64 155.7,71.66 155.12,72.24 155.12,72.7 v1(155,72.82)
  IN3 w0.089: v1(105.12,69.75) 105.12,69.34 105.22,69.25 105.34,69.25 105.56,69.46 105.56,69.98 105.92,70.34 107.25,70.34 107.59,70.69 107.59,70.79 108.6,71.8 108.66,71.8 108.66,71.8 108.68,71.8
  IN3 w0.127: v1(155,72.82) 155.24,72.82 155.36,72.7 155.36,72.55 155.19,72.38 154.1,72.38 153.34,73.14 152.62,73.14 150.01,75.75 138.91,75.75 137.82,74.67 135.03,74.67 133.97,73.6 118.43,73.6 116.62,71.8 108.68,71.8
  BOTTOM w0.14: v1(155,72.82) 155.24,72.82 155.35,72.94 155.35,73.16 155.26,73.26 154.06,73.26 152.8,72 152.39,72 152.05,71.66 JDIMM4.64
DDR_B_DQS4: length 73.5
  TOP w0.102: v1(105.12,50.75) JCPU1.M3
  TOP w0.14: v1(155.98,46.18) 155.84,46.03 155.84,45.77 155.44,45.37 154.18,45.37 152.19,47.36 JDIMM3.137
  IN3 w0.089: v1(105.12,50.75) 105.12,50.74 104.87,50.49 104.77,50.49 104.5,50.23 104.5,48.51 104.85,48.17 107.35,48.17 108.62,46.9
  IN3 w0.127: v1(155.98,46.18) 155.99,46.17 155.79,45.97 155.79,45.78 155.49,45.49 152.52,45.49 151.35,44.32 151,44.32 150.78,44.54 150.6,44.54 150.33,44.27 150.33,44.09 150.55,43.87 150.55,43.52 150.22,43.19 149.18,43.19 148.93,43.44 148.93,43.76 148.8,43.89 148.42,43.89 148.29,43.76 148.29,43.44 148.04,43.19 146.74,43.19 144.86,41.3 116.39,41.3 110.89,46.81 108.71,46.81 108.62,46.9
  BOTTOM w0.14: v1(155.98,46.18) 155.88,46.07 155.79,46.07 155.65,46.21 155.65,46.37 155.48,46.53 155.48,46.84 155.59,46.94 156.47,46.94 156.76,46.65 157.42,46.65 158.24,47.46 158.34,47.46 158.44,47.36 JDIMM4.137
DDR_B_DQS5: length 78.5
  TOP w0.089: v1(99.12,46.75) 99.49,46.75 99.72,46.98 99.72,47.15 JCPU1.H8
  TOP w0.14: v1(155.28,40.8) 155.38,40.7 155.38,40.37 155.65,40.09 156.99,40.09 158.18,41.28 158.18,42.19 158.25,42.26 JDIMM3.154
  IN3 w0.089: v1(99.12,46.75) 99.03,46.84 98.73,46.84 98.66,46.77 98.66,46.54 98.87,46.33 99.39,46.33 99.67,46.04 99.67,45.48 99.85,45.3 101.43,45.3 101.71,45.02 101.71,44.46 101.84,44.33 102.37,44.33 102.73,43.98 102.73,43.6 102.95,43.37 108.58,43.37 108.59,43.39 108.67,43.39 108.67,43.39 108.69,43.39
  IN3 w0.127: v1(155.28,40.8) 155.55,40.8 155.62,40.72 155.62,40.46 155.52,40.36 152.38,40.36 150.31,38.29 146.77,38.29 144.45,35.97 139.16,35.97 137.78,37.35 115.67,37.35 109.63,43.39 108.69,43.39
  BOTTOM w0.14: v1(155.28,40.8) 155.35,40.73 155.46,40.73 155.62,40.89 155.62,40.98 155.72,41.08 155.72,41.17 155.66,41.23 152.97,41.23 152.69,41.51 152.36,41.84 152.36,42.15 152.24,42.26 JDIMM4.154
DDR_B_DQS6: length 83
  TOP w0.102: v1(98.12,41.75) JCPU1.C9
  TOP w0.14: v1(156.12,35.56) 156.12,35.02 155.88,34.79 154.35,34.79 152.56,36.58 152.56,36.92 152.32,37.16 JDIMM3.171
  IN3 w0.089: v1(98.12,41.75) 98.19,41.68 98.52,41.68 98.63,41.79 98.63,42.01 98.47,42.17 97.99,42.17 97.72,41.9 97.72,41.53 97.93,41.32 98.39,41.32 98.73,40.97 98.73,39.54 98.9,39.37 101.54,39.37 101.82,39.09 101.84,39.09 101.86,39.08
  IN3 w0.127: v1(156.12,35.56) 156.01,35.56 155.76,35.82 155.76,35.96 155.52,36.21 153.38,36.21 149.65,32.48 147.25,32.48 144.6,29.84 139.75,29.84 137.37,32.22 134.08,32.22 133.14,33.17 114.86,33.17 109.04,39 101.94,39 101.86,39.08
  BOTTOM w0.14: JDIMM4.171 158.35,37.16 158.28,37.23 158.28,37.42 158.2,37.5 158.11,37.5 157.81,37.2 157.81,36.42 157.39,35.99 156.64,35.99 156.24,36.38 155.77,36.38 155.69,36.3 155.69,35.91 155.83,35.76 155.83,35.69 155.96,35.56 v1(156.12,35.56)
DDR_B_DQS7: length 94.3
  TOP w0.102: v1(92.12,41.75) JCPU1.C15
  TOP w0.14: v1(156.24,30.25) 156.02,30.25 155.9,30.37 155.9,30.8 156.01,30.92 156.66,30.92 157,31.26 157,32.61 157.16,32.77 157.7,32.77 158.08,32.39 158.19,32.39 158.28,32.31 158.28,32.18 158.4,32.06 JDIMM3.188
  IN3 w0.089: 93.84,38.72 93.83,38.73 93.83,38.74 93.56,39.01 93.56,40.88 93.31,41.13 92.73,41.13 92.43,41.43 92.43,41.56 92.24,41.75 v1(92.12,41.75)
  IN3 w0.127: v1(156.24,30.25) 156.05,30.06 156.05,29.81 155.86,29.62 152.5,29.62 149.55,26.67 149.55,26.15 148.67,25.27 148.31,25.27 147.17,26.42 146.99,26.42 146.72,26.15 146.72,25.97 147.87,24.82 147.87,24.47 147.06,23.66 146.47,23.66 146.22,23.91 146.22,24.22 146.09,24.34 145.71,24.34 145.58,24.22 145.58,23.91 145.33,23.66 138.39,23.66 133.56,28.48 114.26,28.48 107.66,35.08 100.56,35.08 99.72,35.93 96.63,35.93 93.94,38.62 93.84,38.72
  BOTTOM w0.14: v1(156.24,30.25) 156.13,30.14 156.13,29.81 155.84,29.53 154.44,29.53 152.6,31.37 152.6,31.81 152.35,32.06 JDIMM4.188
DDR_B_DQS#0: length 91.9
  TOP w0.102: JCPU1.AP18 v1(90.12,73.75)
  TOP w0.14: JDIMM3.10 158.38,87.86 158.29,87.77 158.29,87.58 158.23,87.52 158.12,87.52 157.59,88.04 157.02,88.04 156.64,87.67 155.8,87.67 155.57,87.89 155.57,88.24 155.77,88.44 v1(155.96,88.44)
  IN3 w0.089: 93.74,77.25 93.42,76.93 93.42,76.9 92.54,76.02 92.54,74.53 92.36,74.36 90.61,74.36 90.38,74.13 90.38,73.85 90.28,73.75 v1(90.12,73.75)
  IN3 w0.127: v1(155.96,88.44) 155.85,88.55 155.85,89.01 155.63,89.23 154.29,89.23 154.01,88.95 152.95,88.95 150.14,91.77 144.7,91.77 142.76,93.71 140.62,93.71 136.8,89.89 134.21,89.89 131.58,87.25 100.15,87.25 97.02,84.13 97.02,80.53 93.74,77.25
  BOTTOM w0.14: JDIMM4.10 152.53,87.86 153.84,89.17 155.64,89.17 155.86,88.95 155.86,88.54 v1(155.96,88.44)
DDR_B_DQS#1: length 78.7
  TOP w0.102: JCPU1.AP11 v1(97.12,73.75)
  TOP w0.14: v1(154.86,83.19) 155.08,83.19 155.22,83.05 155.22,82.66 154.97,82.41 154.17,82.41 153.62,82.96 153.13,82.96 152.6,82.42 152.43,82.42 152.09,82.76 JDIMM3.27
  IN3 w0.089: 101.3,77.25 101.14,77.09 101.11,77.09 101.07,77.05 101.06,77.05 100.51,76.5 100.5,76.5 100.17,76.17 99.94,76.17 99.72,75.95 99.72,75.42 99.43,75.13 98.91,75.13 98.74,74.96 98.74,74.54 98.35,74.15 96.84,74.15 96.6,73.91 96.6,73.65 96.69,73.56 96.93,73.56 v1(97.12,73.75)
  IN3 w0.127: 101.3,77.25 101.33,77.28 102.82,77.28 102.96,77.42 105.49,77.42 107.31,79.25 113.44,79.25 114.63,80.43 130.44,80.43 134.2,84.2 136.5,84.2 138.66,86.37 146.69,86.37 146.99,86.07 150.44,86.07 152.88,83.63 155.11,83.63 155.23,83.51 155.23,83.37 155.04,83.19 v1(154.86,83.19)
  BOTTOM w0.14: v1(154.86,83.19) 155.02,83.34 155.02,83.56 155.35,83.89 157.3,83.89 157.89,83.3 157.89,83.16 158.29,82.76 JDIMM4.27
DDR_B_DQS#2: length 69.7
  TOP w0.102: JCPU1.AP5 v1(103.12,73.75)
  TOP w0.14: v1(154.56,78.06) 154.72,78.06 155.06,77.72 155.06,77.52 154.71,77.17 154.37,77.17 153.97,77.57 153.23,77.57 152.7,77.04 152.5,77.04 152.18,77.36 JDIMM3.45
  IN3 w0.089: v1(103.12,73.75) 102.99,73.62 102.71,73.62 102.6,73.73 102.6,73.93 102.82,74.15 106.32,74.15 106.71,74.55 106.71,74.87 106.97,75.13 108.58,75.13 108.6,75.11 108.62,75.11
  IN3 w0.127: v1(154.56,78.06) 154.67,78.06 154.89,78.28 154.89,78.36 154.76,78.48 152.15,78.48 150.13,80.5 147.4,80.5 147.26,80.65 138.19,80.65 137.59,80.05 135.73,80.05 132.6,76.91 117.05,76.91 115.25,75.11 108.62,75.11
  BOTTOM w0.14: v1(154.56,78.06) 154.62,78.13 154.62,78.55 154.93,78.86 156.87,78.86 158.37,77.36 JDIMM4.45
DDR_B_DQS#3: length 67.1
  TOP w0.102: v1(105.12,68.75) JCPU1.AJ3
  TOP w0.14: v1(155.76,72.82) 155.57,72.82 155.38,72.63 155.38,72.35 155.81,71.92 157.97,71.92 158.03,71.98 158.03,72.2 158.09,72.26 JDIMM3.62
  IN3 w0.089: 108.68,71.59 108.66,71.59 107.78,70.71 107.78,70.62 107.31,70.15 106,70.15 105.75,69.9 105.75,69.38 105.42,69.06 105.36,69.06 105.12,68.83 v1(105.12,68.75)
  IN3 w0.127: 108.68,71.59 116.71,71.59 118.52,73.39 134.06,73.39 135.12,74.45 137.91,74.45 139,75.54 149.92,75.54 152.53,72.92 153.25,72.92 154.01,72.16 155.28,72.16 155.58,72.46 155.58,72.64 v1(155.76,72.82)
  BOTTOM w0.14: JDIMM4.62 152.7,72.26 153.95,73.52 155.37,73.52 155.61,73.27 155.61,72.97 v1(155.76,72.82)
DDR_B_DQS#4: length 73.4
  TOP w0.102: v1(105.12,49.75) 105.12,50.02 104.86,50.28 JCPU1.L3
  TOP w0.14: JDIMM3.135 152.03,47.96 152.86,47.13 152.86,47.06 154.2,45.72 154.29,45.63 155.33,45.63 155.58,45.88 155.58,46 155.4,46.18 v1(155.22,46.18)
  IN3 w0.089: 108.77,47.05 108.76,47.06 108.74,47.06 108.7,47.1 108.69,47.1 107.43,48.36 104.93,48.36 104.69,48.59 104.69,50.15 104.85,50.3 105.19,50.3 105.32,50.18 105.32,49.94 v1(105.12,49.75)
  IN3 w0.127: 108.77,47.05 108.8,47.02 110.98,47.02 116.48,41.52 144.77,41.52 146.65,43.4 147.95,43.4 148.08,43.53 148.08,43.85 148.33,44.11 148.89,44.11 149.14,43.85 149.14,43.53 149.27,43.4 150.13,43.4 150.33,43.61 150.33,43.79 150.12,44 150.12,44.36 150.51,44.75 150.87,44.75 151.09,44.54 151.26,44.54 152.43,45.71 155.41,45.71 155.57,45.87 155.57,46.07 155.47,46.18 v1(155.22,46.18)
  BOTTOM w0.14: JDIMM4.135 158.37,47.96 157.32,46.9 156.87,46.9 156.57,47.2 155.48,47.2 155.22,46.94 v1(155.22,46.18)
DDR_B_DQS#5: length 78.6
  TOP w0.102: v1(98.12,46.75) JCPU1.H9
  TOP w0.14: v1(156.04,40.8) 155.77,40.8 155.7,40.73 155.7,40.63 155.63,40.56 155.63,40.47 155.76,40.35 156.88,40.35 157.92,41.39 157.92,42.29 158.16,42.53 158.23,42.53 158.34,42.64 158.34,42.8 158.4,42.86 JDIMM3.152
  IN3 w0.089: 108.62,43.18 108.61,43.18 108.59,43.19 102.88,43.19 102.55,43.52 102.55,43.9 102.3,44.16 101.76,44.16 101.53,44.39 101.53,44.95 101.36,45.12 99.78,45.12 99.5,45.41 99.5,45.97 99.33,46.14 98.79,46.14 98.47,46.46 98.47,46.53 98.26,46.75 v1(98.12,46.75)
  IN3 w0.127: 108.62,43.18 109.54,43.18 115.58,37.14 137.69,37.14 139.07,35.76 144.54,35.76 146.86,38.07 150.4,38.07 152.47,40.14 155.61,40.14 155.84,40.37 155.84,40.61 156.02,40.8 v1(156.04,40.8)
  BOTTOM w0.14: v1(156.04,40.8) 155.98,40.86 155.98,41.27 155.77,41.49 153.08,41.49 152.62,41.95 152.62,42.25 152.01,42.86 JDIMM4.152
DDR_B_DQS#6: length 83
  TOP w0.102: v1(99.12,41.75) JCPU1.C8
  TOP w0.14: JDIMM3.169 152.21,37.76 152.27,37.7 152.27,37.49 152.34,37.42 152.43,37.42 152.82,37.03 152.82,36.69 154.45,35.05 155.78,35.05 155.86,35.13 155.86,35.22 155.52,35.56 v1(155.43,35.56)
  IN3 w0.089: v1(99.12,41.75) 99.1,41.75 98.83,42.02 98.83,42.09 98.55,42.36 97.91,42.36 97.53,41.98 97.53,41.45 97.85,41.13 98.31,41.13 98.54,40.9 98.54,39.46 98.82,39.18 101.46,39.18 101.74,38.9 101.74,38.89 101.75,38.88
  IN3 w0.127: v1(155.43,35.56) 155.55,35.68 155.55,35.87 155.43,35.99 153.47,35.99 149.74,32.26 147.34,32.26 144.69,29.62 139.66,29.62 137.28,32.01 133.99,32.01 133.05,32.95 114.77,32.95 108.95,38.78 101.85,38.78 101.75,38.88
  BOTTOM w0.14: JDIMM4.169 158,37.76 157.55,37.31 157.55,36.52 157.28,36.25 156.74,36.25 156.35,36.64 155.66,36.64 155.43,36.41 v1(155.43,35.56)
DDR_B_DQS#7: length 94.3
  TOP w0.102: v1(93.12,41.75) JCPU1.C14
  TOP w0.14: JDIMM3.186 158.39,32.66 158.38,32.65 158.19,32.65 157.81,33.03 157.06,33.03 156.74,32.72 156.74,31.34 156.58,31.18 155.9,31.18 155.64,30.91 155.64,30.41 v1(155.48,30.25)
  IN3 w0.089: 93.95,38.91 93.94,38.93 93.91,38.93 93.75,39.09 93.75,40.96 93.38,41.32 92.81,41.32 92.62,41.51 92.62,41.82 92.67,41.87 93,41.87 v1(93.12,41.75)
  IN3 w0.127: v1(155.48,30.25) 155.75,30.25 155.83,30.17 155.83,29.9 155.77,29.83 152.41,29.83 149.34,26.76 149.34,26.24 148.58,25.49 148.4,25.49 147.26,26.63 146.9,26.63 146.5,26.24 146.5,25.88 147.65,24.73 147.65,24.55 146.97,23.87 146.56,23.87 146.43,24 146.43,24.31 146.18,24.56 145.62,24.56 145.37,24.31 145.37,24 145.24,23.87 138.48,23.87 133.65,28.7 114.35,28.7 107.75,35.3 100.65,35.3 99.81,36.14 96.72,36.14 93.95,38.91
  BOTTOM w0.14: v1(155.48,30.25) 155.64,30.25 155.87,30.02 155.87,29.92 155.73,29.79 154.55,29.79 152.86,31.47 152.86,31.92 152.37,32.41 152.37,32.59 152.3,32.66 JDIMM4.186
DDR_B_MA0: length 82.1
  TOP w0.102: v1(100.12,53.75) 100.04,53.67 99.64,53.67 99.51,53.8 99.51,54.2 JCPU1.R8 ; JDIMM3.98 158.23,59.06 158.05,58.89 154.91,58.89 154.79,59.01 v1(154.79,60.44)
  IN3 w0.089: v1(100.12,53.75) 100.12,53.68 99.99,53.55 99.74,53.55 99.61,53.68 99.61,56.25 99.74,56.37 100.48,56.37 100.61,56.5 100.61,57.02 100.73,57.15 102.45,57.15 102.67,57.38 102.67,57.97 102.9,58.2 103.34,58.2 103.74,58.61 103.74,59.93 104.35,60.54 108.21,60.54 109.64,59.12 109.89,59.12
  IN3 w0.178: 109.89,59.12 129.78,59.12 129.96,59.29 129.96,59.87 130.14,60.04 130.49,60.04 130.67,59.87 130.67,59.29 130.85,59.12 131.2,59.12 131.38,59.29 131.38,59.87 131.56,60.04 131.91,60.04 132.09,59.87 132.09,59.35 132.22,59.22 132.65,59.22 132.77,59.35 132.77,59.92 132.9,60.04 133.26,60.04 133.38,59.92 133.38,59.75 133.51,59.62 136.52,59.62 136.7,59.8 136.7,59.92 136.83,60.04 137.28,60.04 137.41,59.92 137.41,59.75 137.54,59.62 138,59.62 138.12,59.75 138.12,59.92 138.25,60.04 138.71,60.04 138.83,59.92 138.83,59.8 139.01,59.62 144.21,59.62 145.25,60.66 150.93,60.66 151.63,59.95 154.96,59.95 155.09,60.08 155.09,60.31 154.96,60.44 v1(154.79,60.44)
  BOTTOM w0.102: v1(154.79,60.44) 155.03,60.44 155.15,60.56 155.15,60.74 155.03,60.87 153.09,60.87 152.74,60.52 152.74,59.29 152.52,59.06 JDIMM4.98
DDR_B_MA1: length 81.1
  TOP w0.102: JDIMM3.97 152.56,59.36 152.66,59.26 152.66,58.99 152.76,58.89 152.96,58.89 153.06,58.99 153.06,59.26 153.16,59.36 153.37,59.36 153.47,59.26 153.47,58.92 153.59,58.8 153.76,58.8 153.88,58.92 153.88,59.26 153.98,59.36 154.17,59.36 154.3,59.49 154.3,59.89 154.17,60.02 153.39,60.02 153.26,60.15 v1(153.26,60.44) ; JCPU1.Y5 v1(103.12,58.75)
  IN3 w0.089: v1(103.12,58.75) 103.45,58.75 103.54,58.84 103.54,60 104.26,60.72 108.35,60.72 109.45,59.61 109.89,59.61
  IN3 w0.178: 109.89,59.61 118.89,59.61 119.06,59.79 119.06,60.6 119.24,60.78 119.6,60.78 119.77,60.6 119.77,59.79 119.95,59.61 120.31,59.61 120.49,59.79 120.49,60.6 120.66,60.78 121.02,60.78 121.2,60.6 121.2,59.79 121.37,59.61 121.73,59.61 121.91,59.79 121.91,60.6 122.09,60.78 122.44,60.78 122.62,60.6 122.62,59.79 122.8,59.61 123.15,59.61 123.33,59.79 123.33,60.6 123.51,60.78 123.86,60.78 124.04,60.6 124.04,59.79 124.22,59.61 124.58,59.61 124.75,59.79 124.75,60.6 124.93,60.78 125.29,60.78 125.46,60.6 125.46,59.79 125.64,59.61 126,59.61 126.18,59.79 126.18,60.6 126.35,60.78 126.71,60.78 126.89,60.6 126.89,59.79 127.06,59.61 127.42,59.61 127.6,59.79 127.6,60.6 127.78,60.78 128.13,60.78 128.31,60.6 128.31,59.79 128.49,59.61 129.13,59.61 129.26,59.74 129.26,60.42 129.38,60.54 133.84,60.54 134.27,60.12 135.24,60.12 135.67,60.54 144.11,60.54 144.72,61.16 151.14,61.16 151.81,60.48 153.22,60.48 v1(153.26,60.44)
  BOTTOM w0.102: JDIMM4.97 154.34,59.36 v1(153.26,60.44)
DDR_B_MA2: length 78.8
  TOP w0.102: JDIMM3.96 158.15,59.66 157.85,59.36 156.19,59.36 156.07,59.49 156.07,59.83 156.19,59.95 157.71,59.95 157.84,60.08 157.84,60.29 v1(157.68,60.44) ; JCPU1.Y10 v1(98.12,58.75)
  IN3 w0.089: 109.89,61.78 109.31,61.78 108.61,61.07 103.92,61.07 102.75,59.9 102.75,58.53 102.5,58.28 102.5,57.59 102.24,57.34 100,57.34 99.76,57.57 99.76,57.63 98.96,58.44 98.43,58.44 v1(98.12,58.75)
  IN3 w0.178: 109.89,61.78 129.14,61.78 129.28,61.63 143.79,61.63 144.31,62.15 151.55,62.15 152.22,61.48 156.73,61.48 157.68,60.52 v1(157.68,60.44)
  BOTTOM w0.102: v1(157.68,60.44) 157.24,60.88 155.85,60.88 155.62,61.11 153.07,61.11 152.46,60.5 152.46,60.07 152.05,59.66 JDIMM4.96
DDR_B_MA3: length 78.9
  TOP w0.102: v1(156.31,60.44) 155.84,60.91 153.07,60.91 152.11,59.96 JDIMM3.95 ; JCPU1.AA5 v1(103.12,59.75)
  IN3 w0.089: 109.47,60.11 109.27,60.11 108.49,60.89 104.16,60.89 103.33,60.06 103.33,59.96 v1(103.12,59.75)
  IN3 w0.178: v1(156.31,60.44) 156.52,60.44 156.65,60.57 156.65,60.85 156.52,60.98 152.02,60.98 151.34,61.65 144.52,61.65 143.9,61.04 129.17,61.04 128.93,61.28 118.44,61.28 118.26,61.1 118.26,60.29 118.08,60.11 117.73,60.11 117.55,60.29 117.55,61.1 117.37,61.28 117.02,61.28 116.84,61.1 116.84,60.29 116.66,60.11 116.31,60.11 116.13,60.29 116.13,61.1 115.95,61.28 115.59,61.28 115.42,61.1 115.42,60.29 115.24,60.11 114.88,60.11 114.71,60.29 114.71,61.1 114.53,61.28 114.17,61.28 113.99,61.1 113.99,60.29 113.82,60.11 113.46,60.11 113.28,60.29 113.28,61.1 113.11,61.28 112.75,61.28 112.57,61.1 112.57,60.29 112.39,60.11 112.04,60.11 111.86,60.29 111.86,61.15 111.73,61.28 111.28,61.28 111.15,61.15 111.15,60.29 110.97,60.11 110.62,60.11 110.44,60.29 110.44,60.62 110.31,60.74 109.85,60.74 109.73,60.62 109.73,60.29 109.55,60.11 109.47,60.11
  BOTTOM w0.102: v1(156.31,60.44) 156.08,60.21 155.9,60.21 155.71,60.02 155.71,59.93 155.8,59.84 156.35,59.84 156.47,59.96 156.47,60.02 156.6,60.15 156.79,60.15 156.92,60.02 156.92,59.94 157.02,59.84 157.21,59.84 157.28,59.91 157.28,59.94 157.4,60.05 157.56,60.05 157.67,59.94 157.67,59.89 157.73,59.84 158.13,59.84 158.25,59.96 JDIMM4.95
DDR_B_MA4: length 78.8
  TOP w0.102: JCPU1.Y7 v1(101.12,58.75) ; v1(154.73,62.49) 155.84,61.39 156.03,61.39 156.51,60.91 158.08,60.91 158.13,60.86 JDIMM3.92
  IN3 w0.089: v1(101.12,58.75) 101.43,58.75 101.72,59.04 101.72,59.94 101.93,60.15 102.15,60.15 103.52,61.52 103.52,61.98 103.89,62.35 107.67,62.35 108.84,63.52 109.89,63.52
  IN3 w0.178: v1(154.73,62.49) 154.94,62.49 155.07,62.62 155.07,62.86 154.94,62.99 152.82,62.99 152.15,63.67 150.05,63.67 148.74,64.98 146.23,64.98 145.09,63.84 138.85,63.84 138.13,63.12 132.36,63.12 132.07,63.41 132.07,64.46 131.9,64.64 131.54,64.64 131.36,64.46 131.36,63.25 131.23,63.12 130.78,63.12 130.65,63.25 130.65,64.46 130.47,64.64 130.12,64.64 129.94,64.46 129.94,63.4 129.81,63.27 129.36,63.27 129.23,63.4 129.23,64.46 129.05,64.64 128.69,64.64 128.52,64.46 128.52,63.78 128.39,63.65 127.93,63.65 127.81,63.78 127.81,64.46 127.63,64.64 121.16,64.64 120.03,63.52 109.89,63.52
  BOTTOM w0.102: v1(154.73,62.49) 154.25,62.98 153.07,62.98 152.71,62.62 152.71,61.5 152.07,60.86 JDIMM4.92
DDR_B_MA5: length 79.9
  TOP w0.102: JDIMM3.91 152.04,61.16 152.41,61.53 152.56,61.53 152.66,61.63 152.66,61.78 152.76,61.89 152.96,61.89 153.06,61.78 153.06,61.63 153.16,61.53 154.21,61.53 154.34,61.66 154.34,61.96 154.21,62.09 153.33,62.09 153.21,62.21 v1(153.21,62.49) ; JCPU1.AA6 v1(102.12,59.75)
  IN3 w0.089: v1(102.12,59.75) 102.34,59.97 102.34,60.07 103.71,61.44 103.71,61.9 103.96,62.15 107.84,62.15 108.46,62.77 109.89,62.77
  IN3 w0.178: 109.89,62.77 120.63,62.77 120.81,62.95 120.81,63.59 120.94,63.72 121.39,63.72 121.52,63.59 121.52,62.95 121.7,62.77 122.05,62.77 122.23,62.95 122.23,63.94 122.41,64.12 122.77,64.12 122.94,63.94 122.94,62.95 123.12,62.77 123.48,62.77 123.65,62.95 123.65,63.94 123.83,64.12 124.19,64.12 124.37,63.94 124.37,62.95 124.54,62.77 124.9,62.77 125.08,62.95 125.08,63.94 125.25,64.12 125.61,64.12 125.79,63.94 125.79,62.95 125.97,62.77 126.32,62.77 126.5,62.95 126.5,63.94 126.68,64.12 127.03,64.12 127.21,63.94 127.21,62.95 127.39,62.77 127.74,62.77 127.92,62.95 127.92,63.03 128.05,63.16 128.51,63.16 128.63,63.03 128.63,62.95 128.81,62.77 129.55,62.77 129.7,62.63 138.34,62.63 139.05,63.34 145.29,63.34 145.32,63.37 145.57,63.37 145.79,63.15 145.97,63.15 146.29,63.47 146.29,63.65 146.08,63.87 146.08,64.12 146.43,64.48 146.88,64.48 147.06,64.3 147.06,64.16 147.18,64.03 147.64,64.03 147.77,64.16 147.77,64.3 147.94,64.48 148.53,64.48 149.85,63.17 151.94,63.17 152.62,62.49 v1(153.21,62.49)
  BOTTOM w0.102: JDIMM4.91 157.6,61.16 157.43,61.33 156.24,61.33 155.61,61.96 153.74,61.96 v1(153.21,62.49)
DDR_B_MA6: length 82.3
  TOP w0.102: JDIMM3.90 158.35,61.46 158.28,61.39 157.92,61.39 157.82,61.49 157.82,61.91 157.72,62.01 157.52,62.01 157.42,61.91 157.42,61.49 157.31,61.39 157.11,61.39 156.98,61.52 156.98,61.76 156.85,61.89 156.01,61.89 155.91,61.99 155.91,62.37 156.03,62.49 v1(156.25,62.49) ; JCPU1.Y6 101.59,59.24 v1(102.09,58.75)
  IN3 w0.089: v1(102.09,58.75) 102.09,58.71 101.76,58.37 100.9,58.37 100.72,58.55 100.72,58.91 100.96,59.15 101.16,59.15 101.52,59.51 101.52,60.15 102.72,61.35 102.72,61.91 102.9,62.09 103.36,62.09 103.72,62.45 103.72,62.91 103.96,63.15 107.48,63.15 108.34,64.01 109.89,64.01
  IN3 w0.178: 109.89,64.01 119.82,64.01 120.95,65.14 132.44,65.14 132.57,65.01 132.57,63.75 132.7,63.62 137.93,63.62 138.64,64.33 144.88,64.33 146.02,65.48 148.95,65.48 150.26,64.16 152.35,64.16 153.03,63.49 156.13,63.49 157.46,64.82 157.64,64.82 158.05,64.41 158.05,64.23 156.31,62.49 v1(156.25,62.49)
  BOTTOM w0.102: v1(156.25,62.49) 156.1,62.49 155.29,63.31 153.04,63.31 152.41,62.67 152.41,61.86 152.01,61.46 JDIMM4.90
DDR_B_MA7: length 77.3
  TOP w0.102: v1(156.4,64.58) 156.4,64.55 158.29,62.66 JDIMM3.86 ; JCPU1.AA7 v1(101.12,59.75)
  IN3 w0.089: v1(101.12,59.75) 101.12,60.08 102.52,61.48 102.52,61.98 102.81,62.27 103.27,62.27 103.53,62.53 103.53,62.99 103.89,63.35 106.39,63.35 106.4,63.34 107.36,63.34 108.54,64.51 109.89,64.51
  IN3 w0.178: 109.89,64.51 119.62,64.51 120.74,65.64 132.97,65.64 133.14,65.46 133.14,64.25 133.27,64.12 133.73,64.12 133.86,64.25 133.86,65.46 134.03,65.64 134.39,65.64 134.57,65.46 134.57,64.64 134.69,64.51 135.15,64.51 135.28,64.64 135.28,65.46 135.46,65.64 135.81,65.64 135.99,65.46 135.99,64.25 136.12,64.12 136.57,64.12 136.7,64.25 136.7,64.41 136.83,64.54 137.28,64.54 137.41,64.41 137.41,64.27 137.56,64.12 137.72,64.12 138.82,65.22 144.79,65.22 145.54,65.97 149.15,65.97 150.46,64.66 152.56,64.66 153.23,63.99 155.81,63.99 v1(156.4,64.58)
  BOTTOM w0.102: JDIMM4.86 151.99,62.66 153.11,63.78 155.6,63.78 v1(156.4,64.58)
DDR_B_MA8: length 82.4
  TOP w0.102: JCPU1.Y8 v1(100.12,58.75) ; JDIMM3.89 151.93,61.76 153.08,62.91 157.35,62.91 157.74,62.52 157.75,62.52 v1(157.78,62.49)
  IN3 w0.089: 109.89,62.27 108.28,62.27 107.36,61.35 103.9,61.35 102.9,60.34 102.88,60.34 102.57,60.03 102.57,58.6 102.11,58.15 100.72,58.15 v1(100.12,58.75)
  IN3 w0.178: 109.89,62.27 129.35,62.27 129.49,62.13 138.55,62.13 139.26,62.84 144.11,62.84 144.3,62.65 146.44,62.65 146.75,62.96 146.75,63.25 147.03,63.54 148.77,63.54 149.64,62.67 151.74,62.67 152.43,61.97 157.93,61.97 158.11,61.8 158.11,61.03 158.24,60.91 158.7,60.91 158.82,61.03 158.82,61.91 158.95,62.04 160.13,62.04 160.26,62.16 160.26,62.56 160.13,62.69 157.91,62.69 157.78,62.56 v1(157.78,62.49)
  BOTTOM w0.102: v1(157.78,62.49) 157.65,62.62 157.58,62.62 157.43,62.47 157.43,62.33 157.18,62.09 156.89,62.09 156.83,62.02 156.83,61.87 156.89,61.81 157.46,61.81 157.69,62.04 157.79,62.04 157.85,61.98 157.85,61.73 157.94,61.64 158.08,61.64 158.16,61.72 158.16,61.96 158.21,62.01 158.28,62.01 158.53,61.76 JDIMM4.89
DDR_B_MA9: length 76.3
  TOP w0.102: v1(154.87,64.58) 155.05,64.58 155.18,64.45 155.18,63.86 155.05,63.73 153.1,63.73 152.32,62.95 151.21,62.95 JDIMM3.85 ; JCPU1.AA10 v1(98.12,59.75)
  IN3 w0.089: v1(98.12,59.75) 98.25,59.75 98.81,59.19 99.6,59.19 99.76,59.35 100.25,59.35 100.52,59.62 100.52,60.28 101.53,61.29 101.53,61.94 101.93,62.34 102.24,62.34 102.5,62.59 102.5,62.9 102.93,63.34 103.24,63.34 103.53,63.63 103.53,63.94 103.89,64.3 106.71,64.3 107.91,65.51 109.89,65.51
  IN3 w0.178: v1(154.87,64.58) 155.03,64.58 155.15,64.7 155.15,65.53 155.03,65.66 150.93,65.66 149.01,67.58 145.5,67.58 144.56,66.63 122.59,66.63 121.91,67.31 121.01,67.31 119.21,65.51 109.89,65.51
  BOTTOM w0.102: JDIMM4.85 158.26,62.96 156.91,64.31 156.91,64.31 156.91,64.64 156.5,65.05 155.35,65.05 v1(154.87,64.58)
DDR_B_MA10: length 85
  TOP w0.102: JCPU1.R9 v1(99.12,53.75) ; JDIMM3.107 152.45,56.36 152.51,56.3 152.51,55.79 152.9,55.4 154.73,55.4 154.86,55.53 154.86,55.78 154.73,55.9 v1(154.51,55.9)
  IN3 w0.089: 109.89,55.91 108.98,55.91 107.54,57.35 102.94,57.35 102.52,56.93 102.52,56.58 102.31,56.37 101.83,56.37 101.5,56.03 101.5,55.59 101.28,55.37 101.05,55.37 100.72,55.05 100.72,54.19 100.52,53.99 100.52,53.55 100.29,53.33 99.54,53.33 v1(99.12,53.75)
  IN3 w0.178: v1(154.51,55.9) 154.72,55.9 154.84,56.03 154.84,56.27 154.72,56.4 151.67,56.4 151.16,56.91 150.98,56.91 150.65,56.58 150.65,56.4 150.82,56.24 150.82,56.06 150.52,55.77 150.34,55.77 149.71,56.4 149.43,56.4 149.19,56.16 148.56,56.16 148.41,56.3 148.41,57.02 148.29,57.15 147.83,57.15 147.7,57.02 147.7,56.55 147.49,56.34 147.02,56.34 146.59,55.91 139.44,55.91 138.74,55.2 131.32,55.2 130.61,55.91 119.3,55.91 119.12,55.73 119.12,53.84 118.99,53.71 118.54,53.71 118.41,53.84 118.41,55.73 118.23,55.91 117.88,55.91 117.7,55.73 117.7,53.84 117.57,53.71 117.11,53.71 116.99,53.84 116.99,55.73 116.81,55.91 116.45,55.91 116.28,55.73 116.28,55 116.15,54.88 115.69,54.88 115.56,55 115.56,55.73 115.39,55.91 109.89,55.91
  BOTTOM w0.102: JDIMM4.107 158.52,56.36 157.95,56.93 155.54,56.93 v1(154.51,55.9)
DDR_B_MA11: length 78.5
  TOP w0.102: v1(153.35,64.58) 153.78,65.01 156.61,65.01 158.36,63.26 JDIMM3.84 ; JCPU1.Y9 v1(99.04,58.81)
  IN3 w0.089: 109.89,65.01 107.67,65.01 106.78,64.12 103.97,64.12 103.72,63.88 103.72,63.45 103.42,63.15 102.99,63.15 102.67,62.83 102.67,62.41 102.42,62.15 101.99,62.15 101.72,61.88 101.72,61.21 100.72,60.21 100.72,59.56 100.33,59.17 99.93,59.17 99.6,58.84 99.07,58.84 v1(99.04,58.81)
  IN3 w0.178: 109.89,65.01 119.41,65.01 120.54,66.14 120.94,66.14 121.12,66.31 121.12,66.69 121.25,66.82 121.71,66.82 121.83,66.69 121.83,66.31 122.01,66.14 136.48,66.14 136.66,65.96 136.66,65.44 136.78,65.32 137.24,65.32 137.37,65.44 137.37,65.96 137.55,66.14 137.9,66.14 138.08,65.96 138.08,65.82 138.21,65.69 138.66,65.69 138.79,65.82 138.79,65.96 138.97,66.14 139.32,66.14 139.5,65.96 139.5,65.85 139.63,65.72 140.09,65.72 140.21,65.85 140.21,65.96 140.39,66.14 140.75,66.14 140.92,65.96 140.92,65.85 141.05,65.72 141.51,65.72 141.63,65.85 141.63,65.96 141.81,66.14 142.17,66.14 142.35,65.96 142.35,65.85 142.47,65.72 142.93,65.72 143.06,65.85 143.06,65.96 143.24,66.14 143.59,66.14 143.77,65.96 143.77,65.85 143.9,65.72 144.35,65.72 144.48,65.85 144.48,65.96 144.66,66.14 145,66.14 145.34,66.47 145.39,66.47 145.57,66.65 145.57,66.94 145.69,67.07 146.15,67.07 146.28,66.94 146.28,66.65 146.45,66.47 146.81,66.47 146.99,66.65 146.99,66.96 147.12,67.08 147.57,67.08 147.7,66.96 147.7,66.65 147.88,66.47 149.36,66.47 149.86,65.97 150.67,65.16 153.22,65.16 153.35,65.03 v1(153.35,64.58)
  BOTTOM w0.102: JDIMM4.84 152.25,63.26 152.54,63.55 152.54,63.93 152.41,64.06 152.41,64.2 152.69,64.48 152.84,64.48 152.94,64.37 152.94,64.17 153.01,64.1 153.79,64.1 153.84,64.16 153.84,64.27 153.54,64.58 v1(153.35,64.58)
DDR_B_MA12: length 77.3
  TOP w0.102: JDIMM3.83 152.12,63.56 152.64,64.08 152.64,64.49 153.65,65.5 156.18,65.5 v1(157.29,66.61) ; JCPU1.AF7 v1(101.12,65.75)
  IN3 w0.089: 109.89,66.01 108.16,66.01 107.31,65.16 101.71,65.16 v1(101.12,65.75)
  IN3 w0.178: v1(157.29,66.61) 157.29,66.56 156.88,66.15 151.14,66.15 149.22,68.08 145.3,68.08 145.03,67.81 140.53,67.81 139.85,67.13 128.54,67.13 128.42,67.26 128.42,67.63 128.24,67.81 127.88,67.81 127.71,67.63 127.71,67.26 127.58,67.13 127.12,67.13 126.99,67.26 126.99,67.63 126.82,67.81 126.46,67.81 126.28,67.63 126.28,67.26 126.16,67.13 125.7,67.13 125.57,67.26 125.57,67.63 125.39,67.81 125.04,67.81 124.86,67.63 124.86,67.26 124.73,67.13 124.28,67.13 124.15,67.26 124.15,67.63 123.97,67.81 123.62,67.81 123.44,67.63 123.44,67.26 123.31,67.13 122.85,67.13 122.73,67.26 122.73,67.63 122.55,67.81 120.81,67.81 119,66.01 109.89,66.01
  BOTTOM w0.102: JDIMM4.83 158.29,63.56 157.55,64.3 157.55,64.92 157.29,65.19 157.29,65.58 157.18,65.68 156.77,65.68 156.65,65.8 156.65,65.97 156.77,66.09 157.18,66.09 157.29,66.19 v1(157.29,66.61)
DDR_B_MA13: length 85.9
  TOP w0.102: v1(156.12,53.85) 155.14,52.87 152.44,52.87 152.33,52.76 JDIMM3.119 ; v1(99.07,52.79) 98.59,53.26 JCPU1.P9
  IN3 w0.089: 109.89,52.92 109.46,52.92 108.03,54.35 103.94,54.35 103.52,53.93 103.52,52.62 103.06,52.16 99.7,52.16 v1(99.07,52.79)
  IN3 w0.178: 109.89,52.92 113.42,52.92 116.88,49.47 124.41,49.47 125.09,50.15 127.87,50.15 128,50.28 128,50.59 128.13,50.72 128.63,50.72 128.76,50.59 128.76,50.34 128.93,50.16 129.29,50.16 129.47,50.34 129.47,50.54 129.64,50.72 130.75,50.72 131.32,50.15 134.11,50.15 134.59,50.63 135.84,50.63 136.01,50.8 136.34,50.8 136.52,50.62 136.52,49.99 136.69,49.81 137.05,49.81 137.23,49.99 137.23,50.62 137.4,50.8 137.76,50.8 137.94,50.62 137.94,49.8 138.07,49.68 138.52,49.68 138.65,49.8 138.65,50.62 138.83,50.8 144.55,50.8 146.53,52.78 152.03,52.78 152.35,53.1 155.31,53.1 155.43,52.98 155.43,52.43 155.56,52.3 158.78,52.3 158.91,52.43 158.91,53.21 158.78,53.34 156.25,53.34 156.12,53.46 v1(156.12,53.85)
  BOTTOM w0.102: JDIMM4.119 155.89,52.76 155.76,52.89 155.76,53.72 155.89,53.85 v1(156.12,53.85)
DDR_B_MA14: length 82.1
  TOP w0.102: v1(156.07,66.61) 156.51,67.05 157.43,67.05 157.76,66.72 157.76,65.26 158.56,64.46 JDIMM3.80 ; JCPU1.AA8 v1(100.12,59.75)
  IN3 w0.089: 109.89,67.5 108.4,67.5 107.25,66.35 103.99,66.35 103.6,66.74 103.6,66.8 103.27,67.13 100.97,67.13 100.75,66.9 100.75,66.84 100.03,66.12 99.97,66.12 99.75,65.9 99.75,61.12 98.75,60.12 98.75,59.59 98.97,59.37 99.43,59.37 99.63,59.57 99.95,59.57 v1(100.12,59.75)
  IN3 w0.178: v1(156.07,66.61) 156.07,66.99 155.41,67.65 151.8,67.65 149.43,70.01 145.03,70.01 144.9,69.88 144.9,69.85 144.78,69.72 144.42,69.72 144.29,69.85 144.29,69.9 144.18,70.01 143.72,70.01 143.61,69.9 143.61,69.8 143.48,69.68 143.04,69.68 142.91,69.8 142.91,69.89 142.8,70.01 142.31,70.01 142.2,69.9 142.2,69.82 142.07,69.69 141.64,69.69 141.51,69.82 141.51,69.88 141.39,70.01 140.89,70.01 140.76,69.88 140.76,69.82 140.64,69.7 140.18,69.7 140.05,69.82 140.05,69.88 139.93,70.01 139.5,70.01 139.39,69.9 139.39,69.8 139.29,69.7 138.91,69.7 138.53,69.32 120.2,69.32 118.38,67.5 109.89,67.5
  BOTTOM w0.102: v1(156.07,66.61) 154.94,65.48 153.07,65.48 152.05,64.46 JDIMM4.80
DDR_B_MA15: length 74.3
  TOP w0.102: JDIMM3.78 158.59,65.06 158.06,65.59 158.06,66.75 157.49,67.32 155.56,67.32 v1(154.85,66.61) ; JCPU1.AG7 v1(101.12,66.75)
  IN3 w0.089: v1(101.12,66.75) 101.71,66.16 107.31,66.16 108.16,67 109.89,67
  IN3 w0.178: v1(154.85,66.61) 154.97,66.74 154.97,67.02 154.85,67.15 151.59,67.15 149.67,69.07 148.97,69.07 148.77,69.27 148.77,69.39 148.64,69.51 148.18,69.51 148.06,69.39 148.06,69.27 147.86,69.07 147.39,69.07 147.21,69.25 147.21,69.35 147.08,69.48 146.63,69.48 146.5,69.35 146.5,69.2 146.37,69.07 145.91,69.07 145.78,69.2 145.78,69.39 145.65,69.51 145.27,69.51 145.14,69.39 145.14,69.2 145.02,69.07 144.89,69.07 144.62,68.81 139.62,68.81 139.6,68.82 139.22,68.82 139.09,68.7 139.09,68.31 138.91,68.13 138.56,68.13 138.38,68.31 138.38,68.64 138.2,68.82 137.85,68.82 137.67,68.64 137.67,68.31 137.49,68.13 137.14,68.13 136.96,68.31 136.96,68.64 136.78,68.82 136.34,68.82 136.22,68.69 136.22,68.25 136.09,68.13 135.59,68.13 135.47,68.25 135.47,68.69 135.34,68.82 120.41,68.82 118.59,67 109.89,67
  BOTTOM w0.102: v1(154.85,66.61) 154.85,66.14 154.73,66.03 153.27,66.03 153.13,66.16 153.13,66.57 153.01,66.7 152.73,66.7 152.6,66.57 152.6,65.59 152.07,65.06 JDIMM4.78
DDR_B_RAS#: length 83.7
  TOP w0.102: v1(157.56,55.9) 157.56,55.61 157.43,55.48 156.29,55.48 156.17,55.36 156.17,55.18 156.29,55.05 157.95,55.05 158.07,55.18 158.07,55.33 158.2,55.46 JDIMM3.110 ; JCPU1.R6 v1(102.12,53.75)
  IN3 w0.089: v1(102.12,53.75) 102.12,53.97 102.75,54.59 102.75,54.9 103.02,55.17 103.41,55.17 103.69,55.45 103.69,55.9 103.95,56.16 107.44,56.16 109.18,54.41 109.89,54.41
  IN3 w0.178: v1(157.56,55.9) 157.56,56.18 157.68,56.31 160.14,56.31 160.27,56.18 160.27,54.18 160.14,54.05 159.44,54.05 159.31,54.18 159.31,55.37 159.14,55.55 158.78,55.55 158.6,55.37 158.6,55.07 158.42,54.89 151.99,54.89 151.37,54.27 145.79,54.27 145.04,53.53 143.39,53.53 142.75,52.89 139.61,52.89 138.79,53.71 129.48,53.71 129.33,53.55 129.33,52.34 129.2,52.22 116.24,52.22 114.04,54.41 109.89,54.41
  BOTTOM w0.102: JDIMM4.110 152.34,55.46 152.51,55.29 156.94,55.29 v1(157.56,55.9)
DDR_B_WE#: length 84.1
  TOP w0.102: JCPU1.P6 v1(102.12,52.75) ; v1(153.07,53.85) 153.1,53.83 153.3,53.83 153.45,53.98 153.45,54.04 153.7,54.3 153.7,54.39 153.64,54.45 153.03,54.45 152.72,54.14 152.65,54.14 152.51,54.28 152.51,54.34 152.62,54.45 152.62,54.58 152.46,54.73 152.38,54.73 152.33,54.69 152.33,54.6 152.29,54.56 JDIMM3.113
  IN3 w0.089: 109.89,53.42 109.29,53.42 107.56,55.15 103.96,55.15 103.72,54.91 103.72,54.57 103.31,54.16 103,54.16 102.75,53.9 102.75,53.37 v1(102.12,52.75)
  IN3 w0.178: v1(153.07,53.85) 152.37,53.85 151.8,53.28 146.2,53.28 144.82,51.89 144.36,51.89 143.77,51.3 141.76,51.3 141.49,51.57 141.49,51.76 141.36,51.89 139.2,51.89 139.07,51.76 139.07,51.42 138.95,51.3 136.85,51.3 136.58,51.56 136.3,51.56 136.12,51.74 136.12,51.88 135.94,52.06 135.58,52.06 135.41,51.88 135.41,51.74 135.23,51.56 134.87,51.56 134.7,51.74 134.7,51.88 134.52,52.06 134.16,52.06 133.98,51.88 133.98,51.74 133.81,51.56 133.69,51.56 133.6,51.47 133.6,50.8 133.45,50.65 133.04,50.65 132.94,50.75 132.94,51.12 132.84,51.22 132.33,51.22 132.16,51.04 132.16,50.78 132.03,50.65 131.57,50.65 131.44,50.78 131.44,51.04 131.27,51.22 127.63,51.22 127.45,51.04 127.45,50.86 127.27,50.68 126.92,50.68 126.74,50.86 126.74,51.04 126.56,51.22 126.21,51.22 126.03,51.04 126.03,50.86 125.85,50.68 125.5,50.68 125.32,50.86 125.32,51.04 125.14,51.22 124.78,51.22 124.61,51.04 124.61,50.54 124.48,50.42 124.02,50.42 123.89,50.54 123.89,51.04 123.72,51.22 123.36,51.22 123.18,51.04 123.18,50.09 123.06,49.96 122.6,49.96 122.47,50.09 122.47,51.04 122.29,51.22 121.94,51.22 121.76,51.04 121.76,50.09 121.63,49.96 121.18,49.96 121.05,50.09 121.05,51.04 120.87,51.22 120.52,51.22 120.34,51.04 120.34,50.09 120.21,49.96 119.75,49.96 119.63,50.09 119.63,51.04 119.45,51.22 119.09,51.22 118.92,51.04 118.92,50.09 118.79,49.96 118.33,49.96 118.21,50.09 118.21,51.04 118.03,51.22 117.67,51.22 117.49,51.04 117.49,50.26 117.37,50.14 116.91,50.14 116.78,50.26 116.78,51.04 116.61,51.22 115.83,51.22 113.63,53.42 109.89,53.42
  BOTTOM w0.102: v1(153.07,53.85) 154.04,54.82 158.07,54.82 158.33,54.56 JDIMM4.113
DDR_CKE0_DIMM2: length 54.1
  TOP w0.102: JCPU1.AD9 v1(99.12,63.75)
  IN1 w0.089: 109.89,68.97 109.61,68.69 109.61,68.59 107.92,66.9 107.92,66.43 107.5,66 107.5,65.59 107.25,65.35 101.19,65.35 100.69,64.85 100.69,64.79 100.25,64.35 99.72,64.35 v1(99.12,63.75)
  IN1 w0.178: 109.89,68.97 110.53,68.97 113.19,71.63 118.19,71.63 118.79,72.23 132.17,72.23 132.95,71.45 137.14,71.45 138.77,69.83 141.57,69.83 v1(142.15,69.25)
  BOTTOM w0.102: v1(142.15,69.25) 143.06,68.34 143.56,68.34 144.59,67.31 144.59,66.84 144.87,66.55 JDIMM2.73
DDR_CKE1_DIMM2: length 53.1
  TOP w0.102: JCPU1.AC9 v1(99.12,62.75)
  IN1 w0.089: v1(99.12,62.75) 99.58,63.21 100.11,63.21 100.62,63.71 100.62,63.77 100.97,64.12 101.72,64.12 101.97,64.37 106.28,64.37 106.88,64.98 107.39,64.98 107.85,65.44 107.85,65.86 108.29,66.29 108.29,66.77 109.43,67.9 109.89,67.9
  IN1 w0.178: v1(140.62,69.25) 140.83,69.25 140.95,69.12 140.95,68.89 140.83,68.76 138.32,68.76 136.7,70.38 132.5,70.38 131.72,71.16 119.23,71.16 118.63,70.57 113.64,70.57 110.97,67.9 109.89,67.9
  BOTTOM w0.102: JDIMM2.74 138.55,66.25 140.62,68.32 v1(140.62,69.25)
DDR_CKE2_DIMM4: length 69.9
  TOP w0.102: JCPU1.AF10 v1(98.12,65.75)
  IN3 w0.089: 109.89,69.36 108.81,69.36 107.54,68.08 106.57,68.08 106.3,68.35 103.99,68.35 103.72,68.62 103.72,68.68 103.28,69.12 99.97,69.12 99.68,68.83 99.68,68.77 99.03,68.12 98.97,68.12 98.75,67.9 98.75,67.84 98.05,67.15 97.99,67.15 97.75,66.9 97.75,66.12 v1(98.12,65.75)
  IN3 w0.152: 109.89,69.36 117.61,69.36 119.43,71.18 137.77,71.18 138.95,72.36 149.71,72.36 152.51,69.56 156.65,69.56 v1(157.56,68.65)
  BOTTOM w0.102: JDIMM4.73 158.68,66.56 158.58,66.66 158.58,67.63 v1(157.56,68.65)
DDR_CKE3_DIMM4: length 65.8
  TOP w0.102: JCPU1.AG10 v1(98.12,66.75)
  IN3 w0.089: 109.89,68.9 108.74,68.9 107.74,67.91 106.49,67.91 106.24,68.16 103.74,68.16 103.54,68.36 99.83,68.36 99.5,68.03 99.5,67.52 99.35,67.37 98.75,67.37 v1(98.12,66.75)
  IN3 w0.152: 109.89,68.9 117.8,68.9 119.62,70.72 137.95,70.72 139.13,71.9 146.48,71.9 146.97,71.41 150.01,71.41 152.32,69.1 154.06,69.1 v1(154.52,68.65)
  BOTTOM w0.102: v1(154.52,68.65) 154.11,68.24 153.58,68.24 152.1,66.76 152.1,66.41 151.96,66.26 JDIMM4.74
DDR_CKE4_DIMM1: length 52.6
  TOP w0.102: JCPU1.AD8 v1(100.12,63.75) ; v1(139.1,69.25) 139.1,68.69 139.2,68.59 139.82,68.59 139.94,68.47 139.94,68.3 139.82,68.18 139.2,68.18 139.1,68.08 139.1,67.88 139.2,67.78 139.82,67.78 139.94,67.66 139.94,67.49 139.82,67.37 139.2,67.37 139.1,67.27 139.1,66.86 138.79,66.55 JDIMM1.73
  IN1 w0.089: 109.89,68.44 109.86,68.44 109.76,68.33 109.6,68.33 108.11,66.84 108.11,66.37 107.67,65.93 107.67,65.51 107.32,65.16 101.67,65.16 101.55,65.03 101.55,64.43 101.42,64.3 100.47,64.3 100.31,64.14 99.86,64.14 99.74,64.02 99.74,63.86 99.86,63.75 v1(100.12,63.75)
  IN1 w0.178: v1(139.1,69.25) 139.06,69.29 138.54,69.29 136.92,70.91 132.72,70.91 131.94,71.69 119.01,71.69 118.41,71.1 113.41,71.1 110.75,68.44 109.89,68.44
DDR_CKE5_DIMM1: length 53.9
  TOP w0.102: v1(143.67,69.25) 143.67,68.31 144.79,67.19 144.79,66.43 144.97,66.25 JDIMM1.74 ; v1(100.12,62.75) 99.65,62.28 JCPU1.AC8
  IN1 w0.089: 109.89,67.37 109.14,67.37 108.47,66.69 108.47,66.22 108.03,65.78 108.03,65.37 107.47,64.8 106.96,64.8 106.31,64.16 102,64.16 101.69,63.84 101.69,63.74 101.12,63.18 100.55,63.18 v1(100.12,62.75)
  IN1 w0.178: 109.89,67.37 111.19,67.37 113.86,70.03 118.86,70.03 119.45,70.63 131.5,70.63 132.28,69.85 136.48,69.85 138.1,68.23 141.05,68.23 141.54,68.72 143.14,68.72 v1(143.67,69.25)
DDR_CKE6_DIMM3: length 65.2
  TOP w0.102: JCPU1.AG9 v1(99.12,66.75) ; v1(152.99,68.65) 152.99,68.31 153.12,68.18 154.05,68.18 154.18,68.06 154.18,67.74 154.05,67.61 153.04,67.61 151.99,66.56 JDIMM3.73
  IN3 w0.089: v1(99.12,66.75) 99.57,67.2 99.57,67.34 99.7,67.47 99.7,67.96 99.93,68.18 103.36,68.18 103.67,67.88 103.67,67.65 103.98,67.34 107.5,67.34 108.6,68.44 109.89,68.44
  IN3 w0.152: 109.89,68.44 117.99,68.44 119.81,70.26 138.14,70.26 138.84,70.95 144.18,70.95 144.33,71.11 144.33,71.28 144.48,71.44 144.79,71.44 144.94,71.28 144.94,71.11 145.09,70.95 145.4,70.95 145.55,71.11 145.55,71.28 145.7,71.44 146.01,71.44 146.16,71.28 146.16,71.11 146.31,70.95 149.82,70.95 152.19,68.59 152.94,68.59 v1(152.99,68.65)
DDR_CKE7_DIMM3: length 69
  TOP w0.102: JDIMM3.74 158.61,66.26 158.52,66.36 158.52,67.38 157.74,68.16 156.52,68.16 156.04,68.64 v1(156.04,68.65) ; JCPU1.AF9 v1(99.12,65.75)
  IN3 w0.089: 109.89,67.98 108.48,67.98 107.65,67.15 103.91,67.15 103.69,67.37 100.21,67.37 99.99,67.15 99.92,67.15 99.52,66.76 99.52,66.58 99.12,66.18 v1(99.12,65.75)
  IN3 w0.152: 109.89,67.98 118.18,67.98 120,69.8 138.33,69.8 139.02,70.5 149.63,70.5 152,68.13 155.61,68.13 156.49,67.25 156.67,67.25 156.96,67.55 156.96,67.72 v1(156.04,68.65)
DDR_CS0_DIMM2#: length 57.3
  TOP w0.102: JCPU1.M7 v1(101.12,50.75)
  IN1 w0.089: 109.89,51.21 109.83,51.21 109.08,51.97 107.77,51.97 107.54,52.19 96.77,52.19 96.64,52.07 96.64,51.47 96.77,51.34 97.18,51.34 97.3,51.47 97.3,51.73 97.43,51.85 97.58,51.85 97.71,51.73 97.71,51.47 97.84,51.34 100.29,51.34 100.41,51.22 100.41,50.99 100.53,50.87 100.68,50.87 100.8,50.99 100.8,51.22 100.92,51.34 101.15,51.34 101.28,51.22 101.28,50.87 101.15,50.75 v1(101.12,50.75)
  IN1 w0.178: 109.89,51.21 111.78,51.21 114.08,48.91 124.41,48.91 125.26,49.76 126.64,49.76 126.77,49.63 126.77,49.04 126.89,48.91 127.38,48.91 127.5,49.04 127.5,49.41 127.63,49.53 128,49.53 128.14,49.67 128.14,50.23 128.27,50.35 128.67,50.35 128.8,50.23 128.8,49.88 128.93,49.76 129.3,49.76 129.43,49.88 129.43,50.35 129.86,50.79 132.48,50.79 132.84,51.16 134.13,51.16 v1(134.17,51.12)
  BOTTOM w0.102: v1(134.17,51.12) 133.77,51.12 133.64,51.24 133.64,51.81 133.77,51.94 134.51,51.94 134.63,52.07 134.63,53.31 135.58,54.25 JDIMM2.114
DDR_CS1_DIMM2#: length 57.3
  TOP w0.089: JCPU1.L9 v1(99.12,49.75)
  IN1 w0.089: 108.62,48.54 107.79,49.37 102.62,49.37 102.41,49.16 102.08,49.16 101.95,49.28 101.95,49.38 101.84,49.49 101.68,49.49 101.57,49.38 101.57,49.28 101.44,49.16 99.77,49.16 99.64,49.28 99.64,49.88 99.51,50.01 99.25,50.01 99.12,49.88 v1(99.12,49.75)
  IN1 w0.178: 108.62,48.54 110.68,48.54 113.62,45.6 119.23,45.6 119.41,45.78 119.41,46.07 119.59,46.25 119.94,46.25 120.12,46.07 120.12,45.78 120.3,45.6 120.65,45.6 120.83,45.78 120.83,46.07 121.01,46.25 121.36,46.25 121.54,46.07 121.54,45.78 121.72,45.6 122.08,45.6 122.25,45.78 122.25,46.07 122.43,46.25 122.79,46.25 122.96,46.07 122.96,45.78 123.14,45.6 123.5,45.6 123.68,45.78 123.68,46.07 123.85,46.25 124.21,46.25 124.39,46.07 124.39,45.78 124.56,45.6 124.92,45.6 125.1,45.78 125.1,46.07 125.28,46.25 125.63,46.25 125.81,46.07 125.81,45.78 125.99,45.6 126.34,45.6 126.52,45.78 126.52,46.07 126.7,46.25 129.64,46.25 130.1,46.71 132.17,46.71 133.55,48.09 135.71,48.09 137.34,49.72 v1(139.63,49.72)
  BOTTOM w0.102: JDIMM2.121 143.9,52.15 139.96,50.05 v1(139.63,49.72)
DDR_CS2_DIMM4#: length 72.2
  TOP w0.102: JCPU1.P4 v1(104.12,52.75)
  IN3 w0.089: 109.89,52.44 109.53,52.44 107.81,54.16 104,54.16 103.72,53.88 103.72,53.15 v1(104.12,52.75)
  IN3 w0.152: 109.89,52.44 113.22,52.44 116.68,48.98 117.23,48.98 117.38,48.83 117.38,48.32 117.54,48.17 117.84,48.17 117.99,48.32 117.99,48.83 118.15,48.98 118.45,48.98 118.6,48.83 118.6,48.29 118.73,48.16 119.09,48.16 119.21,48.29 119.21,48.83 119.37,48.98 119.67,48.98 119.82,48.83 119.82,48.32 119.97,48.17 120.28,48.17 120.43,48.32 120.43,48.83 120.58,48.98 120.89,48.98 121.04,48.83 121.04,48.32 121.19,48.17 121.5,48.17 121.65,48.32 121.65,48.83 121.8,48.98 122.11,48.98 122.26,48.83 122.26,48.32 122.41,48.17 122.72,48.17 122.87,48.32 122.87,48.83 123.02,48.98 123.33,48.98 123.48,48.83 123.48,48.32 123.63,48.17 123.94,48.17 124.09,48.32 124.09,48.83 124.24,48.98 125.04,48.98 125.17,49.11 125.17,49.54 125.29,49.67 134.31,49.67 134.79,50.14 135.66,50.14 135.78,50.02 135.78,49.32 135.91,49.19 139.07,49.19 139.2,49.32 139.2,50.19 139.32,50.31 144.75,50.31 146.32,51.88 150.28,51.88 150.69,52.29 152.23,52.29 152.55,52.62 154.82,52.62 154.95,52.49 154.95,51.94 154.82,51.81 v1(154.62,51.81)
  BOTTOM w0.102: v1(154.62,51.81) 153.29,53.15 153.17,53.15 152.56,53.76 152.56,53.93 152.24,54.26 JDIMM4.114
