# Allegro board LA-9771PR10-0624.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_DDPD_AUX#_C: length 3.1
  TOP w0.102: U629.29 34.83,158.22 34.74,158.3 34.74,158.6 33.74,159.6 33.74,159.9 C536.2
PCH_DDPD_AUX_C: length 3.1
  TOP w0.102: C535.2 33.51,159.9 33.51,159.5 v3(33.94,159.08) 34.51,158.5 34.51,158.29 34.43,158.21 U629.30
PCH_DDPD_CTRLCLK: length 81.4
  TOP w0.102: v1(29.24,106.32) 29.4,106.47 UH1.N40 ; U629.25 36.43,158.2 36.51,158.28 36.51,158.94 36.91,159.34 36.91,161.63 v1(36.74,161.81)
  IN1 w0.109: v1(36.74,161.81) 36.91,161.64 36.91,161.09 35.65,159.84 32.12,159.84 30.48,158.2 30.48,156.52 30.28,156.32 30.28,149.24 31.28,148.24 31.28,143.6 30.97,143.29 30.97,135.29 30.74,135.06 30.49,135.06 v1(30.29,135.27)
  BOTTOM w0.102: v1(30.29,135.27) 30.49,135.06 30.81,135.06 31.45,134.42 31.45,128.69 33.28,126.86 33.28,120.31 30.39,117.41 27.18,117.41 25.76,115.99 23.76,115.99 22.06,114.29 22.06,112.43 RH255.2 21.98,111.97 21.9,111.9 21.9,111.79 22.77,110.92 22.81,110.92 23.86,109.87 23.86,109.53 24.97,108.42 26.67,108.42 27.38,107.71 27.85,107.71 28.84,106.72 28.84,106.3 29.01,106.13 29.17,106.13 29.24,106.2 v1(29.24,106.32)
PCH_DDPD_CTRLDATA: length 81.4
  TOP w0.102: UH1.N38 29.66,105.28 v1(29.22,105.73) ; v1(37.32,161.81) 37.14,161.63 37.14,159.25 36.73,158.84 36.73,158.27 36.83,158.18 U629.24
  IN1 w0.109: v1(30.29,134.66) 30.46,134.83 30.84,134.83 31.21,135.19 31.21,143.19 31.51,143.5 31.51,148.34 30.51,149.34 30.51,156.22 30.72,156.42 30.72,158.1 32.22,159.61 35.75,159.61 37.14,161 37.14,161.63 v1(37.32,161.81)
  BOTTOM w0.102: v1(30.29,134.66) 30.46,134.83 30.72,134.83 31.23,134.33 31.23,128.59 33.05,126.76 33.05,120.4 30.29,117.64 27.09,117.64 25.66,116.22 23.66,116.22 21.83,114.38 21.83,112.43 RH256.2 21.4,111.97 22.68,110.69 22.71,110.69 23.63,109.77 23.63,109.43 24.88,108.19 26.58,108.19 27.29,107.48 27.75,107.48 28.61,106.62 28.61,106.21 29.09,105.73 v1(29.22,105.73)
PCH_DPWROK: length 217.9
  TOP w0.102: v1(28.55,94.34) 28.95,94.74 UH1.L13
  IN2 w0.127: v1(56.63,93.46) 56.27,93.1 49.35,93.1 44.98,88.73 42.94,88.73 42.7,88.49 38.69,88.49 37.15,90.03 31.88,90.03 31.31,90.6 30.12,90.6 29.24,91.48 29.04,91.48 28.74,91.78 28.74,94.15 v1(28.55,94.34)
  IN3 w0.127: v1(165.91,85.65) 166.98,84.58 175.32,84.58 177.31,82.59 180.27,82.59 180.81,83.12 182.93,83.12 187.14,78.9 202.08,78.9 207.69,73.3 v1(207.69,72.1)
  IN4 w0.109: v1(165.91,85.65) 165.91,85.71 158.2,93.42 129.72,93.42 128.94,94.2 115.57,94.2 114.53,95.24 107.56,95.24 106.26,96.54 81.87,96.54 81.57,96.84 72.4,96.84 69.41,93.85 66.42,93.85 65.36,94.91 58.08,94.91 v1(56.63,93.46)
  BOTTOM w0.102: v1(207.69,72.1) 209.39,72.1 210.09,72.81 210.09,73.37 210.4,73.67 210.4,74.94 R802.1 ; RH131.2 RH79.1 23.67,85.74 24.49,86.56 24.49,87.4 25.15,88.05 26.69,88.05 27.24,88.61 27.24,90.13 28.61,91.5 28.61,92.34 28.74,92.47 28.74,93.37 v2(28.69,93.42) 28.69,94.2 v1(28.55,94.34)
PCH_GPIO3: length 11.4
  TOP w0.102: v1(26.86,96.25) 26.56,96.54 UH1.F17
  BOTTOM w0.102: v1(26.86,96.25) v2(25.51,96.25) 25.36,96.25 24.12,97.49 22.39,97.49 21.29,98.59 20.01,98.59 19.21,99.39 18.11,99.39 RH83.2
PCH_GPIO06: length 13.1
  TOP w0.102: v1(22.58,94.87) 23.07,95.36 24.56,95.36 UH1.A14
  IN3 w0.127: v1(22.58,94.87) 22.58,94.84 22.16,94.42 19.29,94.42 18.73,94.98 17.53,94.98 17.28,94.73 15.68,94.73 15.02,95.39 v1(14.74,95.39)
  BOTTOM w0.102: RPH8.7 14.14,95.06 14.46,95.39 v1(14.74,95.39) 14.78,95.39 v2(15.36,95.97)
PCH_GPIO13: length 3.2
  TOP w0.102: v1(24.11,99.02) 24.14,98.99 24.49,98.99 24.49,99 24.76,99 25.07,98.69 UH1.C22
  BOTTOM w0.089: v2(24.65,99.2) 24.47,99.02 v1(24.11,99.02)
  BOTTOM w0.102: RH60.2 24.11,99.1 v1(24.11,99.02)
PCH_GPIO15: length 14.5
  TOP w0.102: UH1.AB11 33.55,94.1 v1(33.15,94.51)
  BOTTOM w0.102: v1(33.15,94.51) 32.75,94.1 32.75,88.21 34.84,86.12 v2(34.84,84.96) 34.84,84.63 35.16,84.31 35.16,82.46 RH211.2
PCH_GPIO24: length 11.1
  TOP w0.102: UH1.Y10 32.37,93.22 v1(32.22,93.22)
  BOTTOM w0.076: 31.7,92.69 v1(32.22,93.22)
  BOTTOM w0.089: 31.7,92.69 31.7,91.78 31.59,91.67
  BOTTOM w0.102: 31.59,91.67 31.57,91.65 31.57,90.72 31.86,90.42 31.86,88.14 v2(32.02,87.98) 34.15,85.85 34.15,84.62 RH213.1
PCH_GPIO33: length 5.8
  TOP w0.102: UH1.B17 25.01,96.76 24.21,96.76 23.92,96.47 21.67,96.47 v2(21.5,96.64) 21.5,96.84 21.01,97.32 RH40.2
PCH_GPIO34: length 9.8
  TOP w0.102: UH1.AN6 38.41,91.72 v1(38.65,91.95)
  BOTTOM w0.102: v1(38.65,91.95) 38.97,91.63 38.97,90.97 38.69,90.69 38.69,88.81 39.67,87.83 v2(40.03,87.83) 40.52,87.83 42.34,86.02 42.71,86.02 42.97,85.75 RPH10.5
PCH_GPIO35: length 110.2
  TOP w0.102: v1(37.93,118.5) 37.93,118.12 RH25.1 ; UH1.AP1 38.49,89.71 38.49,89.01 41.31,86.2 v2(41.31,86.02) 41.31,85.58 RH205.1 42.27,84.62 42.27,83.3 v1(42.25,83.27)
  IN3 w0.127: v1(42.25,83.27) 42.07,83.09 40.75,83.09 39.87,83.97 38.3,83.97 37.84,84.43 35.81,84.43 33.94,86.29 31.48,86.29 29.17,83.98 17.46,83.98 17,83.53 13.73,83.53 8.75,88.51 8.75,89.15 5.95,91.95 5.95,96.02 7.7,97.77 7.7,112.26 8.41,112.96 8.56,112.96 9.58,113.98 10.66,113.98 12.84,116.16 15.07,116.16 15.83,116.93 15.83,118.88 17.67,120.71 22.09,120.71 22.97,121.59 25.29,121.59 25.93,122.24 30.82,122.24 33.33,119.72 36.71,119.72 v1(37.93,118.5)
PCH_GPIO36: length 117.9
  TOP w0.102: v1(39.05,119.77) 38.64,120.18 RH12.1 ; v1(43.85,82.94) RH230.1 43.39,82.74 43.39,84.62 RH228.1 43.08,85.08 v2(42.88,85.27) 38.92,89.23 38.92,89.91 38.92,89.91 38.92,89.93 38.94,89.95 38.95,89.95 39.13,90.13 39.13,90.13 39.23,90.23 UH1.AT3
  IN3 w0.127: v1(43.85,82.94) 43.04,83.75 41.92,83.75 41.44,84.24 38.39,84.24 37.94,84.68 35.91,84.68 34.05,86.55 31.37,86.55 29.06,84.24 17.22,84.24 16.94,84.52 13.1,84.52 9.01,88.61 9.01,89.25 6.21,92.05 6.21,95.91 7.96,97.67 7.96,112.15 8.52,112.71 8.67,112.71 9.69,113.73 10.76,113.73 12.95,115.91 15.18,115.91 16.09,116.82 16.09,118.77 17.77,120.46 22.2,120.46 23.08,121.33 25.39,121.33 26.04,121.98 29.6,121.98 32.11,119.47 36.36,119.47 37.75,118.07 38.69,118.07 39.05,118.43 v1(39.05,119.77)
PCH_GPIO37: length 106.5
  TOP w0.102: RH14.1 37.52,121.07 v1(37.96,120.64) ; v1(37.65,81.39) 37.42,81.62 37.42,82.46 RH37.1 37.42,83.37 37.42,84.67 37.83,85.08 RH62.1 37.64,85.31 v2(37.64,85.99) 37.64,87.85 37.12,88.37 37.12,89.29 36.79,89.62 UH1.AK1
  IN3 w0.127: v1(37.65,81.39) 37.04,82 36.61,82 36.27,81.66 35.48,81.66 34.55,82.59 13.6,82.59 6.74,89.44 6.54,89.44 6.1,89.88 6.1,90.72 5.19,91.63 5.19,96.33 6.94,98.09 6.94,113.49 8.19,114.74 10.34,114.74 17.95,122.35 24.97,122.35 25.62,123 31.14,123 33.65,120.48 37.8,120.48 v1(37.96,120.64)
PCH_GPIO49: length 71.7
  TOP w0.102: UH1.AK3 36.86,90.61 36.86,90.14 37.1,89.91 37.1,89.58 37.35,89.33 37.35,88.46 37.98,87.83 v2(37.98,87.29) 37.98,86.09 38.77,85.3 38.77,85.08 39.23,84.62 39.23,83.83 39.12,83.73 39.12,83.27 RH225.1 39.4,82.28 v1(39.4,81.39) ; RH19.1 14.05,115.35 v1(13.42,115.35)
  IN4 w0.109: v1(13.42,115.35) 11.45,113.38 11.45,112.18 10.35,111.09 10.35,111.05 8.97,109.68 8.97,103.62 10.39,102.21 10.39,93.55 13.78,90.16 14.46,90.16 15.67,88.94 15.67,88.36 19.51,84.53 24.78,84.53 25.74,83.56 26.07,83.56 26.97,82.66 33.65,82.66 35.38,80.94 37.8,80.94 38.18,81.32 38.18,81.39 38.59,81.8 39,81.8 v1(39.4,81.39)
PCH_GPIO55: length 11
  TOP w0.102: v1(37.67,91.9) 37.37,91.9 UH1.AL6
  BOTTOM w0.102: RH76.1 40.47,83.37 40.47,85.5 39.63,86.35 39.52,86.35 39.23,86.64 39.23,87.08 v2(38.53,87.77) 38.27,88.03 38.27,88.26 37.67,88.86 v1(37.67,91.9)
PCH_GPIO69: length 14.8
  TOP w0.102: UH1.D13 25.5,95.03 25.21,94.75 24.95,94.75 24.76,94.93 24.37,94.93 23.91,94.47 23.55,94.47 v1(23.16,94.87)
  BOTTOM w0.102: RPH9.6 14.4,98.33 15.9,96.84 v2(17.52,96.84) 19.21,96.84 19.46,96.59 19.46,95.85 20,95.31 22.72,95.31 v1(23.16,94.87)
PCH_GPIO71: length 16.6
  TOP w0.102: UH1.H15 27.76,95.78 v1(27.4,95.42)
  IN3 w0.127: v1(27.4,95.42) 27.4,95.5 27.06,95.84 26.58,95.84 26.17,96.25 19.9,96.25 19.29,96.86 18.63,96.86 18.25,96.48 15.5,96.48 15.35,96.33 14.72,96.33 v1(14.64,96.25)
  BOTTOM w0.089: v2(28.38,94.92) 27.96,94.92 27.46,95.42 v1(27.4,95.42)
  BOTTOM w0.102: RPH8.5 13.97,96.06 14.16,96.25 v1(14.64,96.25)
PCH_INTVRMEN: length 10.9
  TOP w0.102: v1(27.59,93.42) 27.59,93.43 27.16,93.86 UH1.G10
  BOTTOM w0.102: v1(27.59,93.42) 27.2,93.81 25.64,93.81 25.46,93.99 v2(25.35,93.99) 20.28,93.99 19.74,94.52 RH5.2
PCH_JTAG_RST: length 35.6
  TOP w0.102: v1(17.9,112.57) 18.83,113.5 RH32.2 ; v1(33.15,91.9) 33.34,91.72 UH1.AB6
  IN4 w0.109: v1(33.15,91.9) 32.65,91.4 28.02,91.4 27.75,91.68 27.75,92.19 26.98,92.95 26.6,92.95 26.3,93.25 26.3,96 25.61,96.68 25.56,96.68 24.23,98.02 22.59,98.02 20.49,100.11 19.79,100.11 17.39,102.51 17.39,111.8 17.9,112.3 v1(17.9,112.57)
  BOTTOM w0.102: v4(18.04,113.23) 17.9,113.09 v1(17.9,112.57)
PCH_JTAG_RST_R: length 2.6
  TOP w0.102: JXDP2.54 19.3,115.98 18.83,115.5 RH32.1
PCH_JTAG_TCK: length 61.3
  TOP w0.102: v1(31.78,85.68) RH47.1 32.32,85.61 32.32,85.85 33.51,87.04 33.51,89.32 33.84,89.66 33.84,89.91 33.54,90.22 UH1.AB3 ; v1(15.38,113.88) 15.17,114.08 14.11,114.08 13.01,115.17 13.01,115.63 14.16,116.77 14.16,118.06 17.54,121.45 18.04,121.45 18.3,121.71 JXDP2.57
  IN4 w0.109: v1(31.78,85.68) 31.28,86.19 29.3,86.19 28.6,86.9 25.83,86.9 24.61,88.11 24.3,88.11 22.96,89.45 22.96,91.99 22.5,92.45 22.37,92.45 19.86,94.96 18.27,94.96 17.66,95.57 17.66,96.4 14.47,99.6 14.47,100.88 13.48,101.86 13.48,107.37 14.03,107.92 14.03,110.31 14.99,111.28 14.99,113.5 v1(15.38,113.88)
  BOTTOM w0.102: v1(15.38,113.88) v4(15.96,113.88)
PCH_JTAG_TDI: length 72.3
  TOP w0.102: v1(17.92,119.44) 18.03,119.44 18.8,118.67 JXDP2.56 ; v1(35.85,82.33) 35.29,82.33 RH50.2 35.16,83.37 35.16,84.62 RH55.1 34.99,85.36 34.99,87.79 34.73,88.05 34.73,89.44 34.65,89.52 34.65,90.16 UH1.AE2
  IN4 w0.109: v1(35.85,82.33) 35.37,82.81 35.37,83.6 34.33,84.64 31.57,84.64 31.33,84.87 25.85,84.87 25.43,85.29 24.82,85.29 24.55,85.55 21.64,85.55 18.3,88.89 18.3,89.4 16.63,91.07 16.63,92.25 16.01,92.88 15.16,92.88 14.77,92.49 13.71,92.49 12.61,93.59 12.61,100.47 11.89,101.2 11.89,103.13 11.08,103.94 11.08,107.23 12.44,108.58 12.44,111.13 12.88,111.58 12.88,111.94 13.24,112.29 13.24,113.36 14.7,114.82 14.7,115.21 16.39,116.9 16.39,118.55 17.28,119.44 v1(17.92,119.44)
  BOTTOM w0.102: v4(18.55,119.28) 18.39,119.44 v1(17.92,119.44)
PCH_JTAG_TDO: length 81.6
  TOP w0.102: JXDP2.52 19.8,115.97 19.31,115.48 19.31,113.37 18.02,112.08 14.81,112.08 14.1,112.79 13.11,112.79 11.33,111.01 9.1,111.01 v1(8.57,111.54) ; UH1.AD3 34.35,90.22 34.04,89.91 34.04,89.34 33.92,89.22 33.92,86.52 33.23,85.84 33.23,85.51 RH56.1 32.34,84.62 32.34,83.25 RH52.2 33.14,82.45 33.14,81.7 32.86,81.42 32.32,81.42 v1(31.71,80.81)
  IN4 w0.109: v1(31.71,80.81) 31.28,80.38 21.19,80.38 20.12,81.45 19.2,81.45 17.79,82.86 13.15,82.86 6.16,89.84 6.16,90.42 7.3,91.55 7.3,110.27 v1(8.57,111.54)
  BOTTOM w0.102: v4(8.07,110.88) 8.57,111.38 v1(8.57,111.54)
PCH_JTAG_TMS: length 82.2
  TOP w0.102: v1(33.89,80.81) 33.33,81.37 33.33,82.43 RH48.2 33.36,83.37 33.36,84.62 RH54.1 34.32,85.58 34.32,89.76 UH1.AD1 ; JXDP2.58 18.3,113.58 17.64,112.91 16.26,112.91 15.82,112.48 14.98,112.48 14.27,113.19 12.94,113.19 11.16,111.42 9.28,111.42 v1(8.57,112.13)
  IN4 w0.109: v1(8.57,112.13) 8.52,112.13 6.89,110.5 6.89,91.72 5.75,90.59 5.75,88.96 12.26,82.45 17.62,82.45 19.03,81.04 19.85,81.04 20.92,79.96 33.05,79.96 v1(33.89,80.81)
  BOTTOM w0.102: v1(8.57,112.13) 8.59,112.13 v4(9.01,112.55)
PCH_PCIE_RCOMP: length 6.6
  TOP w0.254: v1(47.66,101.43) 47.66,101.51 47.3,101.86 44.2,101.86 43.9,101.56 42.85,101.56 UH1.BD29
  BOTTOM w0.102: v2(47.34,101.9) 47.66,101.59 v1(47.66,101.43)
  BOTTOM w0.254: RH192.2 47.84,101.26 v1(47.66,101.43)
PCH_PCIE_WAKE#: length 178.7
  TOP w0.102: v1(20.74,83.55) 20.53,83.35 20.53,81.57 21.42,80.68 23.55,80.68 23.8,80.92 23.8,81.25 23.5,81.54 23.46,81.54 23.33,81.67 23.33,82.46 RH78.2 ; v1(96.99,158.79) 96.83,158.79 v2(93.5,162.12) 92.34,163.28 v1(92.34,167.02) ; RH78.2 24.21,83.35 24.21,85.41 24.47,85.66 25.07,85.66 26.75,87.34 27.61,87.34 28.81,88.54 28.81,89.44 28.97,89.6 28.97,89.91 28.75,90.13 28.75,90.6 UH1.K3 ; RH78.2 24.67,82.03 RH129.2
  IN2 w0.127: v1(20.74,83.55) 19.39,84.9 19.39,85.84 17.28,87.95 17.28,88.43 17.51,88.66 17.51,89.68 16.4,90.79 15.5,90.79 13.57,92.72 13.57,94.89 12.99,95.47 12.99,100.66 12.28,101.37 12.28,108.05 12.71,108.48 12.71,109.71 14.36,111.36 14.36,113.51 15.6,114.76 15.84,114.76 17.36,116.27 17.36,118.22 15.93,119.64 15.93,125.15 17.57,126.78 21.08,126.78 27.69,133.39 27.69,134.26 33.83,140.39 33.83,143.06 35.6,144.83 36.62,144.83 37.27,145.48 39.02,145.48 41.87,148.32 41.87,148.92 46.68,153.73 49.3,153.73 49.98,154.42 49.98,155.21 50.74,155.97 52.21,155.97 53.08,156.83 54.97,156.83 56.82,158.68 61.53,158.68 68.39,165.54 69.98,165.54 72.34,167.9 87.66,167.9 89.21,166.36 91.6,166.36 92.26,167.02 v1(92.34,167.02)
  BOTTOM w0.102: v1(96.99,158.79) 97.34,158.43 97.93,158.43 98.08,158.27 U51.A44
PCH_PLTRST#: length 384.6
  TOP w0.102: v1(32.22,93.84) 32.4,93.84 UH1.Y11 ; v1(57.9,17.16) 57.9,10.02 56.05,8.17 JUSH1.15 ; QH2.2 48.85,81.49 v1(48.22,80.86) 48.22,78.95 v1(48.68,78.5) ; v1(15.49,105.63) 15.71,105.85 16.87,105.85 v1(18.83,107.81) 18.83,108.28 18.41,108.7 14.64,108.7 14.33,109 14.33,109.43 13.97,109.8 JIO1.6 ; v1(49.72,113.37) 50.78,113.37 51.27,113.85 53.43,113.85 70.32,130.74 70.32,131.83 74.69,136.21 82.44,136.21 83.3,137.06 85.24,137.06 87.88,134.42 87.88,134.07 89.09,132.87 v1(89.09,132.13)
  IN1 w0.109: v1(18.83,107.81) 18.83,108.16 22.26,111.59 24.17,111.59 24.51,111.93 26.13,111.93 26.56,112.36 44.26,112.36 45.27,113.37 v1(49.72,113.37) 49.72,112.53 49.6,112.42 47.05,112.42 46.36,111.73 46.36,111.08 47,110.44 48.27,110.44 48.72,110.89 50.45,110.89 51.74,109.6 51.74,108.35 53.59,106.5 53.59,104.37 55.76,102.19 55.76,98.26 56.23,97.79 56.23,97.43 58.33,95.33 60.19,95.33 61.02,94.5 61.02,92.97 v1(64.75,89.24) ; v1(32.22,93.84) 32.72,93.34 32.72,89.29 36.6,85.42 37.51,85.42 38,84.94 43.05,84.94 44.33,83.65 44.33,82.87 46.34,80.86 v1(48.22,80.86)
  IN3 w0.127: v1(9.76,99.6) 9.76,99.58 9.31,99.13 9.31,97.58 7.23,95.5 7.23,92.49 8.95,90.76 9.48,90.76 9.8,90.44 11.3,90.44 12.64,91.78 15.2,91.78 15.58,91.4 16.47,91.4 17.41,92.34 22.56,92.34 24.95,89.95 28.63,89.95 30.16,91.48 31.15,91.48 31.76,92.09 31.76,93.38 v1(32.22,93.84)
  IN4 w0.109: v1(57.9,17.16) 57.9,17.69 58.9,18.69 61.08,18.69 66.07,23.68 66.07,29.43 57.26,38.24 57.26,51.93 56.38,52.82 56.38,77.26 55.35,78.29 52.31,78.29 51.67,78.93 49.11,78.93 v1(48.68,78.5)
  BOTTOM w0.089: 120.14,147.81 120.14,147.53 119.01,146.4
  BOTTOM w0.102: v1(64.75,89.24) 69.36,89.24 75.9,95.78 75.9,98.68 82.11,104.89 82.53,104.89 82.97,104.46 U16.2 ; v1(48.68,78.5) 48.68,77.82 v2(48.66,77.81) ; v1(9.76,99.6) 10.3,100.14 10.3,102.53 10.68,102.91 10.68,106.26 11.66,107.25 12.68,107.25 13.27,106.66 13.27,106.28 13.6,105.95 14.49,105.95 14.81,105.63 v1(15.49,105.63) 14.83,106.28 14.79,106.28 13.12,107.96 UH3.2 13.12,108.72 12.96,108.88 12.73,108.88 12.47,108.61 UH3.1 ; U31.36 120.14,147.81 ; 119.01,146.4 119.01,144.45 119.62,143.84 119.62,137.96 118.61,136.95 112.16,136.95 109.86,134.66 109.86,133.92 107.43,131.48 89.73,131.48 v1(89.09,132.13)
PCH_PLTRST#_EC: length 402.5
  TOP w0.102: v1(106.89,144.28) 106.89,144.53 105.59,145.83 102.52,145.83 101.3,144.61 100.85,144.61 100.67,144.79 100.67,146.29 103.07,148.69 103.07,149.62 102.79,149.9 102.79,151.69 v1(101.84,152.64) ; v1(11.77,109.48) 11.95,109.48 12.23,109.2 JIO1.8 ; v1(50.58,114.18) 50.66,114.26 53.26,114.26 69.13,130.13 69.13,131.22 74.52,136.61 82.23,136.61 83.08,137.46 85.41,137.46 89.12,133.75 v1(89.12,133.46) ; v1(214.03,79.18) 213.95,79.18 211.49,76.72 211.49,74.36 211.97,73.87 212.73,73.87 213.47,73.14 213.47,72.55 214.28,71.74 216.27,71.74 219.02,69 227.01,69 227.31,69.3 241.44,69.3 242.3,70.17 v1(243.11,70.17)
  IN1 w0.109: v1(214.03,79.18) 214.08,79.23 214.69,79.23 215.32,79.87 215.32,83.6 214.63,84.3 212.48,84.3 211.8,84.98 209.84,84.98 208.78,86.04 205.75,86.04 204.69,84.98 202.48,84.98 196.58,90.87 196.58,91.35 192.75,95.19 192.75,96.04 190.86,97.93 185.02,97.93 176.34,106.6 175.75,106.6 171.81,110.54 171.5,110.54 v1(170.85,111.19) 170.72,111.31 170.72,112.38 171.34,113 171.34,119.33 169.25,121.42 169.25,126.99 166.65,129.59 166.65,131.13 165.58,132.19 158.8,132.19 154.14,136.85 154.14,137.68 148.78,143.04 148.78,147.83 v1(147.1,149.52)
  IN2 w0.127: v1(170.85,111.19) 170.47,111.57 166.99,111.57 165.58,112.98 v1(164.44,112.98) ; v1(106.89,144.28) 106.89,140.49 108.13,139.25 108.13,138.94 v1(108.17,138.9)
  IN3 w0.127: v1(50.58,114.18) 50.2,114.56 48.87,114.56 48.51,114.21 44.92,114.21 44.61,114.51 42.86,114.51 41.49,113.14 32.47,113.14 31.92,113.69 31.67,113.69 29.42,115.94 27.42,115.94 26.58,115.1 24.6,115.1 24.44,115.25 19.39,115.25 15.2,111.06 14.74,111.06 13.17,109.48 v1(11.77,109.48)
  IN4 w0.109: v1(147.1,149.52) 138.79,149.52 133.03,155.28 133.03,155.32 132.25,156.1 131.33,156.1 131.01,155.78 125.5,155.78 125.34,155.94 124.85,155.94 124.6,156.19 117.64,156.19 117.18,155.73 113.46,155.73 113.09,155.36 112.46,155.36 110.25,153.14 109.81,153.14 108.98,152.31 108.98,146.37 v1(106.89,144.28)
  BOTTOM w0.102: JMINI4.17 137.54,148.14 139.54,150.14 JMINI4.22 146.47,150.14 v1(147.1,149.52) ; v1(101.84,152.64) 101.75,152.55 U51.B30 ; UH3.4 13.77,106.74 12.67,107.83 12.07,107.83 11.36,108.54 11.36,109.08 v1(11.77,109.48) ; v1(243.11,70.17) 243.44,70.17 244.76,71.49 244.76,74.11 246.67,76.02 246.67,77.13 247.56,78.01 249.82,78.01 250.83,77 JMINI2.22 ; v1(108.17,138.9) 108.75,138.33 108.75,133.38 107.31,131.94 89.89,131.94 89.12,132.7 v1(89.12,133.46) 88.25,133.46 v2(87.46,132.67) ; JMINI3.22 106.15,143.99 106.45,144.28 v1(106.89,144.28) ; v1(214.03,79.18) 213.94,79.27 U46.B22 ; v1(164.44,112.98) 164.58,112.84 164.58,111.08 164.24,110.75 U39.16
PCH_PWRBTN#_XDP: length 5.5
  TOP w0.102: v1(23.3,125.49) 22.3,124.49 JXDP2.41
  BOTTOM w0.102: v1(23.3,125.49) v2(22.61,124.79) 22.01,124.19 RH28.2
PCH_PWRGD#: length 81.1
  TOP w0.102: R410.1 162.87,134.15 162.14,133.41 159.62,133.41 157.87,135.16 157.87,135.5 156.68,136.7 152.01,136.7 151.8,136.48 v2(150.45,136.48) 149.64,136.48 v1(149.39,136.23) ; v1(94.75,149.97) 95.59,149.97 R893.2 Q52.1
  IN3 w0.127: v1(94.75,149.97) 95.91,148.82 96.47,148.82 97.86,147.42 98.37,147.42 100.35,145.44 101.25,145.44 102.13,144.56 103.45,144.56 103.84,144.96 108.59,144.96 108.87,144.68 113.69,144.68 113.96,144.94 119.92,144.94 121.43,143.43 131.73,143.43 133.56,145.26 135.96,145.26 144.99,136.23 v1(149.39,136.23)
PCH_RI#: length 7
  TOP w0.102: UH1.N4 29.88,90.65 30.17,90.36 30.17,90.11 29.98,89.92 29.98,89.49 29.78,89.29 29.78,88.53 v1(30.18,88.12)
  BOTTOM w0.102: v1(30.18,88.12) 30.18,87.97 v2(29.14,86.93) 28.86,86.65 RH84.2
PCH_RSMRST#: length 70.3
  TOP w0.102: R892.2 95.97,160.08 96.78,159.27 v2(98.23,159.27) 98.54,159.27 99.53,158.28 99.75,158.28 100.08,157.95 100.47,157.95 v1(100.87,158.35) ; v1(142.92,140.31) 142.92,140.64 143.13,140.84 143.54,140.84 143.69,140.68 U7.1
  IN1 w0.109: v1(142.92,140.31) 142.92,141.11 136.03,148 130.63,148 128.12,150.52 128.12,151.84 126.78,153.18 120.28,153.18 116.5,156.96 116.5,160.74 114.96,162.28 112.07,162.28 111.01,163.34 106.2,163.34 105.64,163.9 103.45,163.9 103.07,163.52 103.07,162.02 103.17,161.92 103.17,159.34 101.93,158.1 101.1,158.1 100.87,158.33 v1(100.87,158.35)
  BOTTOM w0.102: U51.B47 99.38,158.52 99.96,157.95 100.54,157.95 100.87,158.28 v1(100.87,158.35)
PCH_RSMRST#_Q: length 285
  TOP w0.102: U7.4 146.19,142.43 146.63,141.98 147.62,141.98 147.8,141.81 147.8,138.35 146.93,137.49 142.87,137.49 140.49,135.11 v1(140.49,134.87) ; UH1.J2 28.15,90.16 28.15,89.65 28.12,89.62 28.12,89.11 v1(27.72,88.71)
  IN1 w0.109: v1(154.28,100.08) 153.75,100.08 145.3,108.53 145.3,115.58 145.71,115.99 145.71,127.99 140.49,133.21 v1(140.49,134.87)
  IN2 w0.127: v1(116.63,101.31) 115.6,102.33 109.78,102.33 108.89,101.45 91.77,101.45 91.62,101.6 81.9,101.6 79.8,99.5 77.05,99.5 76.48,98.93 74.96,98.93 70.87,94.85 70.87,94.07 66.5,89.7 64.58,89.7 63.79,88.91 v1(63.76,88.91)
  IN3 w0.127: v1(116.63,101.31) 117.88,102.55 120.66,102.55 121.45,103.34 121.45,103.72 122.15,104.43 129.29,104.43 131.42,106.56 144.32,106.56 148.72,102.17 152.19,102.17 v1(154.28,100.08) ; v1(22.54,81.14) 22.54,80.94 23.34,80.13 27.88,80.13 28.69,79.32 31.71,79.32 32.78,80.39 34.95,80.39 35.39,79.94 38.27,79.94 38.63,80.3 45.26,80.3 47.16,82.21 51.61,82.21 56.29,86.89 56.41,86.89 59.27,89.75 62.29,89.75 63.13,88.91 v1(63.76,88.91)
  IN4 w0.109: v1(20.68,125.46) 21.12,125.89 21.12,126.48 20.61,126.99 17.81,126.99 15.67,124.85 15.67,121.32 12.6,118.25 12.6,117.11 8.98,113.49 8.98,111.36 7.54,109.91 7.54,89.42 13.61,83.34 17.97,83.34 19.38,81.94 21.74,81.94 v1(22.54,81.14)
  BOTTOM w0.102: v1(22.54,81.14) 22.54,81.24 22.77,81.47 RH142.2 23.29,82.52 23.29,83.78 RH79.2 24.17,84.66 24.17,85.91 v4(25.51,87.26) 26.08,87.83 26.84,87.83 v1(27.72,88.71) ; v1(20.68,125.46) 20.28,125.05 20.28,124.39 RH26.1
PCH_RTCRST#: length 197.2
  TOP w0.102: UH1.D9 25.5,93.41 25.21,93.12 24.95,93.12 24.76,93.3 24.49,93.3 24.34,93.15 24.04,93.15 23.68,92.8 22.97,92.8 22.61,93.15 20.4,93.15 CH7.2 19.36,93.08 17.31,93.08 RH44.2 16.85,91.34 16.43,90.92 15.7,90.92 v1(15.17,90.39) ; v1(84.59,23.52) 85.12,23.52 86.81,25.21 86.81,27.04 86.48,27.37 JAPS1.9
  IN1 w0.109: v1(15.17,90.39) 14.98,90.39 13.85,89.27 13.85,88.38 15.27,86.95 17,86.95 18.89,85.07 18.89,84.2 19.97,83.12 21.59,83.12 22.39,82.32 24.58,82.32 24.77,82.13 26.01,82.13 26.37,81.77 28.4,81.77 29.77,80.4 33.06,80.4 35.16,78.29 35.16,67.47 37.36,65.27 37.36,55.92 39.68,53.6 39.68,51.45 36.15,47.93 36.15,34.5 39.68,30.98 39.68,27.98 42.84,24.82 42.84,18.82 44.42,17.24 44.42,10.56 49.87,5.12 51.85,5.12 53.37,6.64 72.3,6.64 74.93,9.27 74.93,10.44 76.37,11.89 v1(76.72,11.89) 76.72,12.23 78.32,13.83 78.32,14.23 84.59,20.51 v1(84.59,23.52)
  BOTTOM w0.102: v1(84.59,23.52) v4(84.59,24.31) ; v1(76.72,11.89) 76.68,11.92 76.68,18.4 77.29,19.01 77.29,21.03 76.25,22.07 72.93,22.07 72.02,22.98 68.66,22.98 68.41,23.24 CMOS1.2
PCH_RTCX1: length 7.1
  TOP w0.102: UH1.B5 25.32,91.74 v1(25.64,91.43)
  BOTTOM w0.102: v1(25.64,91.43) 24.96,91.43 v2(24.85,91.31) 23.76,90.22 RH39.1 CH4.2 22.86,91.08 22.4,90.63 21.74,90.63 21.51,90.85 21.51,91.63 YH1.1
PCH_RTCX2: length 8
  TOP w0.102: UH1.B4 25.33,91.1 v1(25.64,90.79)
  BOTTOM w0.102: v1(25.64,90.79) 25.56,90.79 v2(24.61,89.84) 23.45,88.68 23.33,88.68 CH5.2 23.07,89.1 RH39.2 22.46,90.12 21.74,90.12 21.5,89.88 YH1.2
PCH_SATA_MOD_EN#: length 141.1
  TOP w0.102: QH2.3 46.92,81.65 47.68,80.88 47.68,78.9 49.11,77.48 53.63,77.48 55.04,78.9 59.2,78.9 59.22,78.88 62.77,78.88 68.41,84.52 68.41,87.67 74.62,93.87 83.03,93.87 83.96,92.95 83.96,89.05 86.97,86.04 v1(89.62,86.04)
  IN1 w0.109: v1(100.67,153.86) 100.24,154.29 99.7,154.29 98.19,152.78 98.19,150.01 94.67,146.49 94.67,145.71 96.18,144.2 96.18,138.21 95.61,137.64 95.61,128.88 95.16,128.43 95.16,126.41 93.98,125.23 93.98,124.32 94.78,123.53 94.78,118.15 95.02,117.9 95.02,112.3 93.49,110.76 93.49,110.3 93.84,109.95 93.84,107.63 92.79,106.59 92.79,97.52 91.12,95.84 91.12,93.13 89.62,91.63 v1(89.62,86.04)
  BOTTOM w0.102: U51.B36 99.93,153.02 100.67,153.76 v1(100.67,153.86) ; v1(89.62,86.04) v4(88.95,86.04)
PCH_SATA_MOD_G_EN#: length 120.8
  TOP w0.102: RH229.1 45.44,85.18 46.12,84.49 46.12,83.87 46.22,83.77 46.22,83.39 v1(45.75,82.92) ; RH229.1 45.51,85.32 47.43,85.32 47.89,84.86 QH2.1 ; RH229.1 44.5,86.18 v2(44.32,86.18) 42.62,86.18 39.54,89.26 39.54,90.16 UH1.AU2 ; v1(37.91,119.75) 37.45,119.29 RH13.1
  IN3 w0.127: v1(37.91,119.75) 37.42,120.23 33.54,120.23 31.03,122.74 25.72,122.74 25.08,122.1 18.06,122.1 10.45,114.49 8.3,114.49 7.2,113.39 7.2,97.98 5.44,96.23 5.44,91.74 8.25,88.94 8.25,88.3 13.7,82.84 34.65,82.84 35.58,81.91 36.17,81.91 36.51,82.26 45.09,82.26 v1(45.75,82.92)
PCH_SMB_ALERT#: length 9.8
  TOP w0.102: v1(29.16,91.98) 29.39,91.98 UH1.N7
  BOTTOM w0.102: RH166.2 25.56,86.15 26.29,86.89 27.06,86.89 28.53,88.36 28.53,89.93 v2(28.83,90.23) 29.45,90.84 29.45,91.35 29.16,91.63 v1(29.16,91.98)
PCH_SPI_CLK: length 25.4
  TOP w0.102: UH1.AJ11 36.5,93.8 v1(36.79,93.8) ; v1(50.45,85.66) 50.78,85.33 RH181.2 51.73,85.97 v2(52.04,85.97) JSPI1.8
  IN1 w0.109: v1(36.79,93.8) 37.22,94.23 37.22,94.65 37.47,94.91 37.8,94.91 38.13,94.57 38.13,94.3 38.52,93.91 41.51,93.91 43.74,91.69 43.74,91.06 44.74,90.05 45.43,90.05 48.24,87.25 49.43,87.25 50.01,86.68 50.82,86.68 50.95,86.55 50.95,85.94 50.82,85.81 50.58,85.81 50.45,85.68 v1(50.45,85.66)
PCH_SPI_CS0#: length 36.1
  TOP w0.102: UH1.AJ7 36.28,92.31 v1(36.69,91.9) ; JSPI1.10 54.01,86.97 53.88,87.11 53.63,87.11 53.47,86.95 53.18,86.95 53.07,87.06 53.07,87.26 52.94,87.39 52.71,87.39 52.59,87.26 52.59,87.06 52.46,86.94 52.23,86.94 52.1,87.06 52.1,87.26 51.98,87.39 51.77,87.39 51.65,87.26 51.65,87.06 51.52,86.94 51.26,86.94 RH182.2 51.09,87.41 50.96,87.54 50.71,87.54 50.58,87.41 50.58,86.93 50.45,86.8 50.25,86.8 50.12,86.93 50.12,87.41 50,87.54 49.84,87.54 49.72,87.67 49.72,87.82 50.08,88.18 50.08,88.4 50.02,88.45 49.79,88.45 49.38,88.04 48.99,88.04 48.87,87.91 48.87,87.74 v2(49.22,87.39) 49.97,86.64 49.97,85.76 v1(49.87,85.66)
  IN1 w0.109: v1(36.69,91.9) 37.19,92.41 37.19,93.76 37.52,94.09 37.83,94.09 38.18,93.74 38.18,91.86 38.49,91.55 38.74,91.55 38.79,91.5 39.81,91.5 40.17,91.86 40.17,92.29 40.47,92.59 41.46,92.59 41.89,92.16 42.5,92.16 42.93,91.73 42.93,90.98 44.48,89.44 45.18,89.44 48.09,86.52 48.32,86.52 48.43,86.63 49.18,86.63 49.59,86.22 49.59,86.07 49.13,85.61 49.13,85.48 49.23,85.38 49.54,85.38 49.82,85.66 v1(49.87,85.66)
PCH_SPI_CS1#: length 27.4
  TOP w0.102: UH1.AL7 37.48,92.31 v1(37.67,92.5) ; JSPI1.2 54.02,82.97 52.61,81.56 52.61,80.81 52.99,80.43 RH177.2 53.17,80.91 v1(53.02,81.06)
  IN1 w0.109: v1(37.67,92.5) 37.25,92.08 37.25,91.76 37.5,91.5 37.65,91.5 38.79,90.36 42.02,90.36 43.31,89.07 45.03,89.07 46.51,87.59 46.51,87.39 47.2,86.7 47.2,86.7 48.88,85.02 50.4,85.02 53.02,82.4 v1(53.02,81.06)
PCH_SPI_DIN: length 27.8
  TOP w0.102: 35.98,90.69 35.98,90.68 35.89,90.59 35.89,90.13 35.67,89.91 35.67,89.63 35.77,89.52 35.77,89.11 v1(36.04,88.85) ; JSPI1.6 53.9,84.97 53.62,84.69 v2(53.26,84.69) 53.13,84.69 51.92,83.49 RH179.2 50.57,83.49 50.45,83.37 v1(49.72,83.37)
  IN1 w0.109: v1(49.72,83.37) 51.01,82.08 51.01,81.9 50.78,81.67 50.6,81.67 49.11,83.16 48.42,83.16 45.05,86.54 41.9,86.54 40.38,88.06 38.04,88.06 37.25,88.85 v1(36.04,88.85)
PCH_SPI_DO: length 24.5
  TOP w0.102: v1(50.45,81.14) 50.49,81.14 RH178.2 51.61,82.26 51.94,82.26 v2(52.85,83.17) 53.65,83.97 JSPI1.4 ; v1(36.13,88.26) 36.43,88.57 36.43,89.07 36.05,89.45 36.05,89.71 35.98,89.78
  IN1 w0.109: v1(50.45,81.14) 49.84,81.75 49.32,81.75 44.9,86.17 41.75,86.17 40.23,87.69 37.89,87.69 37.32,88.26 v1(36.13,88.26)
PCH_SPI_DO2: length 23.8
  TOP w0.102: UH1.AJ4 36.38,90.65 36.67,90.36 36.67,90.11 36.48,89.92 36.48,89.91 36.48,89.91 36.48,89.63 36.93,89.18 36.93,87.96 v1(37.09,87.79) ; JSPI1.12 53.96,87.97 53.81,88.12 51.78,88.12 51.47,88.43 51.47,88.5 RH183.2 50.4,88.89 50.33,88.81 49.56,88.81 v1(49.26,88.5)
  IN3 w0.127: v1(49.26,88.5) 49.26,88.3 48.66,87.7 46.89,87.7 45.25,86.07 42.86,86.07 41.03,87.89 37.19,87.89 v1(37.09,87.79)
PCH_SPI_DO3: length 24.9
  TOP w0.102: JSPI1.14 52.78,88.97 v2(52.1,89.65) RH184.2 50.38,89.95 v1(50.38,89.34) ; v1(36.51,87.77) 36.74,88 36.74,89.04 36.28,89.49 36.28,90.16 UH1.AJ2
  IN3 w0.127: v1(50.38,89.34) 50.38,89.29 50,88.91 49.51,88.91 49.49,88.94 47.58,88.94 45.09,86.45 43.02,86.45 41.07,88.4 37.11,88.4 36.51,87.81 v1(36.51,87.77)
PCH_TD_IREF: length 9.8
  TOP w0.102: v2(48.99,110.58) 48.51,110.09 47.41,110.09 RH176.1 42.23,109.51 41.49,108.77 41.44,108.77 41.21,108.54 41.21,108.27 40.85,107.91 UH1.AY43
PCH_THRMTRIP#_R: length 9.8
  TOP w0.102: 40.04,89.78 40.13,89.78 40.45,89.47 40.45,88.68 42.61,86.51 45.54,86.51 v2(45.86,86.19) 46.9,86.19 CH17.1 RH206.2
PCH_TPM_EN: length 159.8
  TOP w0.102: UH1.BB4 41.74,91.37 v1(41.74,91.67)
  IN2 w0.127: v1(41.74,91.67) 41.74,91.69 45.16,95.11 49.87,95.11 52.94,98.18 53.22,98.18 54.39,99.35 54.39,101.36 55.17,102.14 60.36,102.14 61.68,100.82 64.72,100.82 71.65,107.74 80.21,107.74 81.15,108.68 81.92,108.68 82.22,108.38 116.29,108.38 117.25,109.33 119.04,109.33 119.76,108.61 126.4,108.61 126.92,109.13 129.34,109.13 130.04,108.43 156.9,108.43 157.88,109.41 162.7,109.41 164.09,110.81 v1(164.09,111.22)
  IN3 w0.127: v1(159.41,119.63) 159.7,119.63 161.76,117.57 161.76,113.46 163.99,111.22 v1(164.09,111.22)
  BOTTOM w0.102: v1(41.74,91.67) 40.5,91.67 39.92,91.09 39.92,89.74 39.68,89.49 39.68,89.11 39.88,88.91 41.26,88.91 42.07,88.1 45.37,88.1 RH209.1 45.84,86.82 v2(45.75,86.73) RH208.1 ; v1(159.41,119.63) 159.52,119.75 R2189.1
PCI_5048: length 5.1
  TOP w0.102: v1(26.3,107.43) 25.95,107.78 UH1.D44
  BOTTOM w0.102: v1(26.3,107.43) 25.89,107.02 25.5,107.02 25.43,107.08 25.4,107.08 25.15,107.33 v2(24.9,107.33) 24.37,107.33 22.72,108.98 RH158.1
PCI_DOCK: length 4.3
  TOP w0.102: UH1.B42 25.29,107.02 v1(25.74,106.56)
  BOTTOM w0.102: RH162.1 v2(23.61,107.22) 23.94,106.89 25.33,106.89 25.66,106.56 v1(25.74,106.56)
PCI_LOOPBACKOUT: length 26.3
  TOP w0.102: UH1.A40 24.5,106.16 24.01,106.16 23.81,106.36 23.81,107.2 23.68,107.33 22.82,107.33 22.69,107.45 22.69,107.68 22.82,107.81 23.61,107.81 23.73,107.94 23.73,108.16 23.61,108.29 22.82,108.29 22.69,108.42 22.69,108.65 22.82,108.77 23.61,108.77 23.73,108.9 23.73,109.13 23.61,109.26 22.82,109.26 22.69,109.38 22.69,109.56 22.56,109.69 22.34,109.69 22.21,109.56 22.21,107.88 22.08,107.76 21.47,107.76 21.34,107.88 v2(21.34,108.43) 21.34,109.79 21.22,109.92 18.96,109.92 18.83,109.79 18.83,109.56 18.96,109.43 20.74,109.43 20.86,109.31 20.86,108.27 20.74,108.14 20.63,108.14 20.51,108.01 20.51,107.22 20.25,106.97 20.25,106.41 20.13,106.28 19.97,106.28 19.82,106.44 19.31,106.44 19.21,106.54 19.21,106.64 19.95,107.38 19.95,108.81 20.07,108.94 RH164.1
PCI_MEC: length 8.2
  TOP w0.102: UH1.E44 26.67,107.94 26.67,108.55 26.48,108.75 25.49,108.75 22.95,111.29 22.18,111.29 21.62,111.85 RH160.1 v2(20.65,111.97)
PCI_PIRQA#: length 17.1
  TOP w0.102: v1(27.4,97.32) 27.76,97.68 UH1.H20
  BOTTOM w0.102: RPH1.3 14.98,100.62 15.84,101.48 18.52,101.48 18.88,101.12 18.88,100.68 20.29,99.27 21.57,99.27 22.67,98.17 24.49,98.17 24.65,98.02 24.71,98.02 v2(24.96,97.76) 25.62,97.76 26.01,98.16 26.57,98.16 v1(27.4,97.32)
PCI_PIRQB#: length 18
  TOP w0.102: UH1.L20 28.95,97.57 v1(28.7,97.32)
  BOTTOM w0.102: v1(28.7,97.32) 28.3,97.72 27.27,97.72 26.65,98.35 24.61,98.35 24.56,98.4 22.77,98.4 21.67,99.5 20.38,99.5 19.11,100.78 19.11,101.22 18.61,101.71 15.64,101.71 15.16,101.23 v2(15.11,101.23) 14.76,101.23 14.65,101.12 RPH1.2
PCI_PIRQC#: length 18.1
  TOP w0.102: v1(28.05,96.24) 28.05,96.53 UH1.K17
  BOTTOM w0.102: v1(28.05,96.24) 28.05,96.38 v2(27.73,96.7) 27.58,96.85 25.41,96.85 24.32,97.94 22.58,97.94 21.48,99.05 20.19,99.05 18.65,100.59 18.65,101.03 18.42,101.26 15.93,101.26 14.8,100.12 RPH1.4
PCI_PIRQD#: length 18.6
  TOP w0.102: v1(29.24,98.38) 29.55,98.08 UH1.M20
  BOTTOM w0.102: RPH1.1 15.18,101.62 15.49,101.94 18.71,101.94 19.34,101.31 19.34,100.87 20.23,99.99 v2(21.01,99.99) 21.51,99.99 22.27,99.22 23.35,99.22 23.95,98.63 24.8,98.63 24.89,98.54 26.73,98.54 27.29,97.98 28.36,97.98 28.76,98.38 v1(29.24,98.38)
PCI_TPM_TCM: length 8.6
  TOP w0.102: UH1.C40 25.1,106 24.75,106.36 24.49,106.36 24.29,106.56 24.29,107.68 24.21,107.76 24.21,109.34 23.36,110.2 21.9,110.2 21.7,110.4 v2(21.37,110.4) RH155.2
PCIE_PRX_EXPTX_N7: length 45.6
  TOP w0.102: v1(39.65,105.96) 39.65,105.96 UH1.AT40 ; JIO1.35 8.69,100.8 8.87,100.62 9,100.62 v1(9.18,100.8)
  IN3 w0.089: v1(39.65,105.96) 39.47,105.78 39.27,105.78 39.2,105.85 39.2,106.67 39.43,106.89 39.43,107.08 39.46,107.12 39.46,107.13
  IN3 w0.127: v1(9.18,100.8) 9.34,100.64 9.96,100.64 11.01,101.68 11.01,106.54 11.41,106.94 14.66,106.94 14.97,107.24 15.3,107.24 17.84,109.78 21.95,109.78 23.48,111.31 31.38,111.31 32.5,110.19 34.91,110.19 35.74,111.03 37.99,111.03 39.02,109.99 39.02,108.49 39.46,108.05 39.46,107.13
PCIE_PRX_EXPTX_P7: length 45.7
  TOP w0.102: v1(39.65,105.31) 39.14,105.82 UH1.AT39 ; JIO1.37 8.68,100.2 8.89,100.4 8.99,100.4 v1(9.18,100.21)
  IN3 w0.089: 39.22,107.13 39.22,107.11 39.25,107.07 39.25,106.97 39.02,106.74 39.02,105.78 39.2,105.6 39.48,105.6 39.65,105.43 v1(39.65,105.31)
  IN3 w0.127: v1(9.18,100.21) 9.36,100.39 10.07,100.39 11.26,101.58 11.26,106.44 11.51,106.69 14.77,106.69 15.07,107 15.4,107 17.94,109.54 22.05,109.54 23.58,111.06 31.27,111.06 32.4,109.94 35.01,109.94 35.85,110.78 37.89,110.78 38.77,109.89 38.77,108.39 39.22,107.95 39.22,107.13
PCIE_PRX_GLANTX_N2: length 111.8
  TOP w0.102: 39.53,102.33 39.53,102.52 v1(39.19,102.86)
  IN4 w0.117: v1(115.33,148.87) 116.02,148.87 116.48,148.41 116.48,143.45 115.22,142.19 115.22,135.79 113.59,134.16 109.14,134.16 106.41,131.43 103.53,131.43 103.04,130.94 100.61,130.94 100.55,131 97.43,131 92.92,126.49 92.92,121.47 89.28,117.83 87.22,117.83 86.53,117.14 85.27,117.14 83.45,118.96 72.85,118.96 71.03,117.14 67.16,117.14 66.53,117.77 59.32,117.77 52.79,111.24 52.22,111.24 48.76,107.78 48.5,107.78 46.62,105.9 46.62,105.46 45.76,104.6 42.14,104.6 41.82,104.28 39.74,104.28 39.16,103.7 39.16,102.9 v1(39.19,102.86)
  BOTTOM w0.102: C459.2 116.29,148.99 115.97,148.67 115.53,148.67 v1(115.33,148.87)
PCIE_PRX_GLANTX_N2_C: length 2.9
  BOTTOM w0.102: C459.1 117.53,148.68 117.71,148.68 117.8,148.77 117.8,149.07 v3(118.12,149.39) 118.3,149.57 118.78,149.57 118.85,149.64 U31.39
PCIE_PRX_GLANTX_P2: length 111.7
  TOP w0.102: UH1.AR31 38.93,102.52 v1(38.59,102.86)
  IN4 w0.117: v1(115.33,148.29) 115.33,148.29 115.68,148.64 115.92,148.64 116.24,148.31 116.24,143.55 114.98,142.29 114.98,135.89 113.49,134.4 109.05,134.4 106.32,131.67 103.43,131.67 102.94,131.18 100.71,131.18 100.65,131.23 97.33,131.23 92.69,126.59 92.69,121.57 89.18,118.07 87.13,118.07 86.43,117.37 85.37,117.37 83.55,119.2 72.75,119.2 70.93,117.37 67.26,117.37 66.63,118 59.22,118 52.69,111.47 52.12,111.47 48.67,108.02 48.4,108.02 46.38,106 46.38,105.56 45.66,104.84 42.04,104.84 41.72,104.51 39.64,104.51 38.92,103.79 38.92,103.14 38.64,102.86 38.6,102.86 v1(38.59,102.86)
  BOTTOM w0.102: v1(115.33,148.29) 115.49,148.45 115.95,148.45 C458.2
PCIE_PRX_GLANTX_P2_C: length 2.9
  BOTTOM w0.102: C458.1 117.55,148.46 117.8,148.46 118.02,148.68 118.02,148.96 118.41,149.35 118.77,149.35 118.88,149.24 U31.38
PCIE_PRX_MMITX_N8: length 36
  TOP w0.102: v1(38.64,105.7) 38.58,105.7 UH1.AN38 ; v1(11.77,105.62) 11.59,105.8 8.87,105.8 8.67,105.6 JIO1.19
  IN3 w0.089: 38.05,106.61 38.05,106.59 38.08,106.56 38.08,106.13 38.29,105.93 38.54,105.93 38.64,105.83 v1(38.64,105.7)
  IN3 w0.127: v1(11.77,105.62) 11.93,105.78 14.93,105.78 15.38,106.23 16.14,106.23 18.68,108.77 22.59,108.77 24.12,110.3 30.92,110.3 32.57,108.65 36.31,108.65 38.05,106.9 38.05,106.61
PCIE_PRX_MMITX_P8: length 36
  TOP w0.102: v1(38.65,106.29) 38.24,105.88 UH1.AN39 ; v1(11.77,106.21) 11.58,106.02 8.86,106.02 8.68,106.2 JIO1.17
  IN3 w0.089: 38.3,106.61 38.3,106.6 38.26,106.57 38.26,106.21 38.36,106.11 38.47,106.11 v1(38.65,106.29)
  IN3 w0.127: v1(11.77,106.21) 11.95,106.03 14.82,106.03 15.28,106.48 16.03,106.48 18.57,109.02 22.49,109.02 24.02,110.55 31.02,110.55 32.68,108.9 36.41,108.9 38.3,107.01 38.3,106.61
PCIE_PRX_WLANTX_N3: length 136.9
  TOP w0.102: v1(40.82,103.81) 40.73,103.81 40.87,103.67 40.87,103.45 UH1.AW33
  IN4 w0.089: 42.42,103.21 42.41,103.21 42.38,103.24 41.22,103.24 41.02,103.44 41.02,103.62 40.82,103.81 v1(40.82,103.81)
  IN4 w0.117: 42.42,103.21 43.07,103.21 43.65,102.63 47.3,102.63 49.77,105.09 49.77,105.61 52.24,108.09 54.49,108.09 56.17,109.76 56.17,111.49 60.23,115.56 65.57,115.56 67.58,113.54 70.83,113.54 71.24,113.13 72.92,113.13 73.97,114.18 77.45,114.18 78.24,113.38 82.27,113.38 82.86,113.98 84.01,113.98 84.32,113.67 89.16,113.67 90.36,114.87 116.37,114.87 124.82,123.33 124.82,126.27 128.79,130.24 132.44,130.24 137.93,135.72 137.93,139.86 137.35,140.44 137.35,145.93 134.13,149.15 134.13,150.67 134.26,150.8 134.48,150.8 v1(134.65,150.63)
  BOTTOM w0.102: v1(134.65,150.63) 134.84,150.82 135.01,150.82 135.29,150.54 JMINI4.23
PCIE_PRX_WLANTX_P3: length 136.7
  TOP w0.102: v1(41.49,103.81) 41.49,103.83 41.32,103.66 UH1.AY33
  IN4 w0.089: 42.42,103.44 42.41,103.44 42.38,103.41 41.3,103.41 41.19,103.52 41.19,103.76 41.28,103.85 41.46,103.85 v1(41.49,103.81)
  IN4 w0.117: v1(134.65,151.24) 134.65,151.14 134.55,151.04 134.16,151.04 133.89,150.77 133.89,149.05 137.12,145.83 137.12,140.34 137.69,139.77 137.69,135.82 132.35,130.47 128.69,130.47 124.59,126.37 124.59,123.43 116.27,115.11 90.26,115.11 89.06,113.9 84.42,113.9 84.1,114.22 82.77,114.22 82.17,113.62 78.34,113.62 77.55,114.41 73.87,114.41 72.83,113.36 71.34,113.36 70.93,113.78 67.68,113.78 65.66,115.79 60.13,115.79 55.93,111.59 55.93,109.86 54.39,108.32 52.15,108.32 49.53,105.71 49.53,105.19 47.21,102.86 43.74,102.86 43.16,103.44 42.42,103.44
  BOTTOM w0.102: v1(134.65,151.24) 134.86,151.04 135.01,151.04 135.31,151.34 JMINI4.25
PCIE_PRX_WPANTX_N6: length 84.1
  TOP w0.102: v1(40.99,105.78) 41.32,105.45 UH1.AY38
  IN4 w0.117: v1(105.65,133.01) 105.47,133.18 105.47,133.54 105.09,133.92 104.53,133.92 102.56,131.95 101.08,131.95 100.95,132.07 97.13,132.07 95.21,130.16 94.59,130.16 93.63,129.2 93.63,128.79 91.46,126.61 87.43,126.61 85.81,128.23 83.34,128.23 83.03,127.92 83.03,127.72 82.31,126.99 72.95,126.99 72.14,127.81 67.17,127.81 64.92,125.56 64.92,124.75 52.41,112.24 51.73,112.24 50.35,110.86 49.18,110.86 47.83,109.51 47.83,108.48 45.64,106.3 45.64,105.87 45.34,105.57 41.72,105.57 41.41,105.27 40.9,105.27 40.79,105.38 40.79,105.57 v1(40.99,105.78)
  BOTTOM w0.102: v1(105.65,133.01) 105.48,133.17 105.48,133.4 105.75,133.67 JMINI3.23
PCIE_PRX_WPANTX_P6: length 84.2
  TOP w0.102: v1(40.34,105.78) 40.72,105.4 UH1.AW38
  IN4 w0.117: v1(105.06,133.01) 105.23,133.18 105.23,133.44 104.99,133.68 104.62,133.68 102.66,131.71 100.98,131.71 100.86,131.84 97.23,131.84 95.31,129.92 94.69,129.92 93.87,129.1 93.87,128.69 91.55,126.38 87.33,126.38 85.72,127.99 83.44,127.99 83.27,127.82 83.27,127.62 82.41,126.76 72.86,126.76 72.04,127.57 67.27,127.57 65.16,125.46 65.16,124.65 52.51,112 51.83,112 50.45,110.62 49.28,110.62 48.07,109.41 48.07,108.39 45.88,106.2 45.88,105.78 45.44,105.34 41.81,105.34 41.51,105.03 40.8,105.03 40.55,105.29 40.55,105.57 v1(40.34,105.78)
  BOTTOM w0.102: JMINI3.25 104.95,133.73 105.27,133.41 105.27,133.21 v1(105.06,133.01)
PCIE_PTX_EXPRX_N7: length 50.8
  TOP w0.102: UH1.BE40 43.26,105.91 43.34,105.83 43.54,105.83 43.62,105.9 43.62,106.26 43.93,106.56 44.37,106.56 44.72,106.91 44.91,106.91 45.09,107.09 v1(45.09,107.28) ; JIO1.29 8.73,102.6 8.92,102.41 9.04,102.41 v1(9.31,102.68)
  IN3 w0.127: v1(9.31,102.68) 9.46,102.52 9.76,102.52 10.25,103.01 10.25,106.87 11.08,107.7 13.21,107.7 14.18,108.67 15.01,108.67 16.92,110.57 18.27,110.57 18.99,111.29 22.01,111.29 22.8,112.08 31.71,112.08 32.83,110.95 34.53,110.95 35.44,111.87 39.61,111.87 39.81,111.67 43.14,111.67 44.89,109.92 44.89,107.48 v1(45.09,107.28)
PCIE_PTX_EXPRX_P7: length 50.7
  TOP w0.102: v1(44.44,107.31) 44.44,106.94 44.28,106.78 43.84,106.78 43.42,106.36 43.1,106.36 42.74,106 UH1.BC40 ; v1(9.31,101.94) 9.05,102.19 8.92,102.19 8.73,102 JIO1.31
  IN3 w0.127: v1(9.31,101.94) 9.31,102.14 9.43,102.27 9.86,102.27 10.5,102.91 10.5,106.77 11.18,107.45 13.31,107.45 14.28,108.42 15.12,108.42 17.02,110.32 18.37,110.32 19.09,111.04 22.11,111.04 22.9,111.83 31.6,111.83 32.73,110.7 34.63,110.7 35.54,111.62 39.51,111.62 39.71,111.42 43.04,111.42 44.64,109.81 44.64,109.42 44.53,109.31 44.53,108.88 44.64,108.77 44.64,108.39 44.53,108.28 44.53,107.85 44.64,107.74 44.64,107.51 v1(44.44,107.31)
PCIE_PTX_GLANRX_N2: length 111.7
  TOP w0.076: UH1.BD33 42.86,103.08 42.93,103.08 43.09,103.24 43.41,103.24 43.5,103.34 43.5,103.37 43.52,103.39
  TOP w0.102: 43.52,103.39 43.93,103.8 44.69,103.8 45.01,103.48 v1(45.01,103.37)
  IN4 w0.117: v1(45.01,103.37) 44.9,103.48 44.9,103.69 45.06,103.85 46.14,103.85 47.35,105.07 47.35,105.6 48.8,107.05 49.07,107.05 52.47,110.45 53.05,110.45 59.63,117.03 66.18,117.03 66.82,116.38 71.33,116.38 73.15,118.2 83.14,118.2 85.61,115.73 87.31,115.73 88.63,117.05 89.7,117.05 93.79,121.15 93.79,123.46 94.15,123.81 94.15,126.67 97.73,130.25 99.88,130.25 99.99,130.14 103.34,130.14 103.89,130.69 106.72,130.69 109.44,133.41 113.88,133.41 116.42,135.96 116.42,138.82 117.97,140.36 117.97,143.8 117.97,143.81 117.97,149.16 116.35,150.79 v1(115.65,150.79)
  BOTTOM w0.102: C461.1 115.98,150.6 115.84,150.6 v1(115.65,150.79)
PCIE_PTX_GLANRX_N2_C: length 2.4
  BOTTOM w0.102: U31.42 118.83,150.84 118.74,150.75 v3(118.17,150.75) 117.84,150.75 117.66,150.57 117.55,150.57 C461.2
PCIE_PTX_GLANRX_P2: length 111.6
  TOP w0.076: UH1.BB33 42.37,103.16 42.68,102.84 42.93,102.84 43.16,103.08 43.48,103.08 43.62,103.22 43.66,103.22 43.67,103.23
  TOP w0.102: v1(44.35,103.37) 43.81,103.37 43.67,103.23
  IN4 w0.117: v1(115.65,150.2) 115.65,150.2 116,150.55 116.26,150.55 117.74,149.07 117.74,143.91 117.73,143.9 117.73,140.46 116.19,138.91 116.19,136.05 113.78,133.65 109.34,133.65 106.62,130.93 103.8,130.93 103.24,130.38 100.08,130.38 99.98,130.49 97.63,130.49 93.91,126.77 93.91,123.91 93.56,123.56 93.56,121.25 89.6,117.29 88.53,117.29 87.21,115.97 85.7,115.97 83.24,118.43 73.05,118.43 71.23,116.62 66.92,116.62 66.27,117.26 59.53,117.26 52.95,110.69 52.37,110.69 48.97,107.28 48.7,107.28 47.12,105.7 47.12,105.16 46.04,104.08 44.96,104.08 44.67,103.79 44.67,103.61 44.43,103.37 v1(44.35,103.37)
  BOTTOM w0.102: v1(115.65,150.2) 115.84,150.39 115.93,150.39 C460.1
PCIE_PTX_GLANRX_P2_C: length 2.4
  BOTTOM w0.102: U31.41 118.85,150.44 118.75,150.53 118.49,150.53 118.47,150.52 117.92,150.52 117.75,150.35 117.53,150.35 C460.2
PCIE_PTX_MMIRX_N8: length 50
  TOP w0.102: v1(42.27,107.39) 42.57,107.09 UH1.BD42 ; JIO1.13 8.67,107.4 8.85,107.58 9.1,107.58 9.2,107.48 9.51,107.48 v1(9.81,107.17)
  IN3 w0.127: v1(9.81,107.17) 9.81,107.45 9.91,107.55 10.17,107.55 10.24,107.63 10.24,108.07 10.35,108.17 10.81,108.17 10.85,108.21 12.98,108.21 14.39,109.62 14.92,109.62 17.1,111.8 21.38,111.8 22.16,112.59 31.93,112.59 32.14,112.38 41.69,112.38 41.87,112.21 43.36,112.21 46.19,109.38 46.19,106.92 46.03,106.76 45.72,106.76 45.61,106.87 45.18,106.87 45.07,106.76 44.2,106.76 44.09,106.87 43.72,106.87 43.62,106.76 43.28,106.76 42.84,107.2 42.46,107.2 v1(42.27,107.39)
PCIE_PTX_MMIRX_P8: length 50
  TOP w0.102: JIO1.11 8.66,108 8.86,107.8 9.19,107.8 9.29,107.69 9.52,107.69 v1(9.81,107.99) ; UH1.BD41 42.41,106.74 v1(42.26,106.74)
  IN3 w0.127: v1(42.26,106.74) 42.47,106.95 42.74,106.95 43.18,106.51 46.14,106.51 46.44,106.82 46.44,109.48 43.47,112.46 41.97,112.46 41.8,112.63 32.25,112.63 32.04,112.84 22.06,112.84 21.27,112.05 17,112.05 14.82,109.87 14.28,109.87 12.88,108.46 10.75,108.46 10.71,108.42 10.24,108.42 v1(9.81,107.99)
PCIE_PTX_WLANRX_N3: length 134.5
  TOP w0.102: UH1.BE34 43.26,103.62 44.16,104.52 47.9,104.52 48.02,104.63 48.57,104.63 48.7,104.76 48.7,104.89 v1(48.54,105.05)
  IN4 w0.117: v1(48.54,105.05) 48.46,105.05 48.2,105.31 48.2,105.41 49.1,106.31 49.37,106.31 52.74,109.68 53.31,109.68 59.93,116.29 65.87,116.29 66.53,115.64 71.63,115.64 72.34,116.34 81.04,116.34 81.64,116.95 82.5,116.95 84.98,114.48 87.89,114.48 89.01,115.61 116.06,115.61 122.18,121.73 122.18,124.7 128.46,130.97 131.63,130.97 136.32,135.67 136.32,145.84 131.66,150.51 131.66,152.3 131.05,152.91 131.05,154.08 131.16,154.19 131.27,154.19 131.62,153.85 v1(131.63,153.85)
  BOTTOM w0.102: v1(131.63,153.85) 131.82,154.03 132.3,154.03 132.63,153.71 C596.1
PCIE_PTX_WLANRX_N3_C: length 2.7
  BOTTOM w0.102: JMINI4.31 135.25,153.74 134.96,154.04 133.92,154.04 C596.2
PCIE_PTX_WLANRX_P3: length 134.6
  TOP w0.102: UH1.BC34 42.81,103.57 43.09,103.85 43.1,103.84 43.13,103.87 43.21,103.87 44.07,104.73 47.81,104.73 47.88,104.8 v1(47.88,105.05)
  IN4 w0.117: v1(47.88,105.05) 47.96,105.14 47.96,105.5 49.01,106.55 49.28,106.55 52.64,109.91 53.22,109.91 59.83,116.53 65.97,116.53 66.62,115.87 71.53,115.87 72.24,116.58 80.94,116.58 81.55,117.19 82.6,117.19 85.07,114.72 87.79,114.72 88.91,115.84 115.96,115.84 121.95,121.83 121.95,124.8 128.36,131.21 131.53,131.21 136.09,135.76 136.09,145.74 131.42,150.41 131.42,152.2 130.81,152.81 130.81,154.18 131.06,154.43 v1(131.63,154.43)
  BOTTOM w0.102: v1(131.63,154.43) 131.82,154.25 132.31,154.25 132.66,154.6 C598.1
PCIE_PTX_WLANRX_P3_C: length 2.7
  BOTTOM w0.102: JMINI4.33 135.23,154.54 134.95,154.25 133.93,154.25 C598.2
PCIE_PTX_WPANRX_N6: length 78.6
  TOP w0.102: C636.1 102.28,133.83 102.28,133.43 v1(102.47,133.25) ; v1(44,106.08) 44.19,105.89 44.19,105.69 44.01,105.51 43.14,105.51 42.82,105.19 UH1.BC38
  IN4 w0.117: v1(44,106.08) 44.15,106.23 44.15,106.65 43.76,107.04 43.76,107.77 46.38,110.39 47.32,110.39 48.58,111.65 49.69,111.65 51.55,113.51 52.6,113.51 62.29,123.2 62.29,124.04 67.22,128.97 86.14,128.97 87.74,127.37 91.17,127.37 92.89,129.09 92.89,129.74 95.07,131.91 95.85,131.91 96.75,132.81 100.41,132.81 100.9,133.3 100.9,133.94 101.19,134.23 102.05,134.23 102.47,133.81 v1(102.47,133.25)
PCIE_PTX_WPANRX_N6_C: length 2.7
  TOP w0.102: C636.2 102.29,135.49 102.29,135.87 v1(102.45,136.03)
  BOTTOM w0.102: JMINI3.31 102.55,135.44 102.27,135.72 102.27,135.85 v1(102.45,136.03)
PCIE_PTX_WPANRX_P6: length 78.6
  TOP w0.102: UH1.BE38 43.24,105.19 43.11,105.07 43.11,104.87 43.24,104.75 43.44,104.75 43.57,104.87 43.57,105.17 43.7,105.29 44.1,105.29 44.41,105.6 44.41,105.85 v1(44.64,106.08) ; v1(101.78,133.25) 102.07,133.54 102.07,133.91 C626.1
  IN4 w0.117: v1(101.78,133.25) 102.01,133.25 102.05,133.3 102.05,133.47 102.23,133.65 102.23,133.71 101.95,134 101.29,134 101.14,133.84 101.14,133.2 100.51,132.57 96.85,132.57 95.95,131.68 95.16,131.68 93.13,129.64 93.13,128.99 91.27,127.13 87.64,127.13 86.04,128.73 67.32,128.73 62.53,123.94 62.53,123.1 52.7,113.27 51.64,113.27 49.78,111.42 48.68,111.42 47.42,110.16 46.48,110.16 44,107.68 44,107.14 44.39,106.75 44.39,106.23 44.53,106.08 v1(44.64,106.08)
PCIE_PTX_WPANRX_P6_C: length 2.7
  TOP w0.102: C626.2 102.08,135.44 102.08,135.81 v1(101.86,136.03)
  BOTTOM w0.102: v1(101.86,136.03) 102.05,135.84 102.05,135.74 101.75,135.43 JMINI3.33
PCIE_SATA_PRX_WANTX_N4: length 193.9
  TOP w0.076: UH1.BD13 42.8,94.88 42.86,94.83 43.04,94.83 43.16,94.96 43.5,94.96 43.53,94.93 43.54,94.93
  TOP w0.102: v1(49.46,95.82) 49.41,95.82 49.23,95.64 49.23,95.34 48.74,94.84 v3(48.05,94.84) 47.04,94.84 46.95,94.93 43.54,94.93
  IN4 w0.117: v1(49.46,95.82) 49.26,95.62 49.26,95.44 49.38,95.32 49.87,95.32 50.01,95.46 50.01,96.09 52.18,98.26 54.42,98.26 55.91,99.76 56.73,99.76 57.11,99.38 58.63,99.38 58.76,99.5 59.98,99.5 60.75,100.27 68.31,100.27 68.97,100.93 72.86,100.93 73.28,101.35 82.41,101.35 82.68,101.08 107.19,101.08 108.79,99.48 119.41,99.48 119.72,99.17 122.36,99.17 122.6,98.93 132.71,98.93 133.59,98.05 138.95,98.05 139.35,97.66 175.49,97.66 181.16,91.99 181.16,88.18 186.73,82.61 193.89,82.61 199.1,77.4 199.1,76.63 208.77,66.97 212.07,66.97 212.33,66.71 212.33,65.97 212.12,65.76 211.81,65.76 v1(211.62,65.57)
  BOTTOM w0.102: C534.1 212.09,65.78 211.83,65.78 v1(211.62,65.57)
PCIE_SATA_PRX_WANTX_N4_C: length 2.2
  BOTTOM w0.102: U637.4 214.73,65.56 214.61,65.68 214.26,65.68 214.19,65.74 213.64,65.74 C534.2
PCIE_SATA_PRX_WANTX_P4: length 194
  TOP w0.076: 43.54,95.15 43.53,95.15 43.5,95.12 43.13,95.12 42.93,95.31 42.68,95.31 42.4,95.03 UH1.BB13
  TOP w0.102: 43.54,95.15 47.04,95.15 47.13,95.06 47.75,95.06 47.76,95.07 48.38,95.07 48.4,95.06 48.65,95.06 49.02,95.43 49.02,95.65 v1(48.85,95.82)
  IN4 w0.117: v1(48.85,95.82) 49.02,95.65 49.02,95.34 49.28,95.08 49.97,95.08 50.25,95.36 50.25,95.99 52.28,98.02 54.51,98.02 56.01,99.52 56.63,99.52 57.01,99.14 58.73,99.14 58.86,99.27 60.08,99.27 60.85,100.04 68.41,100.04 69.07,100.7 72.96,100.7 73.38,101.11 82.32,101.11 82.58,100.85 107.1,100.85 108.7,99.25 119.31,99.25 119.62,98.94 122.26,98.94 122.5,98.69 132.61,98.69 133.49,97.82 138.86,97.82 139.25,97.42 175.4,97.42 180.93,91.89 180.93,88.08 186.63,82.38 193.79,82.38 198.87,77.3 198.87,76.53 208.67,66.73 211.98,66.73 212.09,66.61 212.09,66.07 212.02,66 211.82,66 v1(211.62,66.2)
  BOTTOM w0.102: C533.1 212.09,65.99 211.83,65.99 v1(211.62,66.2)
PCIE_SATA_PRX_WANTX_P4_C: length 2.2
  BOTTOM w0.102: C533.2 213.66,66.01 214.3,66.01 214.37,65.94 214.69,65.94 214.81,66.06 U637.5
PCIE_SATA_PTX_WANRX_N4: length 194.4
  TOP w0.102: UH1.AV15 40.13,95.62 v1(40.46,95.29)
  IN4 w0.089: v1(40.46,95.29) 40.64,95.48 40.64,95.65 40.86,95.87 41.4,95.87 41.77,95.49 41.82,95.49 41.83,95.48
  IN4 w0.117: v1(211.62,64.43) 211.44,64.25 210.27,64.25 198.09,76.43 198.09,77.17 193.51,81.75 186.34,81.75 180.13,87.96 180.13,90.83 174.17,96.79 132.28,96.79 132.23,96.84 118.93,96.84 117.15,98.62 108.44,98.62 107.22,99.84 82.65,99.84 82.01,100.49 74.14,100.49 73.41,99.76 69.18,99.76 67.58,98.16 64.68,98.16 64.01,97.5 56.81,97.5 55.32,96 53.65,96 53.04,96.61 51.76,96.61 50.88,95.74 50.88,95.08 50.25,94.45 49.03,94.45 48.39,95.09 42.22,95.09 41.83,95.48
  BOTTOM w0.102: C513.1 212.09,64.22 211.83,64.22 v1(211.62,64.43)
PCIE_SATA_PTX_WANRX_N4_C: length 2.3
  BOTTOM w0.102: C513.2 213.65,64.24 214.06,64.24 214.26,64.44 214.62,64.44 214.73,64.56 U637.2
PCIE_SATA_PTX_WANRX_P4: length 194.4
  TOP w0.102: UH1.AW15 40.72,95.62 41.05,95.29 v1(41.06,95.29)
  IN4 w0.089: 41.66,95.31 41.65,95.33 41.65,95.37 41.32,95.69 40.94,95.69 40.82,95.58 40.82,95.39 40.92,95.29 v1(41.06,95.29)
  IN4 w0.117: v1(211.62,63.79) 211.62,63.91 211.51,64.01 210.17,64.01 197.85,76.33 197.85,77.07 193.41,81.51 186.24,81.51 179.89,87.87 179.89,90.74 174.07,96.56 132.19,96.56 132.14,96.61 118.83,96.61 117.05,98.38 108.34,98.38 107.12,99.6 82.55,99.6 81.91,100.25 74.24,100.25 73.51,99.53 69.27,99.53 67.67,97.93 64.78,97.93 64.11,97.26 56.9,97.26 55.41,95.77 53.55,95.77 52.94,96.38 51.85,96.38 51.11,95.64 51.11,94.98 50.35,94.21 48.93,94.21 48.29,94.85 42.12,94.85 41.66,95.31
  BOTTOM w0.102: v1(211.62,63.79) 211.83,64 212.09,64 C514.1
PCIE_SATA_PTX_WANRX_P4_C: length 2.3
  BOTTOM w0.102: U637.1 214.76,64.06 214.64,64.18 214.37,64.18 214.17,63.97 213.65,63.97 C514.2
PCIE_WAKE#: length 403
  TOP w0.102: v1(95.11,145.91) 95.16,145.96 v2(95.16,146.48) 95.16,147.58 98.15,150.58 98.15,152.13 99.25,153.22 R759.2 99.45,153.45 v1(99.86,153.86) ; JIO1.83 v1(6.52,86.4)
  IN1 w0.102: 123.96,128.57 v1(119.15,133.39)
  IN1 w0.109: 123.96,128.57 124.57,127.96 124.57,123.1 123.45,121.98 123.45,112.25 125.54,110.16 125.54,102.09 v1(125.76,101.86) 127.85,99.78 128.38,99.78 130.51,97.65 161.15,97.65 164.44,94.36 166.03,94.36 177.18,83.21 179.45,83.21 179.68,83.45 181.14,83.45 184.16,80.43 195.61,80.43 205.06,70.98 212.2,70.98 213.31,72.09 213.31,73.01 213.76,73.45 214.47,73.45 214.96,72.97 221.21,72.97 222.82,71.36 231.81,71.36 231.94,71.49 242.43,71.49 243.04,72.1 247.06,72.1 248.39,73.43 251.64,73.43 253.16,74.95 253.82,74.95 256.27,77.4 v1(258.25,77.4) ; v1(119.15,133.39) 120.19,134.43 130.88,134.43 131.8,135.34 v1(134.65,135.34)
  IN2 w0.127: v1(123.07,93.69) 122.87,93.89 117.94,93.89 117.58,94.26 113.52,94.26 113.48,94.3 92.64,94.3 91.73,93.38 89.45,93.38 88.13,92.06 88.13,91.17 80.72,83.75 69.56,83.75 67.32,81.52 58.12,81.52 56.72,80.12 52.17,80.12 51.62,79.58 47.1,79.58 46.88,79.36 39.38,79.36 38.77,78.75 34.63,78.75 33.79,79.59 29.38,79.59 29.15,79.36 25.65,79.36 25.02,78.73 17.4,78.73 16.77,78.09 13.32,78.09 7.02,84.39 7.02,85.91 6.53,86.4 v1(6.52,86.4)
  IN3 w0.127: v1(95.11,145.91) 95.11,145.78 102.17,138.72 105.32,138.72 109.76,134.28 118.26,134.28 v1(119.15,133.39)
  BOTTOM w0.102: v1(134.65,135.34) 134.65,138.28 134.92,138.54 JMINI4.1 ; U51.B38 99.69,154.02 v1(99.86,153.86) ; JMINI2.1 261.41,88.6 261.78,88.22 261.78,82.05 258.25,78.52 v1(258.25,77.4) ; v1(123.07,93.69) 123.07,96.99 124.88,98.79 125.18,98.79 126.22,99.83 126.22,100.62 R1972.2 v1(125.76,101.86) ; JMINI3.1 117.75,133.58 117.98,133.35 119.11,133.35 v1(119.15,133.39)
