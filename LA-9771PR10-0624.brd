# Allegro board LA-9771PR10-0624.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
D90  -  [RB751S40T1G_SOD523-2]  171.48 139.74 0 top
D91  -  [BAT1000-7-F_SOT23-3]  259.95 146.38 0 bottom
F3  -  [F_1206L150THWR]  261.66 153.87 180 bottom
FD1  -  [FIDUCIAL_C40M80]  272.87 147.64 180 bottom
FD2  -  [FIDUCIAL_C40M80]  75.85 2.96 180 bottom
FD3  -  [FIDUCIAL_C40M80]  272.87 147.64 0 top
FD4  -  [FIDUCIAL_C40M80]  75.85 2.96 0 top
H1  -  [H_3P2X6P2N]  11.95 158.81 0 top
H2  -  [H_2P8]  28.95 171.3 0 top
H3  -  [H_3P3]  47.82 162.8 0 top
H4  -  [H_2P3]  56.95 173.8 0 top
H5  -  [H_3P8]  56.72 165.93 0 top
H7  -  [H_3P8]  131.72 165.93 0 top
H8  -  [H_3P8]  162.75 125.93 0 top
H9  -  [H_2P8]  188.95 105 0 top
H10  -  [H_2P8]  264.95 100.3 0 top
H11  -  [H_2P8]  263.95 171.2 0 top
H12  -  [H_2P1X4P1N]  269.45 171.21 90 top
H13  -  [H_3P8]  77.61 88.8 0 top
H14  -  [H_3P8]  101.58 83.8 0 top
H15  -  [H_3P8]  74.46 31.8 0 top
H16  -  [H_3P8]  98.08 31.8 0 top
H17  -  [H_2P8]  39.15 23.3 0 top
H18  -  [H_3P2]  39.15 16.8 0 top
H19  -  [H_2P8]  102.45 20.8 0 top
H20  -  [H_2P3]  153.95 16.7 0 top
H21  -  [H_4P1]  191.5 89.07 0 top
H22  -  [H_4P1]  191.5 27.34 0 top
H23  -  [H_4P1]  268.1 89.07 0 top
H24  -  [H_4P1]  268.1 27.34 0 top
H25  -  [H_2P8]  262.95 17.2 0 top
JAPS1  -  [ACES_88512-01601-071_16P]  82.48 29.03 0 top
JCPU1  -  [FOX_PZ94726-362R-41H_947P-T]  106.59 40.28 90 top
JCRT1  -  [SUYIN_070449HR015M221ZR_15P]  72.01 173.56 0 top
JDEG2  -  [ACES_87152-10071_10P]  169.03 113.74 270 top
JDIMM1  -  [FOX_AS0A621-N2R6-7H_204P]  137.6 90.55 90 top
JDIMM2  -  [FOX_AS0A621-N2S6-7H_204P]  145.8 90.55 270 bottom
JDIMM3  -  [TYCO_2-2013311-1_204P]  151.2 90.56 90 top
JDIMM4  -  [FOX_AS0A621-N2R6-7H_204P]  159.4 90.56 90 bottom
JDOCK1  -  [JAE_WD2F144WB5R400_144P]  73.2 118.3 0 bottom
JDP1  -  [FOX_3V11211-NBYD7-7H_20P]  264.72 164.15 90 top
JEPWR1  -  [ACES_50228-0067N-001_6P]  34.45 134 180 top
JESA1  -  [TAIWI_EU093-117CRL-TW_11P]  45.8 170.52 180 top
JFAN1  -  [ACES_50271-0040N-001_4P]  13.52 131.02 90 bottom
JFAN2  -  [ACES_50271-0040N-001_4P]  174.65 141.55 270 bottom
JHDMI1  -  [CONCR_099AAAC19BBLCNF_19P]  13.06 168.24 180 top
JIO1  -  [FOX_QTSA1401-7011-9H_140P-T]  7.85 111 90 top
JKB1  -  [E-T_6900K-G10N-40R_10P]  179.91 109.5 270 top
JLOM1  -  [SANTA_130454-H_13P]  162.18 162.32 180 top
JLVDS1  -  [ACES_50398-04071-001_40P]  50.3 155.45 90 top
JMINI2  -  [LOTES_AAA-PCI-092-P01-A_52P]  260.5 88.6 270 bottom
JMINI3  -  [LOTES_AAA-PCI-092-P01-A_52P]  117.75 134.65 180 bottom
JMINI4  -  [LOTES_AAA-PCI-092-P01-A_52P]  136.04 138.54 90 bottom
JMXM1  -  [JAE_MM70-314-310B1-1-R300_310P]  134.25 105 180 top
JODD1  -  [OCTEK_SLS-13ADAB_13P]  36.25 50.58 270 top
JPB1  -  [ACES_50228-0067N-001_6P]  252.17 103.3 270 top
JRTC1  -  [ACES_50271-0020N-001_2P]  39.77 155.75 90 bottom
JSATA1  -  [OCTEK_SAT-22PDAB_22P]  171.45 47.1 90 top
JSIM1  -  [T-SOL_159-1000302602_10P-T]  241.38 33.28 180 bottom
JSPI1  -  [TYCO_2-2041070-0_20P-T]  54.65 82.47 270 top
JTAG1  -  [SHORTPADS]  104.05 169.84 0 bottom
JUSB1  -  [LOTES_AUSB0041-P002A_9P]  264.4 109.75 90 top
JUSB2  -  [LOTES_AUSB0041-P002A_9P]  264.4 131.55 90 top
JUSH1  -  [E-T_6712K-Y20N-07L_20P]  49.05 6.7 0 top
JWL1  -  [ACES_50228-0034N-001_3P]  229.49 19.41 180 top
JXDP1  -  [SAMTE_BSH-030-01-L-D-A_60P]  61.7 11.94 0 top
JXDP2  -  [SAMTE_BSH-030-01-L-D-A_60P]  32.3 122.79 180 top
L1  -  [MURAT_BLM15BB470SN1D_2P]  72.09 165.73 90 top
L2  -  [MURAT_BLM15BB470SN1D_2P]  74.2 165.76 90 top
L3  -  [MURAT_BLM15BB470SN1D_2P]  76.97 165.79 90 top
L4  -  [MURAT_BLM15AG121SN1D_L0402_2P]  84.83 163.99 180 top
L5  -  [MURAT_BLM15AG121SN1D_L0402_2P]  87.12 163.99 180 top
L10  -  [MURAT_DLW21HN900SQ2L_4P]  59.62 132.66 90 top
L19  -  [MURAT_DLW21SN900HQ2L-0805_4P]  20.14 162.86 90 top
L23  -  [MURAT_DLW21SN900HQ2L-0805_4P]  17.4 161.63 90 top
L24  -  [MURAT_DLW21SN900HQ2L-0805_4P]  15.44 161.59 90 top
L25  -  [MURAT_DLW21SN900HQ2L-0805_4P]  9.59 163.44 0 top
L29  -  [TAIYO_CBC2012T4R7M_2P]  122.59 156.26 90 top
L39  -  [MURAT_DLW21HN900SQ2L_4P]  259.04 109.33 180 bottom
L40  -  [MURAT_DLW21SN900HQ2L-0805_4P]  256.79 114.48 180 top
L41  -  [MURAT_DLW21HN900SQ2L_4P]  263.56 122.67 180 top
L42  -  [MURAT_DLW21SN900HQ2L-0805_4P]  256.73 112.7 180 top
L43  -  [MURAT_DLW21SN900HQ2L-0805_4P]  257.82 126.36 270 top
L44  -  [MURAT_DLW21SN900HQ2L-0805_4P]  259.73 126.36 270 top
L51  -  [MURAT_DLW21HN900SQ2L_4P]  29.97 164.73 0 top
L60  -  [KC_FBMA-L11-201209-221LMA30_2P]  71.09 140.88 180 top
L61  -  [KC_FBMA-L11-201209-221LMA30_2P]  85.76 147.42 90 bottom
L62  -  [CYNTE_PG031B-4R7MS_2P]  77.84 139.23 180 bottom
L63  -  [DELTA_0603CS-120EJTS_2P]  122.73 144.36 270 bottom
L64  -  [DELTA_0603CS-120EJTS_2P]  124.07 144.36 270 bottom
L65  -  [DELTA_0603CS-120EJTS_2P]  125.42 144.36 270 bottom
L66  -  [DELTA_0603CS-120EJTS_2P]  126.78 144.36 270 bottom
L67  -  [DELTA_0603CS-120EJTS_2P]  128.15 144.36 270 bottom
L68  -  [DELTA_0603CS-120EJTS_2P]  129.51 144.36 270 bottom
L69  -  [DELTA_0603CS-120EJTS_2P]  130.87 144.36 270 bottom
L70  -  [DELTA_0603CS-120EJTS_2P]  132.23 144.36 270 bottom
LH1  -  [MURAT_BLM18PG181SN1D_2P]  29.5 112.02 270 bottom
LH2  -  [MURAT_LQM18FN4R7M00D_2P]  45.37 113.34 270 top
ME1  -  [SHORTPADS]  17.28 92.37 0 bottom
NOREF  -  []  188.95 105 0 top
NOREF#2  -  []  202.09 45.59 0 top
NOREF#3  -  []  39.15 23.3 0 top
NOREF#4  -  []  212.06 41.88 0 top
NOREF#5  -  []  68.87 21.75 0 top
NOREF#6  -  []  74.46 31.8 0 top
NOREF#7  -  []  77.61 88.8 0 top
NOREF#8  -  []  56.95 173.8 0 top
NOREF#9  -  []  191.5 89.07 0 top
NOREF#10  -  []  264.95 100.3 90 top
NOREF#11  -  []  131.72 165.93 0 top
NOREF#12  -  []  268.1 89.07 90 top
NOREF#13  -  []  8.55 119.6 0 top
NOREF#14  -  []  101.58 83.8 0 top
NOREF#15  -  []  28.95 171.3 0 top
NOREF#16  -  []  102.45 20.8 0 top
NOREF#17  -  []  39.15 16.8 0 top
NOREF#18  -  []  191.5 27.34 0 top
NOREF#19  -  []  153.95 16.7 0 top
NOREF#20  -  []  263.95 171.2 0 top
NOREF#21  -  []  47.82 162.8 0 top
NOREF#22  -  []  56.72 165.93 0 top
NOREF#23  -  []  39.15 16.8 0 top
NOREF#24  -  []  94.95 172.3 0 top
NOREF#25  -  []  202.47 59.08 0 top
NOREF#26  -  []  268.1 27.34 0 top
NOREF#27  -  []  98.08 31.8 0 top
NOREF#28  -  []  14.19 216.7 0 top
NOREF#29  -  []  268.1 89.07 90 top
NOREF#30  -  []  162.75 125.93 0 top
NOREF#31  -  []  214.22 -14.89 0 top
NOREF#32  -  []  185.64 50.58 0 top
NOREF#33  -  []  262.95 17.2 0 top
NOREF#34  -  []  112.45 16.11 180 bottom
NOREF#35  -  []  124.94 30.14 90 bottom
NOREF#36  -  []  122.3 64.56 90 bottom
NOREF#37  -  []  114.33 79.03 90 bottom
PBATT1  -  [SUYIN_200045GR009M28QZR_9P]  160.45 16.9 0 top
PC1  -  [C_EEEFK1E101YP]  151.8 103.25 270 top
PC2  -  [C_0603]  44.48 157.2 270 bottom
PC4  -  [C_0402]  158.78 21.36 180 top
PC5  -  [C_0402]  173.19 30.26 0 bottom
PC7  -  [C_0603]  27.09 146.53 180 bottom
PC8  -  [C_0603]  29.24 141.26 90 bottom
PC9  -  [C_0603]  20.99 75.6 90 bottom
PC11  -  [C_0402]  14.89 86.52 90 bottom
PC14  -  [C_0805]  13.94 68.62 180 bottom
PC15  -  [C_0603]  22.51 78.65 90 bottom
PC16  -  [C_0402]  31.29 142.97 180 bottom
PC30  -  [C_0805]  147.7 101.89 180 top
PC31  -  [C_0603]  147.54 103.54 180 top
PC101  -  [C_APXK6R3ARA221MF451]  260.8 55.24 180 bottom
PC102  -  [C_APXK6R3ARA221MF451]  232.4 54.98 0 bottom
PC104  -  [C_0805]  244.64 47.57 90 bottom
PC105  -  [C_0402]  241.35 43.28 180 bottom
PC106  -  [C_0402]  241.35 44.3 180 bottom
PC107  -  [C_0402]  248.36 53.85 180 bottom
PC109  -  [C_0805]  246.41 47.57 90 bottom
PC110  -  [C_0805]  248.19 47.57 90 bottom
PC111  -  [C_0603]  242.1 59.6 0 bottom
PC112  -  [C_0603]  250.73 59.09 0 bottom
PC114  -  [C_0603]  247.04 64.03 270 bottom
PC116  -  [C_0603]  249.47 56.35 0 bottom
PC117  -  [C_0603]  247.05 56.17 270 bottom
PC118  -  [C_0603]  245.78 56.17 270 bottom
PC119  -  [C_0603]  243.1 56.31 180 bottom
PC120  -  [C_0603]  242.34 61.64 180 bottom
PC201  -  [C_APXK2R5ARA331MF451]  193.07 59.22 180 bottom
PC202  -  [C_0805]  179.31 66.7 90 bottom
PC203  -  [C_0805]  177.53 66.7 90 bottom
PC204  -  [C_0402]  175.29 67.09 90 bottom
PC205  -  [C_0402]  176.2 67.09 90 bottom
PC206  -  [C_0603]  179.23 73.63 270 bottom
PC207  -  [C_0805]  173.9 74.37 90 bottom
PC208  -  [C_0805]  172.12 74.37 90 bottom
PC209  -  [C_0402]  127.03 86.19 90 top
PC210  -  [C_0603]  182.6 78.97 0 bottom
PC211  -  [C_0402]  172.75 78.98 270 bottom
PC212  -  [C_0603]  188.76 74.39 90 bottom
PC213  -  [C_0603]  182.6 77.7 0 bottom
PC214  -  [C_0402]  172.7 77.13 180 bottom
PC215  -  [C_0402]  177.91 80.43 180 bottom
PC216  -  [C_0402]  164.23 78.19 270 bottom
PC217  -  [C_0402]  168.73 81.76 90 bottom
PC219  -  [C_0402]  168.79 78.22 90 bottom
PC220  -  [C_0402]  164.26 80.99 270 bottom
PC301  -  [C_APXK2R5ARA331MF451]  23.84 129.23 0 top
PC302  -  [C_0402]  18.41 136.64 180 bottom
PC303  -  [C_0402]  18.44 137.59 180 bottom
PC304  -  [C_0805]  20.46 140.87 0 bottom
PC305  -  [C_0805]  20.46 139.06 0 bottom
PC306  -  [C_0603]  21.31 142.53 180 bottom
PC307  -  [C_0402]  20.48 147.31 270 top
PC308  -  [C_0603]  22.13 144.12 90 top
PC309  -  [C_0402]  14.26 139.36 180 top
PC400  -  [C_0805]  262.5 30.77 180 bottom
PC402  -  [C_0402]  264.5 32.47 180 bottom
PC403  -  [C_0805]  252.98 36.1 180 bottom
PC404  -  [C_0805]  252.98 37.88 180 bottom
PC406  -  [C_0402]  260.56 35.72 0 bottom
PC407  -  [C_0402]  258.53 27.49 90 bottom
PC500  -  [C_0603]  39.99 69.43 0 bottom
PC501  -  [C_0603]  36.67 72.05 0 bottom
PC502  -  [C_0805]  41.6 75.35 0 bottom
PC503  -  [C_0805]  41.6 75.35 0 top
PC504  -  [C_0805]  42.49 60.72 0 bottom
PC507  -  [C_0603]  49.88 75.09 180 top
PC508  -  [C_0603]  51.09 26.39 90 bottom
PC509  -  [C_0402]  51.27 22.13 0 top
PC510  -  [C_0402]  53.12 20.23 180 top
PC511  -  [C_0603]  52.99 28.55 270 bottom
PC512  -  [C_0805]  44.52 45.88 0 bottom
PC513  -  [C_0805]  44.52 45.88 0 top
PC514  -  [C_0805]  44.53 47.66 0 bottom
PC515  -  [C_0402]  37.4 76.85 0 top
PC516  -  [C_0402]  37.4 77.73 0 top
PC519  -  [C_0603]  54.9 28.42 270 bottom
PC520  -  [C_0402]  63.23 22.64 180 top
PC521  -  [C_0603]  47.09 28.99 0 top
PC522  -  [C_0402]  58.2 28.31 270 bottom
PC523  -  [C_0603]  51.34 41.25 270 top
PC525  -  [C_0402]  58.28 21.75 180 top
PC526  -  [C_0402]  58.28 20.86 180 top
PC527  -  [C_0402]  61.25 21.8 90 top
PC528  -  [C_0402]  59.22 23.35 270 bottom
PC529  -  [C_EEEFK1E101YP]  27.3 76.9 180 top
PC530  -  [C_EEEFK1E101YP]  38.17 65.14 0 top
PC531  -  [C_EEEFK1E101YP]  27.22 69.76 180 top
PC532  -  [C_0603]  61.25 23.34 270 bottom
PC533  -  [C_0805]  42.41 62.47 0 bottom
PC534  -  [C_0805]  42.49 60.74 0 top
PC535  -  [C_0805]  44.52 47.79 0 top
PC538  -  [C_0603]  62.52 23.34 270 bottom
PC539  -  [C_0402]  58.21 26.45 180 bottom
PC540  -  [C_0603]  52.74 32.1 270 top
PC541  -  [C_0402]  58.2 25.49 180 bottom
PC542  -  [C_0402]  57.18 23.58 90 top
PC543  -  [C_0402]  58.21 24.55 180 bottom
PC544  -  [C_0402]  57.18 25.36 90 top
PC545  -  [C_0603]  48.45 60.12 90 top
PC546  -  [C_0402]  54.19 25.94 0 bottom
PC547  -  [C_0402]  55.1 24.93 180 bottom
PC700  -  [C_0603]  18.51 76.49 0 top
PC701  -  [C_0603]  31.77 71.4 0 bottom
PC702  -  [C_0402]  177.5 43.34 0 bottom
PC703  -  [C_0402]  178.39 44.23 0 bottom
PC704  -  [C_0402]  179.28 43.34 0 bottom
PC705  -  [C_0402]  185.12 44.77 90 bottom
PC706  -  [C_0603]  186.23 44.63 90 bottom
PC707  -  [C_0805]  187.77 45.02 90 bottom
PC708  -  [C_0805]  189.55 45.04 90 bottom
PC715  -  [C_0805]  209.55 44.11 90 bottom
PC717  -  [C_0402]  188.38 53.93 90 bottom
PC718  -  [C_0805]  211.43 40.37 270 bottom
PC719  -  [C_0805]  209.65 40.37 270 bottom
PC727  -  [C_0402]  217.07 58.28 90 bottom
PC728  -  [C_0402]  216.05 58.25 90 bottom
PC729  -  [C_0402]  225.84 54.82 90 bottom
PC730  -  [C_0402]  226.79 57.96 270 bottom
PC731  -  [C_0402]  217.21 54.29 270 bottom
PC732  -  [C_0402]  217.2 56.12 270 bottom
PC733  -  [C_0402]  229.52 62.57 90 bottom
PC734  -  [C_0603]  182.22 47.53 0 bottom
PC735  -  [C_0402]  231.76 62.77 180 bottom
PC736  -  [C_0402]  231.76 61.89 180 bottom
PC744  -  [C_0402]  173.31 48.42 0 bottom
PC745  -  [C_0603]  181.96 51.88 0 bottom
PC746  -  [C_0402]  113.17 152.8 0 bottom
PC783  -  [C_0402]  174.23 46.65 180 bottom
PC786  -  [C_0603]  175.64 54.14 90 bottom
PC791  -  [C_0603]  182.16 46.25 0 bottom
PC792  -  [C_0603]  178.21 55.47 180 bottom
PC900  -  [C_0805]  84.91 61.63 0 bottom
PC901  -  [C_0805]  84.91 59.73 0 bottom
PC902  -  [C_0805]  84.91 57.82 0 bottom
PC903  -  [C_0805]  84.91 63.54 0 bottom
PC904  -  [C_0805]  84.91 65.44 0 bottom
PC905  -  [C_D2]  68.89 67.57 180 bottom
PC907  -  [C_D2]  68.89 62.85 180 bottom
PC908  -  [C_D2]  89.57 66.61 270 bottom
PC909  -  [C_0805]  84.91 67.35 0 bottom
PC910  -  [C_0805]  84.91 55.92 0 bottom
PC911  -  [C_0805]  84.91 54.01 0 bottom
PC912  -  [C_0805]  84.91 52.11 0 bottom
PC913  -  [C_0805]  84.91 50.2 0 bottom
PC914  -  [C_0805]  84.91 48.3 0 bottom
PC916  -  [C_D2]  89.57 66.61 270 top
PC917  -  [C_0805]  84.91 61.63 0 top
PC918  -  [C_0805]  84.91 63.54 0 top
PC919  -  [C_0805]  84.91 65.44 0 top
PC920  -  [C_0805]  84.91 67.35 0 top
PC921  -  [C_0805]  84.91 54.01 0 top
PC922  -  [C_0805]  84.91 50.2 0 top
PC923  -  [C_0805]  84.91 48.3 0 top
PC924  -  [C_0805]  84.91 55.92 0 top
PC925  -  [C_0805]  84.91 57.82 0 top
PC926  -  [C_0805]  84.91 59.73 0 top
PC935  -  [C_0805]  58.64 58.96 180 bottom
PC936  -  [C_0805]  58.72 65.06 180 top
PC937  -  [C_0805]  58.62 58.99 180 top
PC938  -  [C_0805]  58.72 65.01 180 bottom
PC939  -  [C_0805]  84.91 52.11 0 top
PC940  -  [C_0805]  58.75 67.83 180 bottom
PC941  -  [C_0805]  58.72 67.85 180 top
PC942  -  [C_0805]  58.7 61.81 180 bottom
PC943  -  [C_0805]  58.67 61.81 180 top
PC1001  -  [C_0805]  225.5 52.49 0 bottom
PC1002  -  [C_0402]  176.64 37.12 180 bottom
PC1003  -  [C_0402]  176.64 36.1 180 bottom
PC1004  -  [C_0603]  186.09 30.58 270 bottom
PC1005  -  [C_0603]  178.41 28.09 0 bottom
PC1006  -  [C_0603]  154.4 114.83 270 bottom
PC1007  -  [C_0603]  153.18 114.84 270 bottom
PC1008  -  [C_0603]  146.72 118.15 180 bottom
PC1009  -  [C_0402]  146.41 119.29 180 bottom
PC1080  -  [C_0402]  153.5 147.1 0 bottom
PC1081  -  [C_0402]  150.96 154.6 0 bottom
PC1099  -  [C_0603]  216.57 44.55 90 bottom
PD1  -  [RB715FGT106_UMD3]  43.13 157.52 90 bottom
PD2  -  [TVNST52302AB0_SOT523-3]  199.21 23.82 270 bottom
PD3  -  [TVNST52302AB0_SOT523-3]  197.49 23.68 180 bottom
PD5  -  [SDMK0340L-7-F_SOD323-2]  176.44 28.43 90 bottom
PD8  -  [D_0603]  16.16 86.9 90 bottom
PD700  -  [SBR3A40SA-13_SMA2]  26.21 73.47 180 bottom
PD701  -  [BAT54CW_SOT323-3]  174.92 39.88 90 bottom
PD703  -  [SDMK0340L-7-F_SOD323-2]  184.24 50.35 180 bottom
PD1001  -  [PDS5100H-13_POWERDI5-3]  220.37 48.89 270 bottom
PD1002  -  [PDS5100H-13_POWERDI5-3]  179.69 35.83 270 bottom
PD1010  -  [BAT54CW_SOT323-3]  156.08 108.29 270 bottom
PD1099  -  [SDMK0340L-7-F_SOD323-2]  214.92 45.06 90 bottom
PD1100  -  [SDMK0340L-7-F_SOD323-2]  161.85 106.17 180 bottom
PH500  -  [R_0402]  41.51 56.55 180 top
PH501  -  [R_0402]  49.56 54.85 270 top
PJP1  -  [JUMP_43X79]  119.73 163.76 0 top
PJP2  -  [JUMP_43X79]  265.85 71.83 0 bottom
PJP3  -  [JUMP_43X39]  51.88 104.64 90 bottom
PJP4  -  [JUMP_43X39]  54.34 105.15 90 bottom
PJP5  -  [JUMP_43X79]  126.6 107.75 90 bottom
PJP6  -  [JUMP_43X79]  124.9 111.97 180 bottom
PJP7  -  [JUMP_43X79]  54.66 74.75 180 bottom
PJP8  -  [JUMP_43X79]  87.13 138.29 180 bottom
PJP9  -  [JUMP_43X79]  44.62 26.99 90 top
PJP29  -  [JUMP_43X39]  207.55 77.07 270 bottom
PJP33  -  [JUMP_43X79]  170.43 70.65 0 bottom
PJP65  -  [JUMP_43X39]  109.3 169.33 0 bottom
PJP77  -  [JUMP_43X39]  157.06 116.62 0 bottom
PJP100  -  [JUMP_43X118]  264.53 53.38 0 bottom
PJP101  -  [JUMP_43X118]  264.53 48.04 0 bottom
PJP102  -  [JUMP_43X118]  231.61 42.76 270 bottom
PJP103  -  [JUMP_43X118]  237.27 42.75 270 bottom
PJP200  -  [JUMP_43X118]  177.39 64.48 270 bottom
PJP201  -  [JUMP_43X39]  174.91 70.83 90 bottom
PJP202  -  [JUMP_43X39]  169.5 74.59 0 bottom
PJP203  -  [JUMP_43X118]  183.17 56.81 90 bottom
PJP204  -  [JUMP_43X118]  188.5 56.81 90 bottom
PJP300  -  [JUMP_43X79]  16.79 139.95 0 bottom
PJP301  -  [JUMP_43X79]  28.27 131.48 180 top
PJP302  -  [JUMP_43X79]  28.27 127.67 180 top
PJP400  -  [JUMP_43X79]  261.15 28.78 270 bottom
PJP401  -  [JUMP_43X79]  252.89 27.68 90 bottom
PJPDC1  -  [ACES_50493-0110N-001_11P]  10.5 72.8 90 bottom
PL1  -  [TAI-T_HCB2012KF-121T50_2P]  156.24 102.13 270 top
PL2  -  [TAIYO_FBMJ4516HS720NT_2P]  199.88 30.63 90 bottom
PL3  -  [MURAT_BLM15HG601SN1D_2P]  2.9 73.43 0 top
PL4  -  [CHT_C8BBPH853025_2P]  17.18 80.05 270 bottom
PL6  -  [TAIYO_FBMJ4516HS720NT_2P]  197.44 30.63 90 bottom
PL100  -  [CYNTE_PCMB053T-1R0MS_2P]  246.8 45.27 270 bottom
PL102  -  [TOKO_FDV0630-3R3M-P3_2P]  237.98 47.92 180 bottom
PL103  -  [TOKO_FDSD0630-H-2R2M-P3_2P]  255.55 48.17 0 bottom
PL201  -  [CYNTE_PCMC104T-1R0MN_2P]  198.79 67.98 180 bottom
PL301  -  [TAI-T_VMPI0703AR-4R7M-Z01_2P]  17.81 136.31 0 top
PL401  -  [CYNTE_PH041H-1R0MS_2P]  257.49 32.55 180 bottom
PL500  -  [NEC_MPC0740LR42C_2P]  52.74 66.15 90 top
PL501  -  [NEC_MPC0740LR42C_2P]  52.74 51.52 270 top
PL502  -  [NEC_MPC0740LR42C_2P]  52.74 61.94 270 top
PL510  -  [L_1812-1806]  32.47 72.83 270 top
PL700  -  [CYNTE_PCMB053T-1R0MS_2P]  193.6 41.82 180 bottom
PL701  -  [CYNTE_PCMB104T-5R6MS_2P]  198.54 50.07 0 bottom
PQ1  -  [NTR4502PT1G_SOT23-3]  175.24 32.72 270 bottom
PQ2  -  [FDV301N_NL_SOT23-3]  3.18 75.63 0 top
PQ3  -  [MMST3904-7-F_SOT323-3]  2.57 79.92 0 top
PQ4  -  [TP0610K-T1-E3_SOT23-3]  26.39 142.5 180 bottom
PQ5  -  [SI7447DP_SO8_5P]  15.88 73.43 0 bottom
PQ7  -  [SSM3K7002FU_SC70-3]  30.64 146.27 0 bottom
PQ8  -  [IMD2AT-108_SC74-6]  19.02 66.96 0 top
PQ101  -  [SIS412DN-T1-GE3_POWERPAK8-5]  250.44 48.91 0 bottom
PQ102  -  [SIS412DN-T1-GE3_POWERPAK8-5]  240.83 49.06 0 bottom
PQ103  -  [SI7716ADN-T1-GE3_POWERPAK8-5]  249.46 50.77 90 bottom
PQ104  -  [SI7716ADN-T1-GE3_POWERPAK8-5]  243.62 52.74 270 bottom
PQ201  -  [SIR472DP-T1-GE3_POWERPAK8-5]  186.86 66.75 270 bottom
PQ202  -  [SIR472DP-T1-GE3_POWERPAK8-5]  181.44 68.49 90 bottom
PQ204  -  [DMN66D0LDW-7_SOT363-6]  165.62 77.61 90 bottom
PQ205  -  [DMN66D0LDW-7_SOT363-6]  165.6 80.19 90 bottom
PQ301  -  [SIS412DN-T1-GE3_POWERPAK8-5]  21.84 134.48 180 bottom
PQ303  -  [SI7716ADN-T1-GE3_POWERPAK8-5]  23.49 137.37 0 bottom
PQ500  -  [CSD86350Q5D_SON8]  43.09 72.93 270 top
PQ502  -  [CSD86350Q5D_SON8]  44.58 43.27 270 top
PQ504  -  [CSD86350Q5D_SON8]  43.03 58.02 270 top
PQ700  -  [NTR4502PT1G_SOT23-3]  29.18 77.24 180 bottom
PQ701  -  [SI7447DP_SO8_5P]  27.31 71.03 270 bottom
PQ702  -  [NTR4502PT1G_SOT23-3]  25.18 77.25 180 bottom
PQ703  -  [NTGD4161PT1G_TSOP6]  86.93 112.18 90 top
PQ704  -  [SIR472DP-T1-GE3_POWERPAK8-5]  191.27 50.71 0 bottom
PQ705  -  [FDMC7692S_MLP8-5]  186.74 50.1 90 bottom
PQ706  -  [DMN66D0LDW-7_SOT363-6]  233.08 62.39 90 bottom
PQ707  -  [DMN66D0LDW-7_SOT363-6]  226.16 63.43 0 bottom
PQ710  -  [DMN66D0LDW-7_SOT363-6]  169.99 52.47 90 bottom
PQ1001  -  [SI7447DP_SO8_5P]  223.68 50.54 0 bottom
PQ1002  -  [SI4835DDY-T1-E3_SO8]  200.34 38.16 180 bottom
PQ1003  -  [SI7447DP_SO8_5P]  194.41 37.5 270 bottom
PQ1004  -  [SI7447DP_SO8_5P]  182.99 38.91 0 bottom
PQ1005  -  [SI4835DDY-T1-E3_SO8]  207.57 43.7 270 bottom
PQ1008  -  [SI7447DP_SO8_5P]  221.46 39.28 90 bottom
PQ1009  -  [SI7447DP_SO8_5P]  218.92 43.09 270 bottom
PQ1010  -  [SSM3K7002FU_SC70-3]  215.37 49.95 90 bottom
PQ1011  -  [SSM3K7002FU_SC70-3]  157.54 104.02 90 bottom
PQ1070  -  [NTR4502PT1G_SOT23-3]  234.48 68.2 180 bottom
PQ1071  -  [DMN66D0LDW-7_SOT363-6]  231.82 68.9 180 bottom
PQ1072  -  [NTR4502PT1G_SOT23-3]  154.75 106.51 0 bottom
PQ1080  -  [DMN66D0LDW-7_SOT363-6]  154.61 151.7 180 bottom
PQ1082  -  [SSM3K7002FU_SC70-3]  150.91 149.07 0 bottom
PQ1083  -  [IMD2AT-108_SC74-6]  200.08 26.35 270 bottom
PR1  -  [R_0402]  41.23 155.74 0 bottom
PR2  -  [R_0402]  173.19 28.48 0 bottom
PR3  -  [RP_0804_8P4R]  185.3 27.16 180 bottom
PR7  -  [R_0402]  1.81 85.51 0 top
PR8  -  [R_0402]  1.81 87.54 0 top
PR9  -  [R_0402]  2.7 86.52 180 top
PR10  -  [R_0402]  2.7 84.49 180 top
PR11  -  [R_0402]  4.23 83.09 270 top
PR12  -  [R_0402]  1.81 83.48 0 top
PR13  -  [R_0402]  4.23 81.32 270 top
PR15  -  [R_0402]  26.84 147.67 180 bottom
PR16  -  [R_0402]  22.39 76.57 270 bottom
PR17  -  [R_0402]  26.84 148.63 180 bottom
PR18  -  [R_0402]  13.57 67.22 180 bottom
PR19  -  [R_0805]  20.99 78.65 90 bottom
PR20  -  [R_0402]  18.12 71.79 0 top
PR21  -  [R_0402]  30.39 141.13 90 bottom
PR22  -  [R_0402]  18.12 70.9 0 top
PR23  -  [R_0402]  31.28 141.13 90 bottom
PR33  -  [R0402_0OHM]  174.1 29.37 180 bottom
PR100  -  [R_0402]  249.41 64.26 180 bottom
PR101  -  [R_0402]  243.82 64.34 0 bottom
PR102  -  [R_0402]  249.39 63.37 180 bottom
PR103  -  [R0402_0OHM]  245.99 62.75 90 bottom
PR104  -  [R_0402]  243.82 63.32 0 bottom
PR105  -  [R_0402]  248.5 62.43 0 bottom
PR106  -  [R_0402]  244.74 62.35 180 bottom
PR107  -  [R_0603]  243.49 58.2 180 bottom
PR108  -  [R_0603]  252.13 57.57 180 bottom
PR109  -  [R_1206]  252.29 54.67 180 bottom
PR110  -  [R_1206]  240.66 54.65 0 bottom
PR111  -  [R0402_0OHM]  241.44 62.69 0 bottom
PR112  -  [R_0402]  241.41 63.58 0 bottom
PR118  -  [R0402_0OHM]  251.19 60.7 180 bottom
PR119  -  [R_0402]  250.25 61.67 0 bottom
PR200  -  [R_0603]  177.96 72.24 90 bottom
PR201  -  [R_0402]  182.1 80.17 180 bottom
PR202  -  [R_1206]  184.5 74.59 0 bottom
PR203  -  [R_0603]  181.19 77.59 90 bottom
PR204  -  [R_0402]  174.61 78.01 180 bottom
PR205  -  [R_0402]  179.1 82.28 270 bottom
PR206  -  [R_0402]  176.95 82.28 270 bottom
PR207  -  [R_0402]  171.87 78.06 90 bottom
PR208  -  [R_0402]  175.93 82.28 270 bottom
PR209  -  [R_0402]  180.25 82.28 270 bottom
PR211  -  [R_0402]  174.61 78.9 180 bottom
PR213  -  [R_0402]  163.31 79.09 0 bottom
PR216  -  [R_0402]  170.54 79.13 270 bottom
PR217  -  [R_0402]  163.28 78.19 270 bottom
PR218  -  [R_0402]  169.58 80.03 180 bottom
PR219  -  [R_0402]  169.73 77.28 180 bottom
PR220  -  [R_0402]  169.68 78.22 90 bottom
PR221  -  [R_0402]  164.26 82.83 270 bottom
PR222  -  [R_0402]  169.71 83.91 90 bottom
PR223  -  [R_0402]  169.58 80.92 180 bottom
PR224  -  [R_0402]  163.31 80.99 270 bottom
PR225  -  [R_0402]  169.62 81.76 90 bottom
PR240  -  [R0402_0OHM]  177.96 81.37 90 bottom
PR300  -  [R_0402]  18.83 147.18 270 bottom
PR301  -  [R_0603]  18.7 144.24 270 bottom
PR302  -  [R_0402]  21.37 146.39 90 top
PR303  -  [R_0402]  18.7 146.39 90 top
PR304  -  [R_1206]  14.89 135.42 90 top
PR305  -  [R_0402]  24.04 147.18 270 bottom
PR306  -  [R_0402]  23.15 146.39 90 top
PR307  -  [R_0402]  22.26 146.39 90 top
PR315  -  [R0402_0OHM]  19.59 147.31 270 top
PR400  -  [R_0402]  258.66 35.72 0 bottom
PR401  -  [R_0603]  256.96 28.93 270 bottom
PR402  -  [R_0402]  264.47 33.4 180 bottom
PR403  -  [R_0402]  261.53 37.58 270 bottom
PR404  -  [R_0402]  262.47 36.74 0 bottom
PR405  -  [R_0402]  263.58 34.37 0 bottom
PR406  -  [R0402_0OHM]  260.51 37.58 270 bottom
PR500  -  [R_0402]  49.61 23.91 0 bottom
PR501  -  [R0402_0OHM]  38.76 69.4 180 bottom
PR502  -  [R_0603]  36.67 73.7 0 bottom
PR503  -  [R_0402]  49.61 23.02 0 bottom
PR504  -  [R_0402]  49.61 22.13 0 bottom
PR505  -  [R0402_0OHM]  47.33 23.91 0 top
PR506  -  [R0402_0OHM]  47.33 23.02 0 top
PR507  -  [R_0402]  47.33 26.58 0 top
PR508  -  [R0402_0OHM]  47.33 22.13 0 top
PR509  -  [R_0402]  47.33 25.69 0 top
PR510  -  [R_0603]  57.69 36.42 90 top
PR511  -  [R_0603]  57.69 36.42 90 bottom
PR512  -  [R_0402]  56.55 36.66 90 top
PR513  -  [R0402_0OHM]  47.33 21.25 0 top
PR514  -  [R_0402]  47.33 24.8 0 top
PR515  -  [R_1206]  47.34 75.47 180 top
PR516  -  [R_0402]  57.69 34.12 90 top
PR517  -  [R_0402]  47.33 20.36 0 top
PR518  -  [R_0402]  56.55 34.12 90 top
PR519  -  [R_0402]  50.33 20.03 90 top
PR520  -  [R0603_0OHM]  50.33 30.71 90 top
PR521  -  [R_0402]  52.18 21.25 180 top
PR522  -  [R0402_0OHM]  49.44 20.03 90 top
PR523  -  [R_0402]  51.37 30.95 90 top
PR524  -  [R0402_0OHM]  53.12 21.17 90 top
PR525  -  [R_0402]  55.03 22.08 270 top
PR526  -  [R0402_0OHM]  56.42 30.69 90 top
PR528  -  [R_0402]  54.14 22.08 270 top
PR529  -  [R_0402]  60.23 21.8 90 top
PR531  -  [R_0402]  57.31 30.69 90 top
PR533  -  [R_0402]  62.26 23.58 90 top
PR534  -  [R_0603]  47.09 27.72 0 top
PR535  -  [R_0603]  53.12 36.42 90 bottom
PR536  -  [R_0402]  63.28 23.58 90 top
PR537  -  [R_0402]  59.14 28.36 0 bottom
PR539  -  [R_0603]  53.12 37.82 270 top
PR541  -  [R_0402]  56.42 20.79 90 top
PR542  -  [R_1206]  51.28 38.01 180 top
PR543  -  [R_0402]  61.25 23.58 90 top
PR544  -  [R_0402]  58.84 37.58 270 top
PR545  -  [R_0402]  60.05 27.47 180 bottom
PR546  -  [R_0402]  54.26 35.04 270 top
PR547  -  [R_0402]  54.26 35.04 270 bottom
PR548  -  [R0402_0OHM]  60.93 28.37 270 bottom
PR549  -  [R_0603]  54.01 32.1 270 top
PR550  -  [R_0402]  60.17 23.35 270 bottom
PR551  -  [R_0402]  63.6 23.35 270 bottom
PR552  -  [R_0603]  55.41 36.42 90 bottom
PR553  -  [R_0603]  55.41 37.82 270 top
PR554  -  [R_1206]  48.48 63.08 180 top
PR555  -  [R_0402]  54.26 37.58 270 top
PR556  -  [R_0402]  55.41 35.04 270 top
PR557  -  [R_0402]  55.41 35.04 270 bottom
PR558  -  [R_0402]  56.97 28.92 90 bottom
PR700  -  [R0402_0OHM]  150.15 114.92 270 bottom
PR701  -  [R_1206_4P-D]  29 69.59 0 bottom
PR702  -  [R0402_0OHM]  34.11 75.09 270 bottom
PR703  -  [R0402_0OHM]  19.67 77.63 180 top
PR704  -  [R_0402]  168.31 47.71 90 bottom
PR705  -  [R0402_0OHM]  167.42 47.71 90 bottom
PR706  -  [R_0402]  32.55 76.01 180 bottom
PR707  -  [R_0402]  31.66 79.21 90 bottom
PR708  -  [R_0402]  32.57 76.91 180 bottom
PR709  -  [R_0402]  82.97 113.18 90 top
PR710  -  [R0402_0OHM]  32.6 80.17 0 bottom
PR711  -  [R0402_0OHM]  32.6 79.28 0 bottom
PR712  -  [R_0402]  88.62 113.12 90 top
PR713  -  [R_0402]  84.54 116.24 0 top
PR714  -  [R0402_0OHM]  89.7 113.12 90 top
PR715  -  [R_0402]  85.45 115.35 180 top
PR716  -  [R_0402]  214.71 57.27 90 bottom
PR717  -  [R_0402]  170.26 54.9 0 bottom
PR718  -  [R0402_0OHM]  213.74 57.26 90 bottom
PR723  -  [R_1206_4P-D]  211.53 49.44 270 bottom
PR724  -  [R_1206]  192.25 54.39 180 bottom
PR732  -  [R_0402]  173.31 47.53 0 bottom
PR734  -  [R_0402]  223.67 60.17 0 bottom
PR735  -  [R_0402]  216.16 57.28 0 bottom
PR736  -  [R_0402]  227.87 55.74 270 bottom
PR737  -  [R_0402]  227.87 57.05 90 bottom
PR738  -  [R_0402]  227.87 59.33 90 bottom
PR739  -  [R0402_0OHM]  231.76 63.66 180 bottom
PR740  -  [R_0402]  220.35 53.09 0 bottom
PR741  -  [R_0402]  214.54 55.2 90 bottom
PR742  -  [R0402_0OHM]  225.9 59.33 90 bottom
PR743  -  [R_0402]  218.5 53.09 0 bottom
PR744  -  [R_0402]  226.86 54.82 90 bottom
PR745  -  [R_0402]  225.78 57.96 270 bottom
PR746  -  [R_0402]  226.92 60.25 270 bottom
PR747  -  [R_0402]  215.43 56.12 270 bottom
PR748  -  [R_0402]  216.32 56.12 270 bottom
PR749  -  [R_0402]  229.65 61.29 180 bottom
PR757  -  [R_0402]  173.31 54.01 0 bottom
PR758  -  [R_0402]  174.23 51.22 180 bottom
PR759  -  [R_0603]  178.22 52.8 90 bottom
PR760  -  [R_0402]  174.23 52.11 180 bottom
PR761  -  [R_0603]  176.95 52.8 90 bottom
PR762  -  [R_0402]  175.8 43.65 90 bottom
PR763  -  [R0402_0OHM]  174.23 49.44 180 bottom
PR764  -  [R_0402]  173.31 53.12 0 bottom
PR765  -  [R_0603]  182.22 48.78 0 bottom
PR766  -  [R0402_0OHM]  174.23 50.33 180 bottom
PR771  -  [R_0402]  176.67 43.65 90 bottom
PR772  -  [R_0402]  170.34 56.88 270 bottom
PR775  -  [R_1206]  179.29 41.31 180 bottom
PR1001  -  [R_0402]  228.76 39.48 270 bottom
PR1002  -  [R0402_0OHM]  146.41 121.13 180 bottom
PR1003  -  [R_0402]  184.95 30.53 270 bottom
PR1004  -  [R0402_0OHM]  157.72 121.58 180 bottom
PR1005  -  [R_1206]  181.01 29.91 180 bottom
PR1006  -  [R0402_0OHM]  157.72 120.56 180 bottom
PR1007  -  [R0402_0OHM]  157.72 119.54 180 bottom
PR1008  -  [R0402_0OHM]  156.8 122.59 0 bottom
PR1009  -  [R0402_0OHM]  148.75 126.6 270 bottom
PR1010  -  [R0402_0OHM]  157.72 118.53 180 bottom
PR1011  -  [R_0805]  156.24 113.12 90 bottom
PR1012  -  [R0402_0OHM]  155.86 125.69 90 bottom
PR1013  -  [R_0402]  151.21 112.81 0 bottom
PR1014  -  [R0402_0OHM]  153.83 125.69 90 bottom
PR1015  -  [R0402_0OHM]  151.1 114.01 90 bottom
PR1016  -  [R0402_0OHM]  154.85 125.69 90 bottom
PR1017  -  [R0402_0OHM]  152.05 114.01 90 bottom
PR1018  -  [R_0402]  151.8 126.6 270 bottom
PR1019  -  [R0402_0OHM]  152.82 125.69 90 bottom
PR1020  -  [R0402_0OHM]  150.78 125.69 90 bottom
PR1021  -  [R0402_0OHM]  149.2 114.01 90 bottom
PR1022  -  [R0402_0OHM]  148.24 114.01 90 bottom
PR1023  -  [R0402_0OHM]  149.77 125.69 90 bottom
PR1024  -  [R_0402]  147.74 125.69 90 bottom
PR1025  -  [R0402_0OHM]  146.41 123.92 180 bottom
PR1026  -  [R_0402]  207.09 38.59 0 bottom
PR1027  -  [R0402_0OHM]  146.42 122.05 180 bottom
PR1028  -  [R_0402]  146.41 122.97 180 bottom
PR1029  -  [R0402_0OHM]  146.41 120.24 180 bottom
PR1030  -  [R_0402]  158.11 105.78 180 bottom
PR1031  -  [R_0402]  154.96 109.21 270 bottom
PR1032  -  [R_0402]  158.11 106.68 180 bottom
PR1033  -  [R0402_0OHM]  214.55 51.6 0 bottom
PR1070  -  [R0402_0OHM]  235.02 72.07 0 bottom
PR1071  -  [R_0402]  233.19 72.02 0 bottom
PR1072  -  [R_0402]  232.28 72.07 180 bottom
PR1073  -  [R_0402]  231.34 67.5 180 bottom
PR1081  -  [R_0402]  149.56 150.53 0 bottom
PR1083  -  [R_0402]  152.26 150.53 180 bottom
PR1097  -  [R_0402]  217.41 46.9 180 bottom
PR1098  -  [R_0402]  216.37 51.6 0 bottom
PR1099  -  [R_0402]  217.71 44.54 90 bottom
PR1100  -  [R_0402]  154.34 102.68 0 bottom
PU1  -  [TS5A63157DCKR_SC70-6]  5.11 86.52 180 top
PU101  -  [TPS51225CRUKR_QFN20_3X3]  245.78 61 0 bottom
PU200  -  [RT8207MZQW_WQFN20_3X3]  176.34 76.3 90 bottom
PU300  -  [TPS51212DSCR_SON10_3X3]  20.48 147.17 0 bottom
PU400  -  [SY8033BDBC_DFN10_3X3]  259.67 32.44 90 bottom
PU500  -  [ISL95812HRZ-T_QFN32_4X4]  51.53 24.16 0 top
PU501  -  [ISL6208BCRZ-T_QFN8_2X2]  39.47 73.25 0 bottom
PU700  -  [BQ24737RGRR_VQFN20_3P5X3P5]  179.23 46.77 180 bottom
PU701  -  [INA199A1DCKR_SC70-6]  33.1 72.67 180 bottom
PU703  -  [LM393DR_SO8]  224.06 58.33 270 bottom
PU704  -  [TC7SH08FU_SSOP5]  238.8 63.76 270 bottom
PU1001  -  [CD3301RHHR_QFN36_6X6]  153.7 117.38 180 bottom
PU1080  -  [TC7SH08FU_SSOP5]  152.75 148.23 90 bottom
PU1081  -  [TC7SH08FU_SSOP5]  152.07 151.61 180 bottom
PWRSW1  -  [SHORTPADS]  112.56 165.26 90 top
Q4  -  [DMN65D8LW-7_SOT323-3]  87.22 99.6 270 bottom
Q5  -  [DMN65D8LW-7_SOT323-3]  118.4 103.67 180 bottom
Q6  -  [DMN66D0LDW-7_SOT363-6]  58.17 143.33 0 top
Q14  -  [PMST3904_SOT323-3]  124.37 60.33 0 bottom
Q15  -  [PMST3904_SOT323-3]  56.17 44.17 0 bottom
Q16  -  [PMST3904_SOT323-3]  94.05 113.57 270 top
Q17  -  [PMST3904_SOT323-3]  118.65 70.81 0 top
Q21  -  [FDC654P-G_SSOT-6]  52.71 153.52 90 bottom
Q22  -  [DMN65D8LW-7_SOT323-3]  49.95 157.7 180 bottom
Q24  -  [PMV65XP_SOT23-3]  57.54 148.63 270 top
Q26  -  [PMST3904_SOT323-3]  89.57 56.33 0 top
Q27  -  [PMST3904_SOT323-3]  84.02 141.77 90 bottom
Q28  -  [PMST3904_SOT323-3]  158.02 137.11 0 top
Q29  -  [DMN66D0LDW-7_SOT363-6]  172.12 48.57 270 bottom
Q45  -  [DMN65D8LW-7_SOT323-3]  98.84 145.32 90 bottom
Q52  -  [DMN65D8LW-7_SOT323-3]  95.79 151.29 180 top
Q55  -  [DMN65D8LW-7_SOT323-3]  254.42 96.18 180 bottom
Q63  -  [SI4164DY-T1-GE3_SO8]  35.82 125.07 90 top
Q74  -  [DMN66D0LDW-7_SOT363-6]  9.96 151.93 180 top
Q75  -  [PDTA114EU_SC70-3]  9.65 147.24 180 top
Q77  -  [DMN65D8LW-7_SOT323-3]  243.56 71.16 270 bottom
Q78  -  [DMN65D8LW-7_SOT323-3]  14 145.77 90 top
Q79  -  [PDTA114EU_SC70-3]  10.16 144.32 180 top
Q80  -  [PDTA114EU_SC70-3]  8.67 153.64 270 bottom
Q81  -  [DMN66D0LDW-7_SOT363-6]  39.72 31.8 270 top
Q84  -  [DMN65D8LW-7_SOT323-3]  14.51 151.8 180 bottom
Q86  -  [PDTA114EU_SC70-3]  16.75 145.43 0 bottom
Q87  -  [DMN65D8LW-7_SOT323-3]  151.58 109.04 180 top
Q89  -  [L2N7002WT1G_SC-70-3]  149.7 160.31 90 bottom
Q110  -  [DMN66D0LDW-7_SOT363-6]  82.46 130.97 0 top
Q113  -  [DMN66D0LDW-7_SOT363-6]  85.89 130.97 0 top
Q124  -  [DMN66D0LDW-7_SOT363-6]  149.51 157.52 270 bottom
Q186  -  [SI4835DDY-T1-GE3_SO8]  148 105.12 90 top
Q295  -  [DMN66D0LDW-7_SOT363-6]  114.9 101.65 270 bottom
Q304  -  [DMN66D0LDW-7_SOT363-6]  56.27 132.53 0 top
Q318  -  [DMN65D8LW-7_SOT323-3]  12.58 150.15 90 bottom
Q322  -  [DMN65D8LW-7_SOT323-3]  225.21 69.76 0 bottom
Q325  -  [DMN66D0LDW-7_SOT363-6]  130.97 145.32 0 top
Q326  -  [DMN65D8LW-7_SOT323-3]  26.07 153.96 180 bottom
Q327  -  [DMN65D8LW-7_SOT323-3]  131.61 150.4 180 top
Q328  -  [DMN65D8LW-7_SOT323-3]  15.15 149.26 270 top
Q335  -  [DMN66D0LDW-7_SOT363-6]  32.05 162.28 180 top
Q336  -  [DMN66D0LDW-7_SOT363-6]  25.44 150.67 270 top
Q337  -  [DMN66D0LDW-7_SOT363-6]  29.51 162.28 180 top
Q338  -  [DMN65D8LW-7_SOT323-3]  259.43 105.45 270 bottom
Q339  -  [DMN66D0LDW-7_SOT363-6]  244.63 69.24 270 bottom
Q340  -  [DMN66D0LDW-7_SOT363-6]  241.85 77.35 0 bottom
Q344  -  [DMN66D0LDW-7_SOT363-6]  19.96 150.97 0 bottom
Q345  -  [DMN66D0LDW-7_SOT363-6]  39.67 138.27 180 top
Q346  -  [DMN66D0LDW-7_SOT363-6]  39.67 141.58 180 top
QC5  -  [DMN65D8LW-7_SOT323-3]  17.08 94.84 180 top
QC6  -  [LBSS138LT1G_SOT23-3]  66.2 43.7 180 bottom
QH2  -  [BSS138_NL_SOT23-3]  47.89 82.29 0 top
QH3  -  [L2N7002WT1G_SC-70-3]  52.04 92.75 270 top
QH4  -  [DMN66D0LDW-7_SOT363-6]  18.31 86.59 0 top
R1  -  [R_0402]  111.92 101.08 270 bottom
R2  -  [R_0402]  115.99 101.31 90 bottom
R3  -  [R_0402]  84.11 100.32 270 bottom
R4  -  [R_0402]  118.73 100.24 180 bottom
R5  -  [R_0402]  83.22 100.32 270 bottom
R6  -  [R_0402]  64.74 96.35 90 bottom
R7  -  [R_0402]  51.34 81.75 90 bottom
R8  -  [R_0402]  50.07 81.75 90 bottom
R9  -  [R_0402]  48.8 81.75 90 bottom
R10  -  [R_0402]  85.96 101.38 180 bottom
R11  -  [R_0402]  88.43 101.43 90 bottom
R12  -  [R_0402]  42.15 140.88 180 top
R13  -  [R_0402]  42.15 139.74 180 top
R14  -  [R_0402]  127.67 100.16 90 bottom
R15  -  [R_0402]  87.54 134.33 180 bottom
R17  -  [R_0402]  221.01 72.86 90 bottom
R18  -  [R_0402]  235.24 77.18 90 bottom
R19  -  [R_0402]  220.15 88.26 90 bottom
R20  -  [R_0402]  41.11 137.45 0 top
R21  -  [R_0402]  41.11 138.47 0 top
R22  -  [R_0402]  225.37 89.13 0 bottom
R23  -  [R_0402]  225.37 87.35 0 bottom
R24  -  [R_0402]  225.37 90.02 0 bottom
R25  -  [R_0402]  225.37 86.46 0 bottom
R26  -  [R_0402]  231.3 77.18 90 bottom
R27  -  [R_0402]  234.35 77.18 90 bottom
R28  -  [R_0402]  233.33 77.18 90 bottom
R29  -  [R_0402]  220.65 91.15 90 bottom
R30  -  [R_0402]  232.38 77.16 90 bottom
R36  -  [R_0402]  126.6 102.53 180 bottom
R37  -  [R_0402]  124.37 101.08 270 bottom
R38  -  [R_0402]  85.96 102.27 180 bottom
R39  -  [R_0402]  85.96 104.68 180 bottom
R45  -  [R_0402]  167.53 63 90 top
R53  -  [R_0402]  71.65 164.78 270 top
R54  -  [R_0402]  74.01 163.93 0 top
R55  -  [R_0402]  77.17 163.92 180 top
R56  -  [R_0402]  243.62 78.83 90 bottom
R57  -  [R_0402]  18.96 156.2 270 bottom
R58  -  [R_0402]  27.85 157.19 90 top
R59  -  [R_0402]  242.73 78.83 90 bottom
R61  -  [R_0402]  28.69 153.07 180 top
R62  -  [R_0402]  243.75 92.31 270 bottom
R63  -  [R_0402]  28.69 159.04 180 top
R64  -  [R_0402]  28.69 154.09 180 top
R65  -  [R_0402]  16.93 157.06 90 bottom
R66  -  [R_0402]  27.54 164.76 180 top
R67  -  [R_0402]  18.96 157.06 90 bottom
R68  -  [R_0402]  27.54 165.64 180 top
R69  -  [R_0402]  22.64 159.85 90 bottom
R70  -  [R_0402]  20.79 160.69 0 bottom
R71  -  [R_0402]  16.93 156.2 270 bottom
R72  -  [R_0402]  18.37 151.29 0 top
R73  -  [R_0402]  18.37 150.4 0 top
R74  -  [R_0402]  15.2 155.48 0 top
R75  -  [R_0402]  241.99 92.32 270 bottom
R76  -  [R_0402]  238.79 92.31 270 bottom
R77  -  [R_0402]  239.7 91.37 90 bottom
R78  -  [R_0402]  235.94 80.22 90 bottom
R79  -  [R_0402]  235.05 81.14 270 bottom
R80  -  [R_0402]  237.91 92.31 270 bottom
R81  -  [R_0402]  237.02 91.4 90 bottom
R82  -  [R_0402]  37.25 141.39 270 top
R96  -  [R_0402]  30.31 158.28 0 top
R98  -  [R_0402]  31.23 154.21 180 top
R99  -  [R_0402]  35.47 144.31 0 top
R101  -  [R_0402]  80.81 141.31 90 bottom
R102  -  [R_0402]  214.28 89.77 270 bottom
R105  -  [R0603_0OHM]  82.9 29.12 0 bottom
R115  -  [R_0402]  31.23 151.67 180 bottom
R116  -  [R_0402]  35.72 146.16 270 top
R117  -  [R_0402]  38.9 146.16 270 top
R118  -  [R_0402]  38.01 146.16 270 top
R119  -  [R_0402]  31.99 147.1 180 top
R120  -  [R_0402]  29.29 147.1 0 top
R121  -  [R_0402]  32.85 147.1 0 top
R122  -  [R_0402]  28.53 148.88 0 top
R123  -  [R_0402]  36.99 146.16 270 top
R124  -  [R_0402]  37.25 144.31 0 top
R127  -  [R_0402]  74.53 142.02 180 top
R159  -  [R_0402]  54.09 146.42 180 top
R160  -  [R_0402]  54.09 148.75 180 bottom
R161  -  [R_0402]  57.13 145.67 270 top
R162  -  [R_0402]  57.13 143 90 top
R209  -  [R0603_0OHM]  120.94 156.31 90 top
R222  -  [R_0402]  34.36 136.4 0 top
R227  -  [R_0402]  53.17 142.28 0 bottom
R230  -  [R_0402]  53.17 141.39 0 bottom
R231  -  [R_0402]  53.17 140.5 0 bottom
R232  -  [R_0402]  53.17 139.61 0 bottom
R233  -  [R_0402]  53.17 138.72 0 bottom
R234  -  [R_0402]  53.17 137.83 0 bottom
R235  -  [R_0402]  53.17 136.94 0 bottom
R236  -  [R_0402]  53.17 136.05 0 bottom
R301  -  [R_0402]  58.03 110.15 0 bottom
R336  -  [R_0402]  37.37 137.35 270 bottom
R339  -  [R_0402]  36.48 137.35 270 bottom
R392  -  [R_0402]  168.64 140.24 180 top
R394  -  [R_0402]  173.9 135.6 90 top
R395  -  [R_0402]  168.22 128.81 0 top
R396  -  [R_0402]  160.56 136.23 90 top
R399  -  [R_0402]  156.37 136.13 270 top
R402  -  [R_0402]  163.79 133.26 0 top
R405  -  [R_0402]  163.79 136.18 0 top
R407  -  [R_0402]  109.84 146.72 180 bottom
R408  -  [R_0402]  109.84 147.67 180 bottom
R409  -  [R_0402]  170.14 138.47 0 top
R410  -  [R_0402]  163.79 134.15 0 top
R415  -  [R_0402]  237.51 80.24 0 bottom
R418  -  [R_0402]  164.7 132.24 180 top
R420  -  [R_0402]  162.42 135.29 180 top
R422  -  [R_0402]  54.26 158.98 180 bottom
R423  -  [R_0402]  51.72 157.72 270 bottom
R424  -  [R_0402]  174.91 133.56 90 top
R426  -  [R_0402]  161.5 137.07 0 top
R429  -  [R_0402]  105.89 146.54 270 bottom
R430  -  [R_0402]  173.9 130.8 270 top
R431  -  [R_0402]  46.14 145.65 270 bottom
R432  -  [R_0402]  44.92 137.7 0 bottom
R451  -  [R_0402]  19.27 163.24 90 top
R452  -  [R_0402]  20.16 163.24 90 top
R453  -  [R_0402]  16.47 162.01 90 top
R454  -  [R_0402]  17.36 162.01 90 top
R455  -  [R_0402]  14.58 161.97 90 top
R456  -  [R_0402]  15.46 161.97 90 top
R458  -  [R_0402]  9.96 163.42 0 top
R459  -  [R_0402]  9.96 164.31 0 top
R460  -  [R_0402]  22.89 163.87 90 top
R461  -  [R_0402]  22.01 163.87 90 top
R491  -  [R_0402]  23.08 149.44 90 top
R492  -  [R_0402]  81.31 111.21 90 top
R501  -  [R_0402]  166.28 40.12 270 bottom
R502  -  [R_0402]  168.88 37.66 90 bottom
R503  -  [R_0402]  169.2 45.9 270 bottom
R504  -  [R_0402]  167.34 44.99 0 bottom
R513  -  [R_0402]  169.2 47.71 90 bottom
R514  -  [R_0402]  219.62 73.82 270 bottom
R515  -  [R_0402]  40.17 28.41 90 top
R518  -  [R_0402]  28.69 155.36 180 top
R549  -  [R_0402]  121.57 158.41 270 bottom
R550  -  [R_0402]  217.33 69.35 270 bottom
R551  -  [R_0402]  216.9 61.4 270 bottom
R553  -  [R_0402]  124.24 158.41 270 bottom
R554  -  [R_0402]  118.91 156.63 270 bottom
R555  -  [R0402_0OHM]  122.46 158.41 270 bottom
R556  -  [R0402_0OHM]  115.65 157.14 0 bottom
R558  -  [R0402_0OHM]  123.35 157.52 90 bottom
R560  -  [R_0402]  216.44 69.35 270 bottom
R561  -  [R_0402]  122.21 147.91 90 top
R562  -  [R_0402]  127.54 154.6 0 bottom
R563  -  [R0402_0OHM]  115.65 158.02 0 bottom
R564  -  [R_0402]  217.79 61.42 270 bottom
R566  -  [R_0402]  74.77 16.8 90 bottom
R568  -  [R_0402]  222.61 63.28 180 bottom
R571  -  [R_0402]  166.15 157.14 90 bottom
R572  -  [R_0402]  164.37 157.14 90 bottom
R573  -  [R_0402]  165.26 157.14 90 bottom
R574  -  [R_0402]  163.48 157.14 90 bottom
R585  -  [R_0402]  51.85 3.64 90 bottom
R589  -  [R_0402]  50.83 3.64 90 bottom
R656  -  [R_0402]  169.54 113.52 90 bottom
R692  -  [R_0402]  148.19 152.82 180 bottom
R695  -  [R_0402]  147.66 146.59 0 bottom
R696  -  [R_0402]  130.44 160.96 270 top
R705  -  [R_0402]  148.57 142.78 180 bottom
R706  -  [R_0402]  148.57 143.67 180 bottom
R709  -  [R0603_0OHM]  42.13 152.19 270 bottom
R717  -  [R_0402]  126.68 169.53 180 top
R718  -  [R_0402]  147.61 158.53 0 bottom
R719  -  [R_0402]  249.26 70.2 180 bottom
R720  -  [R_0402]  263.88 56.41 90 bottom
R725  -  [R_0402]  147.74 162.09 0 bottom
R733  -  [R_0402]  109.32 145.82 270 bottom
R747  -  [R_0402]  255.18 103.12 90 bottom
R755  -  [R_0402]  104.92 126.4 0 top
R756  -  [R_0402]  105.19 117.87 90 top
R757  -  [R_0402]  218.22 68.46 90 bottom
R759  -  [R_0402]  98.33 153.45 0 top
R760  -  [R0402_0OHM]  223.55 88.86 90 bottom
R761  -  [R_0402]  208.14 83.6 180 bottom
R763  -  [R_0402]  226.3 85.51 180 bottom
R768  -  [R_0402]  213.39 89.77 270 bottom
R775  -  [R_0402]  219.74 92.06 270 bottom
R782  -  [R_0402]  226.02 81.57 0 bottom
R783  -  [R_0402]  68.54 167.3 0 top
R784  -  [R_0402]  109.66 118.49 270 top
R785  -  [R_0402]  218.73 60.41 90 bottom
R794  -  [R_0402]  209.91 84.62 180 bottom
R795  -  [R_0402]  209.91 82.33 180 bottom
R796  -  [R_0402]  41.06 28.41 90 top
R798  -  [R_0402]  209 85.51 0 bottom
R799  -  [R_0402]  97.87 147.1 0 bottom
R801  -  [R_0603]  258.67 142.56 270 bottom
R802  -  [R0402_0OHM]  210.19 75.14 90 bottom
R803  -  [R_0402]  222.62 88.8 90 bottom
R804  -  [R_0402]  211.24 73.77 270 bottom
R805  -  [R_0402]  221.78 91.15 90 bottom
R807  -  [R_0402]  224.44 91.15 90 bottom
R808  -  [R_0402]  110.61 117.57 90 top
R810  -  [R_0402]  112.12 163.61 180 top
R811  -  [R_0402]  109.64 163.41 90 top
R814  -  [R_0402]  98.26 156.88 0 top
R815  -  [R_0402]  127.8 170.1 270 top
R816  -  [R_0402]  255.43 97.6 270 bottom
R817  -  [R_0402]  107.27 151.23 180 top
R818  -  [R_0402]  167.34 128.09 90 top
R819  -  [R_0402]  106.46 163.41 90 top
R820  -  [R_0402]  174.79 136.51 270 top
R822  -  [R_0402]  112.12 156.63 180 top
R823  -  [R_0402]  133.59 155.61 180 bottom
R824  -  [R_0402]  147.35 155.23 0 bottom
R825  -  [R_0402]  106.46 165.19 90 top
R829  -  [R_0402]  112.12 157.52 180 top
R835  -  [R_0402]  102.27 165.21 270 bottom
R838  -  [R_0402]  112.12 160.95 180 top
R839  -  [R_0402]  112.12 159.55 180 top
R840  -  [R_0402]  112.12 158.66 180 top
R841  -  [R_0402]  112.12 161.83 180 top
R843  -  [R_0402]  95.08 154.34 0 top
R844  -  [R0402_0OHM]  125.52 168.59 0 top
R847  -  [R_0402]  172.32 115.48 180 top
R848  -  [R_0402]  173.25 112.49 90 top
R849  -  [R_0402]  172.32 112.43 180 top
R854  -  [R_0402]  113.5 156.25 0 bottom
R855  -  [R_0402]  98.26 157.77 0 top
R864  -  [R_0402]  172.32 119.42 180 top
R866  -  [R0402_0OHM]  97.44 164.3 90 bottom
R869  -  [R_0402]  95.08 155.61 0 bottom
R870  -  [R_0402]  104.81 162.04 270 top
R871  -  [R_0402]  112.12 156.25 180 bottom
R872  -  [R_0402]  113.5 158.66 0 top
R873  -  [R_0402]  109.97 163.99 180 bottom
R874  -  [R_0402]  106.33 169.12 90 bottom
R875  -  [R_0402]  112.12 155.74 180 top
R876  -  [R_0402]  106.33 166.96 90 bottom
R883  -  [R_0402]  92.44 149.01 180 bottom
R884  -  [R_0402]  111.21 162.72 0 top
R885  -  [R_0402]  101.44 148.84 270 bottom
R887  -  [R_0402]  102.27 161.12 90 top
R892  -  [R_0402]  96.88 160.44 180 top
R893  -  [R_0402]  95.79 149.26 90 top
R895  -  [R_0402]  56.93 79.97 90 bottom
R897  -  [R_0402]  57.31 94.47 270 bottom
R899  -  [R_0402]  49.69 94.47 270 bottom
R900  -  [R_0402]  53.88 93.56 90 bottom
R901  -  [R_0402]  46.9 94.02 90 bottom
R909  -  [R_0402]  53.93 135.14 0 top
R931  -  [R_0402]  37.5 123.18 270 top
R932  -  [R_0402]  11.26 149.9 0 top
R933  -  [R_0402]  35.77 128.31 0 bottom
R934  -  [R_0402]  8.53 146.96 270 top
R935  -  [R_0402]  141.13 105.65 270 top
R936  -  [R_0402]  58.2 81.75 90 bottom
R937  -  [R_0402]  13.06 144.05 180 top
R938  -  [R_0402]  13.75 147.86 90 bottom
R939  -  [R_0402]  8.54 144.72 270 top
R940  -  [R_0402]  149.64 107.78 90 top
R941  -  [R_0402]  12.07 151.99 180 bottom
R942  -  [R_0402]  8.29 151.96 270 bottom
R943  -  [R_0402]  16.67 144.51 270 bottom
R944  -  [R_0402]  150.54 108.7 270 top
R952  -  [R_0402]  93.71 158.41 180 bottom
R955  -  [R_0402]  22.39 150.1 270 bottom
R956  -  [R_0402]  18.83 149.18 90 bottom
R1000  -  [R_0402]  82.83 118.76 0 top
R1069  -  [R_0402]  102.33 146.54 270 bottom
R1118  -  [R_0402]  107.73 148.83 270 top
R1123  -  [R_0402]  76.23 153.53 270 bottom
R1124  -  [R_0402]  77.12 153.53 270 bottom
R1125  -  [R_0402]  110.83 163.99 0 bottom
R1128  -  [R_0402]  19.41 158.91 180 bottom
R1137  -  [R_0402]  52.36 149.95 90 bottom
R1138  -  [R_0402]  44.92 140.5 0 bottom
R1159  -  [R_0402]  249.22 74.23 270 bottom
R1160  -  [R_0402]  249.22 71.37 90 bottom
R1164  -  [R_0402]  23.85 163.87 90 top
R1165  -  [R_0402]  21.12 164.82 270 top
R1167  -  [R_0402]  153.2 162.01 90 bottom
R1170  -  [R_0402]  153.2 161.15 270 bottom
R1171  -  [R_0402]  153.2 163.79 90 bottom
R1197  -  [R_0402]  101.38 162.04 270 top
R1530  -  [R_0402]  88.3 130.85 90 top
R1532  -  [R_0402]  84.77 132.4 90 top
R1537  -  [R_0402]  84.77 131.51 270 top
R1539  -  [R_0402]  84.77 134.15 90 top
R1611  -  [R_0402]  37.93 128.43 0 top
R1614  -  [R_0402]  259.56 107.51 90 bottom
R1622  -  [R_0402]  142.31 140.79 270 top
R1626  -  [R0402_0OHM]  257.63 104.56 90 bottom
R1629  -  [R_0402]  146.41 141.48 0 top
R1630  -  [R_0402]  142.31 141.65 90 top
R1970  -  [R0402_0OHM]  120.02 108.57 270 top
R1972  -  [R_0402]  125.76 100.16 90 bottom
R1973  -  [R_0402]  85.96 103.16 180 bottom
R1977  -  [R_0402]  126.78 101.08 270 bottom
R1978  -  [R_0402]  87.41 102.35 270 bottom
R1979  -  [R_0402]  63.79 96.35 90 bottom
R1980  -  [R_0402]  96.3 152.74 90 bottom
R1981  -  [R_0402]  103.29 167.85 90 bottom
R1982  -  [R_0402]  111.21 153.58 0 bottom
R1983  -  [R_0402]  107.67 148.89 270 bottom
R1984  -  [R_0402]  106.84 148.83 270 top
R1986  -  [R_0402]  113.9 162.72 180 top
R1990  -  [R_0402]  83.66 153.53 270 bottom
R1993  -  [R_0402]  80.68 153.53 270 bottom
R1994  -  [R_0402]  83.98 151.37 270 bottom
R1995  -  [R_0402]  83.98 149.46 270 bottom
R2141  -  [R_0402]  225.37 88.24 0 bottom
R2151  -  [R_0402]  27.77 156.25 0 top
R2152  -  [R_0402]  27.48 148.12 180 top
R2153  -  [R_0402]  24.79 148.12 0 top
R2154  -  [R_0402]  28.86 157.19 90 top
R2157  -  [R_0402]  30.56 163.36 0 top
R2160  -  [R_0402]  82.63 126.66 0 top
R2161  -  [R_0402]  29.7 163.36 180 top
R2164  -  [R_0402]  74.14 112.16 90 bottom
R2165  -  [R_0402]  75.15 112.16 90 bottom
R2166  -  [R_0402]  76.17 112.16 90 bottom
R2167  -  [R_0402]  77.19 112.16 90 bottom
R2168  -  [R_0402]  78.2 112.16 90 bottom
R2169  -  [R_0402]  79.22 112.16 90 bottom
R2170  -  [R_0402]  80.23 112.16 90 bottom
R2171  -  [R_0402]  81.25 112.16 90 bottom
R2172  -  [R_0402]  73.95 134.07 90 bottom
R2173  -  [R_0402]  74.96 134.07 90 bottom
R2174  -  [R_0402]  75.98 134.07 90 bottom
R2175  -  [R_0402]  77 134.07 90 bottom
R2176  -  [R_0402]  78.01 134.07 90 bottom
R2177  -  [R_0402]  79.03 134.07 90 bottom
R2178  -  [R_0402]  80.04 134.07 90 bottom
R2179  -  [R_0402]  81.06 134.07 90 bottom
R2188  -  [R0402_0OHM]  161.92 119.91 180 bottom
R2189  -  [R_0402]  160.1 119.75 270 bottom
R2190  -  [R_0402]  212.91 62.09 180 bottom
R2191  -  [R_0402]  240.51 76.5 270 bottom
R2192  -  [R_0402]  212.91 60.27 180 bottom
R2193  -  [R_0402]  212.91 61.19 180 bottom
R2195  -  [R_0402]  83.04 149.52 180 bottom
R2196  -  [R_0402]  83.04 150.4 180 bottom
R3664  -  [R_0402]  46.9 81.75 90 bottom
R3665  -  [R_0402]  55.66 81.75 90 bottom
R3666  -  [R_0402]  60.56 88.81 180 bottom
R3667  -  [R_0402]  53.63 81.75 90 bottom
R3668  -  [R_0402]  51.47 94.47 270 bottom
R3669  -  [R_0402]  50.58 93.56 90 bottom
R3670  -  [R_0402]  60.56 87.29 180 bottom
RC1  -  [R_0402]  82.71 48.12 270 bottom
RC2  -  [R_0402]  83.6 48.14 270 bottom
RC5  -  [R_0402]  71.28 12.81 270 bottom
RC6  -  [R_0402]  72.17 12.81 270 bottom
RC7  -  [R_0402]  75.73 12.81 270 bottom
RC8  -  [R_0402]  73.4 18.31 270 bottom
RC9  -  [R_0402]  74.84 12.81 270 bottom
RC14  -  [R_0402]  111.67 76.92 90 bottom
RC16  -  [R_0402]  112.56 77.84 270 bottom
RC18  -  [R_0402]  113.14 82.71 180 bottom
RC19  -  [R_0402]  70.06 76.87 0 bottom
RC23  -  [R_0402]  60.18 75.09 180 bottom
RC24  -  [R_0402]  60.18 76.62 180 top
RC26  -  [R0402_0OHM]  70.06 75.98 0 bottom
RC27  -  [R_0402]  74.2 82.28 270 top
RC29  -  [R_0402]  59.27 75.98 0 bottom
RC30  -  [R_0402]  78.52 79.21 90 top
RC31  -  [R_0402]  76.11 79.21 90 top
RC32  -  [R_0402]  80.43 80.12 270 top
RC35  -  [R_0402]  61.96 76.62 180 top
RC40  -  [R_0402]  69.88 81.27 270 top
RC41  -  [R_0402]  59.27 77.76 0 bottom
RC42  -  [R_0402]  108.11 80.86 90 bottom
RC44  -  [R_0402]  76.06 81.44 180 top
RC45  -  [R_0402]  67.8 47.66 180 bottom
RC47  -  [R_0402]  82.2 79.21 90 top
RC48  -  [R_0402]  81.31 80.12 270 top
RC49  -  [R_0402]  110.4 74.41 270 bottom
RC50  -  [R_0402]  87.66 80.12 270 top
RC55  -  [R_0402]  109.38 80.86 90 bottom
RC56  -  [R_0402]  74.2 80.12 270 top
RC57  -  [R_0402]  75.22 80.12 270 top
RC58  -  [R_0402]  77.25 79.21 90 top
RC59  -  [R_0402]  89.44 35.42 270 bottom
RC60  -  [R_0402]  83.09 82.28 270 top
RC61  -  [R_0402]  83.09 79.21 90 top
RC62  -  [R_0402]  60.18 76.87 180 bottom
RC63  -  [R_0402]  59.27 74.2 0 bottom
RC64  -  [R_0402]  75.66 17.71 270 bottom
RC65  -  [R_0402]  65.26 41.77 180 bottom
RC66  -  [R_0402]  61.04 74.59 0 top
RC69  -  [R_0402]  82.84 30.19 90 bottom
RC70  -  [R_0402]  58.07 27.14 90 top
RC71  -  [R_0402]  82.84 33.64 270 bottom
RC72  -  [R_0402]  90.2 32.22 90 bottom
RC73  -  [R_0402]  89.32 33.13 270 bottom
RC75  -  [R_0402]  64.96 47.64 0 bottom
RC76  -  [R_0402]  65.19 11.9 90 bottom
RC77  -  [R_0402]  67.73 11.9 90 bottom
RC99  -  [R_0603]  67.28 75.09 180 bottom
RC106  -  [R_0603]  85.25 35.28 270 top
RC109  -  [R_0402]  124.37 83.86 0 top
RC110  -  [R_0402]  125.26 47.2 90 top
RC111  -  [R_0402]  177.96 88.12 270 bottom
RC124  -  [R_0402]  73.95 12.81 270 bottom
RC125  -  [R_0402]  73.95 8.6 90 top
RC126  -  [R_0402]  59.34 75.42 270 top
RC127  -  [R_0402]  74.96 8.6 90 top
RC128  -  [R_0402]  59.27 78.65 0 bottom
RC130  -  [R_0402]  63.79 71.33 90 bottom
RD5  -  [R_0402]  127.8 73.62 90 top
RD8  -  [R0402_0OHM]  130.97 30.69 90 top
RD11  -  [R0402_0OHM]  128.94 31.61 270 top
RD12  -  [R0402_0OHM]  128.69 74.53 270 top
RD19  -  [R0402_0OHM]  128.94 31.61 270 bottom
