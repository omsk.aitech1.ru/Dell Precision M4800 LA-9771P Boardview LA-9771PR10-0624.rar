# Allegro board LA-9771PR10-0624.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 262.42,35.85 262.42,35.09 261.91,34.58 261.91,31.79 261.53,31.41 261.53,30.14 261.27,29.88 259.62,29.88 259.37,30.14 259.37,31.53 260.13,32.29 260.13,34.58 260.77,35.22 260.89,35.22 261.02,35.34 261.02,35.98 261.15,36.1 262.16,36.1
GND on BOTTOM (solid shape): 166.15,66.58 166.15,53.5 166.02,53.38 166.02,51.85 165.59,51.42 165.59,50.03 165.5,49.95 164.88,49.95 164.63,50.2 164.63,50.96 164.37,51.22 164.37,52.49 164.63,52.74 164.63,66.58 164.88,66.84 165.9,66.84
GND on BOTTOM (solid shape): 168.18,34.71 168.18,34.45 168.11,34.2 168.18,33.95 168.18,33.44 167.93,33.18 164.12,33.18 163.86,33.44 163.86,34.71 164.12,34.96 167.93,34.96
GND on BOTTOM (solid shape): 172.25,78.27 172.25,76.74 172.37,76.62 173.01,76.62 173.52,77.13 174.53,77.13 174.79,76.87 174.79,75.86 174.53,75.6 171.48,75.6 171.36,75.73 171.36,78.27 171.61,78.52 171.99,78.52
GND on BOTTOM (solid shape): 246.29,53.38 246.29,50.48 247.18,49.59 247.18,48.8 246.92,48.55 244.13,48.55 243.87,48.8 243.87,49.57 244,49.69 244.76,49.69 245.14,50.07 245.14,50.96 244.89,51.22 242.99,51.22 242.86,51.34 242.86,53.38 243.11,53.63 246.03,53.63
GND on BOTTOM (solid shape): 83.07,140.03 83.07,138.92 83.06,138.92 83.06,137.55 82.85,137.34 82.67,137.34 81.77,138.24 81.76,138.24 81.52,138.48 81.52,139.13 81.47,139.33 81.33,139.49 81.33,140.18 82.92,140.18
GND on BOTTOM (solid shape): 247.91,53.28 247.91,52.5 248.06,52.36 248.14,52.36 249.84,52.36 250.1,52.11 250.1,50.58 249.59,50.07 249.59,48.93 249.34,48.68 247.68,48.68 247.43,48.93 247.43,49.63 246.67,50.39 246.67,53.25 246.82,53.41 247.79,53.41
GND on BOTTOM (solid shape): 264.98,59.5 264.98,58.68 265.13,58.53 266.53,58.53 266.86,58.2 268.13,58.2 268.26,58.08 268.26,57.06 268,56.81 267.37,56.81 266.56,57.62 264.63,57.62 264.45,57.44 264.45,57.19 264.32,57.06 263.56,57.06 262.8,57.82 262.8,58.58 262.92,58.71 264.32,58.71 264.45,58.84 264.45,59.47 264.55,59.57 264.91,59.57
GND on BOTTOM (solid shape): 48.34,155.2 48.52,154.99 48.8,154.97 48.81,154.98 49.79,154.98 50.26,154.51 50.26,153.51 50.04,153.29 48.64,153.29 48.33,153.6 48.33,154.31 48.04,154.61 47.73,154.61 47.58,154.76 47.58,155.02 47.79,155.24 48.32,155.24
GND on BOTTOM (solid shape): 179.29,76.8 179.34,76.8 180.25,76.8 180.56,76.49 181.01,76.49 181.07,76.43 181.07,75.99 180.96,75.87 180.53,75.87 180.03,76.38 180.03,76.5 179.94,76.59 179.64,76.59 179.59,76.6 179.55,76.61 179.34,76.61 179.3,76.6 179.25,76.59 179.07,76.59 178.99,76.67 178.99,76.74 179.05,76.8
GND on BOTTOM (solid shape): 113.33,149.46 113.55,149.37 113.8,149.37 113.8,149.38 114.08,149.38 114.11,149.37 114.78,148.7 114.78,148.51 114.84,148.45 114.84,146.98 114.97,146.85 115.57,146.85 115.71,146.7 115.71,146.4 115.52,146.21 114.23,146.21 114.13,146.11 114.13,144.85 114.07,144.79 113.22,144.79 113.13,144.88 113.13,146.66 112.81,146.98 112.81,149.39 112.89,149.46
GND on BOTTOM (solid shape): 55.41,27.34 55.41,26.94 55.04,26.58 55.02,26.57 54.49,26.11 54.72,25.44 54.72,24.62 54.26,24.17 51.34,24.17 50.45,25.06 50.45,26.71 50.71,26.96 51.34,26.96 51.98,27.6 55.15,27.6
GND on BOTTOM (solid shape): 25.31,160.06 25.31,159.42 24.93,159.04 24.93,157.26 25.43,156.75 25.43,154.47 24.8,153.83 23.78,153.83 23.53,153.58 23.53,152.69 23.43,152.59 23.37,152.56 23.13,152.56 22.94,152.61 22.76,152.56 22.54,152.56 22.36,152.61 22.18,152.56 21.94,152.56 21.89,152.58 21.84,152.6 19.72,154.72 19.72,155.48 19.34,155.87 18.7,155.87 18.58,155.99 18.58,157.39 19.59,157.39 19.72,157.52 19.72,158.28 19.47,158.53 19.21,158.53 19.08,158.66 19.08,159.68 19.59,160.18 25.18,160.18
GND on BOTTOM (solid shape): 48.8,75.98 48.8,69.32 48.75,69.24 48.65,69.23 48.11,68.99 48.47,68.51 48.49,68.51 48.8,68.21 48.8,54.9 47.41,53.5 47.41,45.12 48.8,43.72 48.8,34.71 48.57,34.48 45.73,34.48 45.5,34.71 45.5,53.88 44.61,54.77 44.61,59.09 43.72,59.98 43.72,63.16 44.36,63.79 44.36,73.19 42.83,74.71 42.83,76.11 42.96,76.24 48.55,76.24
GND on BOTTOM (solid shape): 157.27,175.35 157.46,175.27 157.65,175.25 158.15,175.25 158.32,175.17 158.4,175 158.4,174.13 158.4,168.62 158.38,168.58 158.34,168.57 155.99,168.57 155.74,168.82 155.74,170.72 151.62,174.84 95.33,174.84 94.78,174.28 93.13,174.28 89.82,170.98 85.76,170.98 85.51,171.23 85.51,174.28 85.52,174.3 84.91,174.3 84.88,174.3 84.87,174.32 84.74,174.49 84.59,174.62 84.56,174.74 84.65,174.81 91.41,174.81 91.78,174.95 91.97,175.33 92.01,175.35 156.15,175.35
GND on BOTTOM (solid shape): 18.22,88.28 18.22,88.07 17.18,87.03 14.51,87.03 14.26,87.29 7.02,87.29 6.89,87.41 6.89,88.17 7.15,88.43 13.94,88.43 13.95,88.4 14.28,88.17 14.61,88.4 14.63,88.43 14.93,88.43 14.96,88.4 14.99,88.37 14.98,88.33 15.12,87.82 15.61,88.01 15.69,88.08 15.78,88.05 16.54,88.05 16.8,87.79 17.18,87.79 17.43,88.05 17.43,88.3 17.69,88.56 17.94,88.56
GND on BOTTOM (solid shape): 150.03,50.1 150.03,29.58 149.9,29.44 147.19,29.44 146.95,29.68 146.95,33.37 147,33.46 147.1,33.46 147.48,33.46 147.49,33.45 147.94,33.88 147.35,34.05 147.33,34.03 147.26,34.03 147.26,34.11 147.02,34.35 146.95,34.35 146.95,44.15 147.07,44.15 147.08,44.16 147.1,44.16 147.51,44.53 147.07,44.86 146.98,44.88 146.95,44.96 146.95,49.89 147.32,50.26 149.87,50.26
GND on BOTTOM (solid shape): 150.07,90.83 150.07,68.8 149.98,68.71 147.03,68.71 146.95,68.79 146.95,69.95 147.09,69.95 148.11,70.97 148.11,71.55 147.91,72.2 147.72,71.55 147.72,71.14 147.13,70.55 147.01,70.52 146.95,70.62 146.95,74.75 147.21,74.75 147.59,74.38 147.59,74.35 148.19,74.05 147.89,74.66 147.87,74.66 147.37,75.15 146.95,75.15 146.95,90.84 147.03,90.91 149.98,90.91
GND on BOTTOM (solid shape): outline of 91 points within 121.45,29.37 136.43,90.71
GND on BOTTOM (solid shape): 48.87,144.44 49.15,144.34 49.44,144.4 49.47,144.42 49.61,144.27 49.61,144.11 49.56,144.03 49.46,144.03 48.77,143.92 48.73,143.23 48.8,142.51 49.52,142.47 49.54,142.49 49.61,142.49 49.61,136.64 49.43,136.46 46,136.46 45.56,136.9 45.56,138.01 45.6,138.05 46.57,138.05 47.24,138.72 47.24,139.51 46.9,139.85 46.91,139.89 46.94,140.11 46.83,140.3 46.51,140.39 46.26,140.17 46.25,140.14 45.67,140.14 45.55,140.25 45.55,140.8 45.57,140.84 45.6,140.85 45.78,140.92 45.9,141.07 45.93,141.19 45.92,141.31 45.91,141.34 46.11,141.54 46.5,141.54 46.56,141.45 46.64,141.38 46.64,141.35 47.1,140.89 47.1,140.87 47.58,140.67 47.37,141.15 47.35,141.15 47.07,141.43 47.1,141.47 47.12,141.5 47.14,141.54 47.85,141.54 48.17,141.86 48.17,141.96 48.19,141.96 48.19,143.1 48.17,143.1 48.17,144.14 48.46,144.44
GND on BOTTOM (solid shape): 58.12,99.68 58.12,99.67 58.2,99.56 58.32,99.48 58.33,99.47 58.45,99.35 58.65,99.35 58.75,99.29 58.73,99.18 58.69,99.14 58.58,98.97 58.56,98.77 58.55,98.73 58.52,98.71 58.42,98.68 58.34,98.62 58.27,98.59 58.2,98.62 57.59,98.36 58.2,98.11 58.27,98.14 58.34,98.11 58.7,98.03 58.94,98.32 58.96,98.35 58.99,98.36 59.04,98.36 59.08,98.35 59.1,98.32 59.33,98.03 59.7,98.11 59.77,98.14 59.84,98.11 60.11,98.01 60.37,98.15 60.44,98.19 60.52,98.16 60.74,97.94 60.74,96.8 60.13,96.19 60.13,96.05 60.1,96 60.04,96.01 60.02,96.04 59.84,96.16 59.62,96.2 59.19,96.2 58.93,95.95 56.52,95.95 56.44,95.94 56.36,95.92 56.3,95.92 56.17,96.05 56.17,97.7 56.55,98.08 56.93,98.08 57.31,98.46 57.31,98.92 57.31,98.92 57.31,99.48 57.57,99.73 58.07,99.73
GND on BOTTOM (solid shape): outline of 209 points within 257.46,121.07 262.16,128.18
GND on BOTTOM (solid shape): outline of 245 points within 85.53,47.15 93.58,68.11
GND on BOTTOM (solid shape): outline of 322 points within 4.35,74.71 23.15,80.81
GND on BOTTOM (solid shape): outline of 1509 points within 0.26,0.26 94.92,178.45
GND on BOTTOM (solid shape): outline of 2151 points within 97.28,13.2 275.3,175.35
GND on GND1 (solid shape): outline of 170016 points within 0.26,0.26 275.3,178.45
GND on IN1 (solid shape): 47.28,74.97 47.28,70.01 47.02,69.76 44.48,69.76 44.23,70.01 44.23,74.97 44.48,75.22 47.02,75.22
GND on IN1 (solid shape): 47.41,59.28 47.41,54.33 47.15,54.07 44.61,54.07 44.36,54.33 44.36,59.28 44.61,59.54 47.15,59.54
GND on IN1 (solid shape): 49.06,43.35 49.06,39.53 48.61,39.09 46.01,39.09 45.5,39.6 45.5,44.23 45.75,44.49 47.92,44.49
GND on IN1 (solid shape): 90.73,174.18 90.73,171.19 90.47,170.93 86.59,170.93 86.21,171.31 86.21,174.22 86.45,174.46 90.45,174.46
GND on IN1 (solid shape): 11.99,177.26 11.99,176.89 12.19,176.69 12.19,175.69 11.99,175.49 11.99,172.98 12.19,172.78 12.21,172.78 12.23,172.77 12.23,172.58 12,172.36 11.99,172.36 11.99,168.09 11.18,167.28 8.31,167.28 7.95,167.64 7.95,171.88 7.72,172.11 7.72,172.4 7.95,172.62 7.95,176.87 7.73,177.09 7.73,177.37 7.8,177.44 11.81,177.44
GND on IN1 (solid shape): 52.42,177.93 52.42,176.99 53.04,176.37 58.68,176.37 58.94,176.11 58.94,175.14 59,175.08 59.11,175.08 59.59,174.6 65.1,174.6 65.2,174.7 65.4,174.7 65.53,174.58 65.53,174.42 65.45,174.34 65.45,171.15 65.12,170.82 61.47,170.82 60.02,169.37 60.02,164.99 58.74,163.71 55.65,163.71 50.77,168.59 50.77,172.18 49.9,173.05 49.57,173.05 49.38,173.24 49.38,177.58 50.15,178.35 52,178.35
GND on IN1 (solid shape): 32.79,178.12 33.62,178.12 34.27,177.47 34.27,176.54 35.1,175.71 35.1,172.26 34,171.07 35.26,170.06 35.26,168.79 34.83,168.35 25.79,168.35 25.39,167.96 24.09,167.96 23.55,168.5 23.55,172.13 23,172.68 23,177.26 23.19,177.44 26.05,177.44 27.02,176.48 32.27,176.48 32.27,177.66 32.74,178.13 32.78,178.13
GND on IN1 (solid shape): 157.27,175.35 157.46,175.27 157.65,175.25 158.15,175.25 158.32,175.17 158.4,175 158.4,174.5 158.4,168.57 157.26,168.57 157.01,168.82 157.01,172.38 154.54,174.84 92.33,174.84 91.94,174.44 91.41,174.3 84.88,174.3 84.6,174.62 84.22,174.81 91.41,174.81 91.76,174.93 91.95,175.26 91.96,175.3 91.98,175.33 92.01,175.35 156.45,175.35
GND on IN1 (solid shape): outline of 583 points within 0.26,0.26 275.3,178.45
GND on VCC (solid shape): 157.27,175.35 157.46,175.27 157.65,175.25 158.15,175.25 158.32,175.17 158.4,175 158.4,174.05 158.4,168.57 156.59,168.57 156.2,168.18 155.97,168.18 155.74,168.42 155.74,175.19 155.89,175.35 156.34,175.35
GND on VCC (solid shape): 174.84,175.35 175.72,174.98 176.09,174.1 176.09,172.9 176.6,171.66 177.84,171.15 179.55,171.15 180.43,170.78 180.8,169.9 180.8,161.45 181.12,160.61 181.92,160.2 181.94,160.2 182.05,160.2 182.25,160.2 182.78,159.98 183,159.45 183,156.66 182.55,155.71 181.53,155.44 177.87,153.23 179.56,149.3 179.88,149 180,148.58 180,138.66 179.81,138.47 179.77,138.47 179.66,138.53 179.54,138.57 179.5,138.58 179.5,145.03 176.56,147.97 176.56,148.25 176.6,148.25 177.2,148.84 177.2,154.51 176.18,155.52 176.18,166.45 174.06,168.57 173.49,168.57 173.11,168.95 173.11,175 173.18,175.17 173.35,175.25 173.89,175.25 174.07,175.28 174.22,175.35
GND on VCC (solid shape): outline of 1102 points within 30.51,0.26 81.35,68.36
GND on VCC (solid shape): outline of 2644 points within 249.84,105.19 275.3,174.45
GND on VCC (solid shape): outline of 2942 points within 6.26,160.56 91.45,178.45
GND on VCC (solid shape): outline of 6674 points within 93.89,25.82 161.2,48.14
GND on VCC (solid shape): outline of 7790 points within 91.86,65.67 161.45,91.32
GND on IN2 (solid shape): 90.73,174.18 90.73,171.19 90.47,170.93 86.59,170.93 86.21,171.31 86.21,174.22 86.45,174.46 90.45,174.46
GND on IN2 (solid shape): 12.15,177.33 12.15,172.45 12.07,172.37 11.99,172.37 11.99,168.09 11.18,167.28 8.38,167.28 8.01,167.65 7.95,167.65 7.8,167.8 7.8,177.39 8.02,177.61 11.87,177.61
GND on IN2 (solid shape): 52.42,177.93 52.42,176.99 53.04,176.37 58.68,176.37 58.94,176.11 58.94,175.23 59.57,174.6 65.05,174.6 65.14,174.69 65.45,174.69 65.51,174.64 65.51,174.41 65.45,174.35 65.45,171.15 65.12,170.82 61.47,170.82 60.02,169.37 60.02,164.99 58.74,163.71 55.65,163.71 50.77,168.59 50.77,172.18 49.9,173.05 49.57,173.05 49.38,173.24 49.38,177.63 50.1,178.35 52,178.35
GND on IN2 (solid shape): 34.36,177.4 34.36,176.45 35.1,175.71 35.1,172.26 34,171.07 35.26,170.06 35.26,168.79 34.83,168.35 25.79,168.35 25.39,167.96 24.09,167.96 23.55,168.5 23.55,172.13 23,172.68 23,176.49 22.95,176.54 22.95,177.23 23.17,177.44 26.05,177.44 27.02,176.48 32.16,176.48 32.31,176.62 32.31,177.83 32.68,178.19 33.57,178.19
GND on IN2 (solid shape): 157.27,175.35 157.46,175.27 157.65,175.25 158.15,175.25 158.32,175.17 158.4,175 158.4,174.26 158.4,168.57 157.26,168.57 157.01,168.82 157.01,172.38 154.54,174.84 92.33,174.84 91.94,174.44 91.41,174.3 84.88,174.3 84.6,174.62 84.22,174.81 91.41,174.81 91.76,174.93 91.95,175.26 91.96,175.3 91.98,175.33 92.01,175.35 156.13,175.35
GND on IN2 (solid shape): outline of 221 points within 0.26,0.26 85,178.45
GND on IN2 (solid shape): outline of 311 points within 97.03,13.48 275.3,175.35
GND on IN2 (solid shape): outline of 7211 points within 88.81,68.32 161.45,95.41
GND on IN2 (solid shape): outline of 8034 points within 91.6,21.75 162.59,51.98
GND on IN2 (solid shape): outline of 8037 points within 71.79,39.15 90.59,70.01
GND on IN3 (solid shape): 47.28,74.97 47.28,70.01 47.02,69.76 44.48,69.76 44.23,70.01 44.23,74.97 44.48,75.22 47.02,75.22
GND on IN3 (solid shape): 47.41,59.28 47.41,54.33 47.15,54.07 45.18,54.07 44.36,54.9 44.36,59.28 44.61,59.54 47.15,59.54
GND on IN3 (solid shape): 49.06,43.49 49.06,39.53 48.61,39.09 46.01,39.09 45.5,39.6 45.5,44.23 45.75,44.49 48.06,44.49
GND on IN3 (solid shape): 90.73,174.18 90.73,171.19 90.47,170.93 86.59,170.93 86.21,171.31 86.21,174.22 86.45,174.46 90.45,174.46
GND on IN3 (solid shape): 12.13,177.34 12.13,172.42 12.05,172.34 11.99,172.34 11.99,168.09 11.18,167.28 8.36,167.28 7.68,167.96 7.68,177.31 7.95,177.59 11.87,177.59
GND on IN3 (solid shape): 52.42,177.93 52.42,176.99 53.04,176.37 58.68,176.37 58.94,176.11 58.94,175.14 59.48,174.6 65,174.6 65.15,174.75 65.5,174.75 65.63,174.61 65.63,174.46 65.45,174.28 65.45,171.46 65.05,171.06 56.16,171.06 53.79,173.43 49.5,173.43 49.38,173.55 49.38,177.6 50.11,178.33 50.11,178.35 52,178.35
GND on IN3 (solid shape): 33.86,177.86 33.86,176.95 35.1,175.71 35.1,172.26 34,171.07 35.26,170.06 35.26,168.79 34.83,168.35 25.79,168.35 25.39,167.96 24.09,167.96 23.55,168.5 23.55,172.13 23,172.68 23,176.53 22.93,176.61 22.93,177.27 23.11,177.44 26.05,177.44 27.02,176.48 32.25,176.48 32.25,177.5 32.88,178.13 33.58,178.13
GND on IN3 (solid shape): 157.27,175.35 157.46,175.27 157.65,175.25 158.15,175.25 158.32,175.17 158.4,175 158.4,174.33 158.4,168.57 157.26,168.57 157.01,168.82 157.01,172.38 154.54,174.84 92.33,174.84 91.94,174.44 91.41,174.3 84.88,174.3 84.6,174.62 84.22,174.81 91.41,174.81 91.76,174.93 91.95,175.26 91.96,175.3 91.98,175.33 92.01,175.35 156.41,175.35
GND on IN3 (solid shape): outline of 542 points within 0.26,0.26 275.3,178.45
GND on GND2 (solid shape): outline of 170067 points within 0.26,0.26 275.3,178.45
GND on IN4 (solid shape): 47.28,74.97 47.28,70.01 47.02,69.76 44.48,69.76 44.23,70.01 44.23,74.97 44.48,75.22 47.02,75.22
GND on IN4 (solid shape): 47.41,59.28 47.41,54.33 47.15,54.07 44.61,54.07 44.36,54.33 44.36,59.28 44.61,59.54 47.15,59.54
GND on IN4 (solid shape): 49.06,43.47 49.06,39.53 48.93,39.41 45.69,39.41 45.5,39.6 45.5,44.23 45.75,44.49 48.04,44.49
GND on IN4 (solid shape): 90.73,174.18 90.73,171.19 90.59,171.06 86.47,171.06 86.21,171.31 86.21,174.22 86.45,174.46 90.45,174.46
GND on IN4 (solid shape): 12.23,177.18 12.23,172.46 12.15,172.37 11.99,172.37 11.99,170.44 11.39,169.84 11.39,167.49 11.18,167.28 8.31,167.28 7.95,167.65 7.95,171.56 7.71,171.79 7.71,177.35 7.8,177.44 8.13,177.44 8.14,177.44 11.97,177.44
GND on IN4 (solid shape): 52.42,177.93 52.42,176.99 53.04,176.37 58.68,176.37 58.94,176.11 58.94,175.14 59.48,174.6 65.05,174.6 65.17,174.72 65.45,174.72 65.52,174.65 65.52,174.45 65.4,174.33 65.45,174.28 65.45,171.68 64.93,171.15 61.8,171.15 59.66,169.02 59.66,164.64 58.74,163.71 55.65,163.71 50.77,168.59 50.77,172.18 49.9,173.05 49.57,173.05 49.38,173.24 49.38,177.52 50.21,178.35 52,178.35
GND on IN4 (solid shape): 33.97,177.78 33.97,176.61 34.11,176.48 34.34,176.48 35.1,175.71 35.1,172.26 34,171.07 35.26,170.06 35.26,168.79 34.83,168.35 25.79,168.35 25.39,167.96 24.09,167.96 23.55,168.5 23.55,172.13 23,172.68 23,176.56 22.98,176.58 22.98,177.32 23.1,177.44 26.05,177.44 27.02,176.48 32.14,176.48 32.32,176.65 32.32,177.74 32.76,178.17 33.58,178.17
GND on IN4 (solid shape): 157.27,175.35 157.46,175.27 157.65,175.25 158.15,175.25 158.32,175.17 158.4,175 158.4,174.06 158.4,168.57 157.26,168.57 157.01,168.82 157.01,172.38 154.54,174.84 92.33,174.84 91.94,174.44 91.41,174.3 84.88,174.3 84.6,174.62 84.22,174.81 91.41,174.81 91.76,174.93 91.95,175.26 91.96,175.3 91.98,175.33 92.01,175.35 156.29,175.35
GND on IN4 (solid shape): outline of 240 points within 0.26,0.26 95.07,178.45
GND on IN4 (solid shape): outline of 309 points within 98.02,13.48 275.3,175.35
GND on GND3 (solid shape): outline of 170177 points within 0.26,0.26 275.3,178.45
GND on TOP: 32.37,136.9 34.59,136.9 34.65,136.84 34.65,135.94 33.93,135.21 33.93,133.18 34.1,133.02 34.9,133.02 35.12,133.25 35.12,135.28 35.64,135.8 36.17,135.8 36.32,135.65 36.32,135.32 35.77,134.77 35.77,131.44 34.83,130.5 32.61,130.5 32.1,131.01 32.1,136.64
GND on TOP: 221.75,19.1 221.58,19.27 221.58,19.7 221.33,19.96 204.92,19.96 204.55,20.32 204.55,34.86 202,37.41 177.97,37.41 176.44,38.94 176.44,51.55 177.27,52.37 195.68,52.37 196.57,53.26 196.57,60.55 195.35,61.77 185.95,61.77 185.14,62.58 185.14,71.11 185.6,71.56 194.76,71.56 223.7,42.62 229.27,42.62 230.04,43.39 230.04,56.26 232.96,59.18 242.91,59.18 246.09,62.36 255.07,62.36 261.38,56.06 263.14,56.06 263.73,56.65 263.73,57.04 262.79,57.98 262.79,58.72 263.4,59.33 266.59,59.33 268.11,57.8 268.11,47.55 263.36,42.8 242.78,42.8 239.9,39.92 239.9,36.56 240.77,35.69 262.66,35.69 270.38,43.41 270.38,57.89 261.36,66.92 261.36,68.51 256.54,73.33 256.54,84.52 259.55,87.53 264.8,87.53 274.29,78.04 274.29,38.57 264.58,28.87 264.58,23.76 261.83,21.02 230.35,21.02 229.74,21.63 229.74,24.96 228.69,26.01 226.25,26.01 225.29,25.05 225.29,19.47 224.92,19.1
GND_CHASSIS on TOP (solid shape): 175.18,151.07 175.18,150.01 175.07,149.9 172.98,149.9 172.86,150.02 172.86,152.03 173.39,152.56 173.68,152.56
GND_CHASSIS on BOTTOM (solid shape): 167.55,158.41 167.55,157.77 167.29,157.52 166.56,157.52 165.74,157.52 165.62,157.52 164.85,157.52 164.73,157.52 163.33,157.52 163.15,157.69 163.15,158.58 163.23,158.66 167.29,158.66
+BL_PWR_SRC on TOP (solid shape): 53.76,155.61 53.76,154.34 53.5,154.09 52.74,154.09 52.49,154.34 51.09,154.34 51.09,155.74 51.22,155.87 53.5,155.87
+BL_PWR_SRC on BOTTOM (solid shape): 52.36,154.85 55.66,154.85 55.91,154.6 55.91,153.33 55.66,153.07 52.72,153.07 52.54,153.12 52.35,153.07 51.12,153.07 51.12,153.16 50.83,153.44 50.83,155.3 51.01,155.46 51.08,155.69 51.08,155.74 51.47,155.74
+CAMERA_VDD on TOP (solid shape): 51.95,151.93 52.36,151.93 52.49,151.8 57.82,151.8 58.07,151.55 58.07,150.15 58.33,149.9 58.33,148.12 58.07,147.86 57.06,147.86 56.8,148.12 56.8,149.46 55.53,150.73 51.9,150.73 50.82,151.82 49.69,151.82 49.64,151.88 49.64,152.02 49.69,152.08 51.8,152.08
+CAP_LDO on TOP (solid shape): outline of 175 points within 215.57,84.29 219.64,90.59
+CHAGER_SRC on BOTTOM (solid shape): 196,49.31 196,39.91 195.74,39.66 191.3,39.66 191.04,39.91 191.04,43.85 190.79,44.11 184.82,44.11 184.69,44.23 184.69,44.99 184.82,45.12 186.47,45.12 187.23,45.88 190.41,45.88 190.79,46.26 190.79,49.31 191.04,49.57 195.74,49.57
+DC1_PWR_SRC on BOTTOM (solid shape): 249.72,47.79 252.61,47.79 252.89,47.51 252.89,43.85 252.64,43.6 243.75,43.6 242.73,42.58 241.21,42.58 240.95,42.84 240.95,44.87 240.45,45.38 240.45,47.79 240.7,48.04 249.46,48.04
+DC1_PWR_SRC on BOTTOM (solid shape): 247.09,58.3 247.09,58.11 247.08,58.06 247.07,58.02 247.07,57.49 247.43,57.13 247.49,57.13 247.86,56.77 247.86,55.99 247.67,55.8 246.66,55.8 246.59,55.88 246.59,56.47 246.9,56.78 246.9,57.08 246.9,57.1 246.9,58.31 246.94,58.35 247.04,58.35
+DC_IN on BOTTOM (solid shape): 23.02,79.03 23.02,76.49 22.77,76.24 20.23,76.24 18.83,74.84 18.83,72.68 18.58,72.43 15.78,72.43 15.53,72.68 15.53,74.97 16.04,75.47 16.04,77.25 16.29,77.51 18.7,77.51 20.48,79.28 22.77,79.28
+DC_IN_SS on BOTTOM (solid shape): outline of 123 points within 13.24,66.71 25.82,74.59
+DCIN_JACK on BOTTOM (solid shape): outline of 354 points within 6.89,81.32 20.52,87.85
+DOCK_PWR_BAR on TOP (solid shape): outline of 7209 points within 108.49,43.34 229.14,135.04
+DOCK_PWR_BAR on BOTTOM (solid shape): 229.14,48.93 229.14,39.15 229.02,39.03 228.76,39.03 228.74,39.03 228.13,39.03 227.75,38.64 223.17,38.64 222.92,38.9 222.92,43.98 222.54,44.36 222.03,44.36 221.78,44.11 218.86,44.11 218.73,44.23 218.73,45.63 218.86,45.76 222.41,45.76 222.67,46.01 222.67,48.68 222.97,48.98 229.09,48.98
+DP_VCC on BOTTOM (solid shape): outline of 108 points within 260.31,146.14 268.13,158.04
+LCDVDD on TOP (solid shape): 50.98,153.52 50.98,152.86 50.92,152.8 49.41,152.8 48.96,152.36 47.59,152.36 47.33,152.61 47.33,153.09 47.82,153.58 50.91,153.58
+LCDVDD on TOP (solid shape): 41.26,134.97 41.26,133.6 40.85,133.18 39.84,133.18 39.59,132.93 38.38,132.93 38.13,133.17 38.13,134.91 38.26,135.04 40.19,135.04 40.52,135.37 40.86,135.37
+LCDVDD on BOTTOM (solid shape): 48.17,154.21 48.17,153.45 48.8,152.82 48.8,152.23 48.77,152.21 48.73,152.18 48.49,151.93 48.4,151.93 48.04,151.93 47.99,151.88 47.23,151.88 47.16,151.87 47.08,151.85 47.02,151.85 46.96,151.85 46.9,151.84 46.87,151.83 46.77,151.93 46.77,154.21 47.02,154.47 47.91,154.47
+LCDVDD on IN2 (solid shape): 48.93,153.07 48.93,152.31 48.68,152.06 47.28,152.06 46.9,152.44 46.9,153.07 47.04,153.21 48.79,153.21
+MXM_PWR_SRC on TOP (solid shape): 143.67,111.67 143.67,104.81 143.54,104.68 142.15,104.68 141.51,105.32 134.65,105.32 134.4,105.07 134.4,102.25 134.33,102.16 134.22,102.19 133.59,101.97 134.22,101.74 134.33,101.77 134.4,101.68 134.4,96.18 134.27,96.05 129.96,96.05 129.83,96.18 129.83,103.54 130.08,103.8 130.08,106.72 129.7,107.1 129.7,111.83 130.17,112.3 143.04,112.3
+PCH_USB_DCPSUS3 on IN2 (solid shape): outline of 233 points within 37.98,103.29 39.31,108.58
+PCH_VCCCLK on BOTTOM (solid shape): 34.45,120.56 34.45,117.64 34.39,117.49 34.35,117.33 34.37,117.1 34.44,116.89 34.45,116.88 34.45,116.75 34.95,116.25 34.95,115.09 34.74,114.88 33.9,114.88 33.82,114.97 33.82,115.48 33.05,116.24 33.05,119.29 33.69,119.92 33.69,120.1 33.71,120.13 33.71,120.58 33.94,120.81 33.99,120.81 34.2,120.81
+PCH_VCCCLK on BOTTOM (solid shape): 35.34,104.18 35.34,102.14 35.21,102.02 34.96,102.02 34.83,101.89 34.83,101.26 34.71,101.13 34.2,101.13 33.94,101.38 33.94,101.89 33.95,102.53 33.44,102.14 33.42,102.05 33.34,102.02 33.05,102.02 32.82,102.25 32.8,102.33 32.8,103.16 33.05,103.41 33.31,103.41 33.56,103.67 33.56,104.3 33.69,104.43 34.32,104.43 34.45,104.56 34.96,104.56
+PCH_VCCCLK on IN2 (solid shape): outline of 1015 points within 30.64,101.89 36.36,119.16
+PCH_VCCCLK3_3 on TOP (solid shape): 28.65,102.2 28.95,102.05 29.25,102.2 29.33,102.16 29.44,102.08 29.57,102.06 29.79,102.06 29.88,101.97 29.88,101.8 29.88,101.76 29.88,101.03 29.88,100.99 29.88,100.95 29.88,100.49 29.63,100.24 28.86,100.24 28.61,100.49 28.61,100.5 28.61,101.24 28.61,101.25 28.6,101.48 28.42,101.63 28.4,101.63 28.36,101.68 28.36,102.02 28.4,102.06 28.41,102.06 28.5,102.1 28.57,102.16
+PCH_VCCCLK3_3 on BOTTOM (solid shape): 17.99,107.43 17.99,106.84 18.47,106.36 18.73,106.36 19.62,105.47 19.69,105.47 19.72,105.45 19.72,104.68 19.47,104.43 19.21,104.43 18.96,104.68 18.45,104.68 18.2,104.94 18.2,105.32 17.94,105.57 17.43,105.57 17.15,105.86 17.15,107.6 17.19,107.63 17.79,107.63
+PCH_VCCCLK3_3 on IN3 (solid shape): outline of 752 points within 18.7,100.24 31.4,105.95
+PWR_SRC on TOP (solid shape): 34.58,68.96 34.58,65.95 34.46,65.83 30.77,65.83 30.51,66.08 30.51,68.95 30.9,69.33 34.21,69.33
+PWR_SRC on TOP (solid shape): 160.31,99.35 160.31,93.51 160.05,93.25 155.86,93.25 155.61,93.51 155.61,100.49 155.86,100.75 158.91,100.75
+PWR_SRC on TOP (solid shape): 184.44,64.43 184.44,61.89 184.18,61.63 175.8,61.63 175.55,61.89 175.55,64.43 175.8,64.68 184.18,64.68
+PWR_SRC on BOTTOM (solid shape): 16.98,141.05 16.98,138.94 16.86,138.82 15.29,138.82 15.16,138.95 15.16,140.96 15.3,141.1 16.94,141.1
+PWR_SRC on BOTTOM (solid shape): 184.44,24.42 184.44,21.88 184.18,21.63 178.22,21.63 177.96,21.88 177.96,24.42 178.22,24.67 184.18,24.67
+PWR_SRC on BOTTOM (solid shape): 249.34,42.84 249.34,39.03 249.08,38.77 244.64,38.77 244.38,39.03 244.38,42.84 244.64,43.09 249.08,43.09
+PWR_SRC on BOTTOM (solid shape): 158.75,102.12 158.75,101.45 158.69,100.3 158.69,99.03 158.43,98.78 155.89,98.78 155.51,99.16 155.51,101.89 155.95,102.32 158.55,102.32
+PWR_SRC on BOTTOM (solid shape): 56.38,158.58 56.38,155.39 56.09,155.1 54.87,155.1 54.71,155.27 54.71,156.69 53.95,157.45 53.95,159.25 54.09,159.39 55.57,159.39
+PWR_SRC on BOTTOM (solid shape): 80.55,9.94 80.55,4.86 80.3,4.61 75.9,4.61 75.81,4.61 74.58,4.61 74.33,4.86 74.33,6.26 78.14,10.07 80.43,10.07
+PWR_SRC on BOTTOM (solid shape): 226.6,53.12 226.6,49.69 226.48,49.57 222.67,49.57 222.28,49.19 222.28,46.39 222.03,46.14 218.47,46.14 218.22,46.39 218.22,51.64 218.69,52.11 221.27,52.11 222.54,53.38 226.35,53.38
+PWR_SRC on BOTTOM (solid shape): 190.53,43.47 190.53,40.29 190.31,40.06 186.2,40.06 185.91,39.78 185.91,38.17 185.66,37.91 182.35,37.91 181.96,37.52 181.96,33.78 181.48,33.31 176.56,33.31 176.31,33.56 176.31,39.03 176.69,39.41 179.61,39.41 183.93,43.72 190.28,43.72
+PWR_SRC on BOTTOM (solid shape): 36.24,68.56 36.24,65.95 36.15,65.85 30.36,65.85 30.26,65.95 30.26,67.87 30.6,68.21 31.61,68.21 32.02,68.62 32.02,69.19 32.04,69.21 33.55,69.21 33.77,69.43 33.77,69.75 33.53,69.99 32.08,69.99 32.03,70.03 32.03,70.64 32.18,70.79 34.02,70.79
+PWR_SRC on BOTTOM (solid shape): 176.39,64.12 176.39,63.59 176.41,63.56 177.12,63.56 177.17,63.61 177.17,64.09 177.2,64.12 177.55,64.12 177.61,64.07 177.61,63.61 177.63,63.59 178.34,63.59 178.37,63.61 178.37,64.12 178.39,64.15 179.03,64.15 179.31,63.87 179.31,62.32 179.15,62.16 175.65,62.16 175.42,62.39 175.42,63.79 175.78,64.15 176.36,64.15
+PWR_SRC on BOTTOM (solid shape): outline of 81 points within 173.11,135.64 176.69,140.9
+PWR_SRC on IN1 (solid shape): 149.89,174.28 149.89,172.25 149.64,171.99 144.31,171.99 144.05,172.25 144.05,174.28 144.31,174.53 149.64,174.53
+PWR_SRC on IN1 (solid shape): 177.83,141.39 177.83,138.85 177.1,138.11 175.45,138.11 174.71,138.86 174.71,140.11 175.71,141.12 176.3,141.12 176.82,141.64 177.58,141.64
+PWR_SRC on IN2 (solid shape): 35.09,68.24 35.09,65.87 35.03,65.81 29.3,65.81 28.99,66.12 28.99,68.11 29.37,68.49 34.83,68.49
+PWR_SRC on IN2 (solid shape): 184.57,24.42 184.57,20.86 184.31,20.61 178.22,20.61 177.96,20.86 177.96,24.42 178.22,24.67 184.31,24.67
+PWR_SRC on IN2 (solid shape): 80.55,11.09 80.55,4.86 80.3,4.61 74.58,4.61 74.33,4.86 74.33,6.26 77.38,9.31 77.38,11.09 77.63,11.34 80.3,11.34
+PWR_SRC on IN3 (solid shape): 149.89,174.28 149.89,172.25 149.64,171.99 144.31,171.99 144.05,172.25 144.05,174.28 144.31,174.53 149.64,174.53
+PWR_SRC on IN3 (solid shape): 35.09,68.52 35.09,65.98 34.95,65.85 29.34,65.85 28.99,66.2 28.99,68.54 29.25,68.8 34.81,68.8
+PWR_SRC on IN3 (solid shape): 177.83,141.39 177.83,138.85 177.15,138.17 175.26,138.17 174.67,138.75 174.67,140.59 175.17,141.09 176.27,141.09 176.82,141.64 177.58,141.64
+PWR_SRC on IN3 (solid shape): 80.55,11.09 80.55,4.86 80.3,4.61 74.58,4.61 74.33,4.86 74.33,6.26 77.38,9.31 77.38,11.09 77.63,11.34 80.3,11.34
+PWR_SRC on IN3 (solid shape): 187.36,43.34 187.36,38.37 187.16,38.03 187.36,37.69 187.36,31.91 187.11,31.66 176.44,31.66 176.18,31.91 176.18,40.3 176.44,40.55 179.61,40.55 179.87,40.8 179.87,43.34 180.12,43.6 187.11,43.6
+PWR_SRC on IN4 (solid shape): 149.89,174.28 149.89,172.25 149.64,171.99 144.05,171.99 144.05,174.53 149.64,174.53
+PWR_SRC on IN4 (solid shape): 16.35,140.75 16.35,139 16.17,138.82 14.8,138.82 14.33,139.29 14.33,140.79 14.6,141.06 16.04,141.06
+PWR_SRC on IN4 (solid shape): 55.15,162.6 55.15,157.64 54.9,157.39 52.61,157.39 52.36,157.64 52.36,162.6 52.61,162.85 54.9,162.85
+PWR_SRC on IN4 (solid shape): outline of 2302 points within 174.41,23.53 249.97,64.43
+PWR_SRC_MXM on TOP (solid shape): 149.94,108.06 149.94,107.4 150.08,107.26 152.25,107.26 152.41,107.1 154.09,107.1 156.88,104.3 156.88,101.38 156.63,101.13 147.23,101.13 146.97,101.38 146.97,107.61 147.35,107.99 149.01,107.99 149.13,108.11 149.89,108.11
+SDC_IN on BOTTOM (solid shape): 29.52,74.81 30.97,74.81 31.51,74.26 31.51,73.56 32.01,73.06 32.01,72.11 32.11,72.01 32.11,70.98 32.04,70.9 31.18,70.9 30.98,70.69 30.98,70.03 30.93,69.99 29.47,69.99 29.24,69.75 29.24,69.44 29.47,69.21 30.97,69.21 30.99,69.19 30.99,68.46 30.86,68.34 29.73,68.34 29.5,68.11 26.58,68.11 26.32,68.36 26.32,71.03 24.8,72.55 24.8,74.97 25.05,75.22 29.11,75.22
+SW_LX on BOTTOM (solid shape): 75.83,142.2 75.83,142 75.73,141.9 75.73,140.75 76.23,140.24 76.23,138.59 76.11,138.47 75.03,138.47 74.95,138.54 74.95,141.86 75.41,142.31 75.71,142.31
+SWR_V12 on TOP (solid shape): outline of 303 points within 74.84,141.51 80.17,151.55
+SWR_V12 on BOTTOM (solid shape): 76.75,143.17 76.83,143.13 76.85,143.04 76.84,142.98 76.85,142.92 77.07,142.63 77.44,142.7 77.5,142.72 77.57,142.7 77.7,142.62 77.85,142.61 78.09,142.75 78.16,143.02 78.19,143.09 78.26,143.13 78.37,143.13 79.34,142.16 79.42,142.16 79.62,141.97 79.71,141.97 79.79,141.88 79.84,141.88 79.89,141.83 79.89,141.43 79.92,141.41 79.92,141.01 78.39,139.48 78.39,138.59 78.27,138.47 77.25,138.47 77.12,138.59 77.12,139.99 77.99,140.85 78.06,140.85 78.09,140.88 78.62,140.88 78.63,140.88 78.77,140.85 78.92,140.88 78.93,140.88 79.03,140.88 79.16,141.01 79.16,141.06 79.16,141.07 79.23,141.31 79.16,141.55 79.16,141.56 79.16,141.64 78.65,142.15 77.63,142.15 77.38,141.9 76.87,141.9 76.74,142.02 76.74,142.53 76.64,142.63 76.51,142.63 76.36,142.78 76.36,143.04 76.49,143.17
+VCHGR on BOTTOM (solid shape): 211.13,46.38 211.13,44.89 211.35,44.68 211.69,44.68 211.91,44.89 211.91,46.37 211.95,46.4 212.9,46.4 213.17,46.14 213.17,43.86 213.31,43.72 217.2,43.72 217.59,43.34 217.59,39.43 216.24,38.09 212.61,38.09 212.43,38.26 212.43,39.13 211.9,39.66 209.09,39.66 208.85,39.9 208.85,40.46 208.5,40.8 206.74,40.8 206.61,40.93 206.61,44.38 206.82,44.59 210.23,44.59 210.42,44.78 210.42,46.34 210.5,46.42 211.1,46.42
+VDISPLAY_VCC on BOTTOM (solid shape): outline of 149 points within 21.13,161.96 24.29,170.49
BOOT1 on TOP (solid shape): 54.47,31.02 54.47,30.41 54.64,30.24 54.64,29.25 54.05,28.65 54.05,28.62 54.02,28.6 54.02,28.24 54.03,28.18 54.05,28.12 54.05,27.84 54,27.79 53.87,27.79 53.82,27.84 53.82,28.7 54.24,29.12 54.24,30.16 54.03,30.36 53.58,30.36 53.5,30.44 53.5,31.02 53.63,31.15 54.34,31.15
BOOT2 on TOP (solid shape): 48.88,28.13 48.88,27.9 49.87,26.91 51.32,26.91 51.34,26.88 51.34,26.73 51.31,26.7 50.94,26.7 50.89,26.7 50.01,26.7 50,26.71 49.86,26.73 49.72,26.69 49.71,26.68 49.36,26.68 48.8,27.24 48.17,27.24 48.12,27.29 48.12,28.13 48.19,28.2 48.8,28.2
BOOT3 on BOTTOM (solid shape): 40.12,74.13 40.12,72.86 40.06,72.81 39.89,72.81 39.84,72.86 39.84,73.77 39.66,73.95 38.64,73.95 38.39,73.7 38.39,73.19 38.26,73.06 37.75,73.06 37.63,73.19 37.63,74.33 37.88,74.59 39.66,74.59
BST1_3V on BOTTOM (solid shape): 252.64,59.35 252.64,57.19 252.38,56.93 251.88,56.93 251.62,57.19 251.62,59.35 251.88,59.6 252.38,59.6
BST1_5V on BOTTOM (solid shape): 242.6,59.85 242.6,57.57 242.35,57.31 241.21,57.31 240.95,57.57 240.95,59.85 241.21,60.11 242.35,60.11
BST_3V on BOTTOM (solid shape): 250.3,58.2 251.11,58.2 251.37,57.94 251.37,57.32 251.11,57.06 250.04,57.06 249.88,57.22 249.88,57.92 248.87,58.94 248.55,58.94 248.54,58.95 247.75,58.95 247.68,59.02 247.68,59.16 247.71,59.19 249.31,59.19
BST_5V on BOTTOM (solid shape): 245.5,59.13 245.5,59 245.44,58.94 244.35,58.94 243.87,58.47 243.87,58.47 243.87,57.83 243.81,57.77 243.2,57.77 243.11,57.86 243.11,58.66 243.26,58.8 243.85,58.8 244.24,59.19 245.44,59.19
BST_+1.05VSP on BOTTOM (solid shape): 20.61,144.56 20.61,143.93 20.48,143.8 20.35,143.8 20.23,143.93 19.85,143.93 19.72,143.8 18.32,143.8 18.2,143.93 18.2,144.56 18.27,144.64 20.53,144.64
CHG on BOTTOM (solid shape): 212.38,51.09 212.38,47.47 212.35,47.45 211.92,47.45 211.91,47.46 211.91,48.98 211.68,49.21 211.37,49.21 211.15,48.98 211.15,47.46 211.13,47.45 210.36,47.45 209.46,46.54 202.78,46.54 202.47,46.85 202.47,54.01 202.73,54.27 209.2,54.27
CPU_B+ on TOP (solid shape): 45.12,48.3 45.12,42.33 44.99,42.2 43.6,42.2 43.34,42.45 43.34,48.3 43.6,48.55 44.87,48.55
CPU_B+ on BOTTOM (solid shape): outline of 208 points within 39.53,43.85 45.12,76.24
CPU_B+ on TOP: 32.08,77.15 32.63,77.71 32.66,77.7 32.8,77.7 32.93,77.76 33.26,77.76 33.39,77.68 33.54,77.66 33.81,77.75 33.93,78 33.94,78.01 37.63,78.01 37.86,77.78 37.85,77.73 37.85,76.85 37.86,76.78 37.88,76.69 37.88,76.36 37.92,76.32 37.95,76.25 37.91,76.17 37.78,75.81 38.03,75.52 38.42,75.6 38.53,75.98 38.55,76.07 38.63,76.11 38.9,76.11 38.9,76.11 39.05,76.08 39.19,76.11 39.2,76.11 42.07,76.11 42.33,75.86 42.33,74.46 42.71,74.08 43.34,74.08 43.6,73.82 43.6,72.17 43.34,71.92 42.37,71.92 42.25,71.93 42.13,71.92 41.44,71.92 40.55,71.03 40.55,70.38 40.54,70.37 40.52,70.24 40.54,70.12 40.55,70.11 40.55,69.25 41.18,68.62 41.18,64.55 43.47,62.27 43.47,57.19 43.21,56.93 42.58,56.93 42.45,57.06 36.74,57.06 36.48,57.31 36.48,67.98 33.66,70.8 30.29,70.8 28.36,68.87 25.82,68.87 25.56,69.12 25.56,77.51 25.82,77.76 28.75,77.76 29.36,77.15
DH_1.35V on BOTTOM (solid shape): 189.14,63.28 189.14,62.9 188.88,62.65 186.34,62.65 186.09,62.9 186.09,63.28 186.34,63.54 188.88,63.54
DH_1.35V on BOTTOM (solid shape): 178.39,75.94 178.39,74.92 178.6,74.71 179.1,74.71 179.36,74.46 179.36,74.33 179.1,74.08 178.66,74.08 178.53,74.08 178.09,74.08 177.96,74.2 177.96,74.46 178.19,74.69 178.19,75.95 178.24,76 178.33,76
DL_1.35V on BOTTOM (solid shape): 179.89,76.33 179.89,76.21 180.37,75.73 180.37,75.47 180.12,75.22 179.74,75.22 179.61,75.22 178.98,75.86 178.98,76.24 178.98,76.35 179.03,76.4 179.82,76.4
DL_CHG on BOTTOM (solid shape): 187.23,52.61 187.23,51.98 187.11,51.85 185.58,51.85 185.45,51.98 185.45,52.61 185.58,52.74 187.11,52.74
LG_3V on BOTTOM (solid shape): 248.67,57.35 248.67,57.03 248.61,56.97 247.85,56.97 247.28,57.54 247.28,58.28 247.35,58.34 247.68,58.34
LG_3V on BOTTOM (solid shape): 248.83,54.9 248.83,53.77 248.94,53.67 249.8,53.67 250.1,53.38 250.1,52.74 249.84,52.49 248.19,52.49 248.07,52.61 248.07,54.9 248.11,54.94 248.79,54.94
LG_5V on BOTTOM (solid shape): 244.76,50.91 244.76,50.2 244.51,49.95 243.11,49.95 242.99,50.07 242.99,50.84 243.11,50.96 244.31,50.96 244.36,51.01 244.66,51.01
LG_5V on BOTTOM (solid shape): 245.88,58.29 245.88,58.08 245.87,58.02 245.87,57.53 245.63,57.29 245.63,57.16 245.18,56.71 244.67,56.71 244.55,56.84 244.55,57.1 245.18,57.73 245.44,57.73 245.69,57.98 245.69,58.3 245.75,58.35 245.82,58.35
LG_5V on IN1 (solid shape): 244.76,50.91 244.76,50.2 244.51,49.95 243.6,49.95 242.93,50.61 242.93,50.84 243.11,51.01 244.66,51.01
LG_5V on IN1 (solid shape): 245.65,57.69 245.65,57.34 244.33,56.01 244.24,56.01 243.8,56.45 243.8,56.61 244.98,57.78 245.14,57.78 245.31,57.95 245.4,57.95
LG_+1.05VSP on BOTTOM (solid shape): 25.91,139.06 25.91,137.06 25.72,136.87 25.37,136.87 25.26,136.98 25.26,139.11 25.34,139.19 25.78,139.19
LG_+1.05VSP on BOTTOM (solid shape): 23.53,144.44 23.53,143.29 23.4,143.17 23.02,143.17 22.89,143.29 22.89,143.55 22.64,143.8 22.41,143.8 22.34,143.88 22.34,144.56 22.41,144.64 23.33,144.64
LG_+1.05VSP on IN1 (solid shape): 25.76,139.02 25.76,138.19 25.59,138.01 24.8,138.01 24.26,138.55 24.26,138.69 24.74,139.17 25.61,139.17
LGATE1 on TOP (solid shape): 48.93,54.9 48.93,53.88 48.17,53.12 47.79,53.12 47.66,53.25 47.66,53.88 47.91,54.14 47.91,54.9 48.17,55.15 48.68,55.15
LGATE1 on TOP (solid shape): 52.21,30.26 52.76,29.7 52.76,29.45 52.74,29.42 52.74,29.07 52.84,28.97 52.84,27.82 52.79,27.77 52.66,27.77 52.61,27.82 52.61,28.12 52.63,28.18 52.63,28.24 52.63,28.89 52.36,29.17 52.36,29.37 51.8,29.93 51.8,30.14 51.93,30.26 52.17,30.26
LGATE1 on IN4 (solid shape): 48.8,54.27 48.8,53.63 48.42,53.25 48.42,51.85 47.41,51.85 47.41,53.5 48.29,54.39 48.68,54.39
LGATE1 on IN4 (solid shape): 52.61,31.02 52.61,29.86 52.79,29.68 52.79,29.45 52.64,29.3 52.43,29.3 51.6,30.14 51.6,31.02 51.8,31.23 52.41,31.23
LGATE2 on TOP (solid shape): 50.52,29.51 50.52,29.31 51.14,28.69 51.32,28.69 51.33,28.68 51.44,28.66 51.56,28.67 51.58,28.68 51.62,28.64 51.62,27.82 51.57,27.77 51.49,27.77 51.04,28.23 50.86,28.23 50.2,28.89 50.12,28.89 49.56,29.45 49.56,29.53 50,29.96 50.07,29.96
LGATE3 on TOP (solid shape): 48.93,69.85 48.93,68.01 48.82,67.9 48.08,67.9 47.98,68 47.98,69.89 48.11,70.01 48.77,70.01
LGATE3 on BOTTOM (solid shape): 41.74,71.51 41.74,70.67 41.59,70.52 41.33,70.52 41.16,70.7 40.9,70.7 40.83,70.78 40.83,71.56 40.9,71.64 41.61,71.64
LGATE3 on IN1 (solid shape): 41.69,71.54 41.69,71.16 42.45,70.39 42.45,70.14 42.33,70.01 41.82,70.01 41.06,70.78 41.06,71.54 41.18,71.66 41.56,71.66
LX_CHG on BOTTOM (solid shape): 202.09,55.15 202.09,45.38 201.84,45.12 196.63,45.12 196.38,45.38 196.38,50.59 196.39,50.71 196.38,50.83 196.38,51.22 195.87,51.73 194.73,51.73 194.47,51.47 194.47,50.2 194.22,49.95 191.04,49.95 190.15,49.06 187.99,49.06 187.74,49.31 187.74,52.87 187.99,53.12 190.66,53.12 190.92,53.38 190.92,55.28 191.17,55.54 201.71,55.54
P1_SW on TOP (solid shape): 51.85,57.95 51.85,57.44 52.36,56.93 53.12,56.93 53.37,57.19 53.37,57.69 53.5,57.82 54.14,57.82 54.26,57.69 54.26,54.39 54.01,54.14 51.22,54.14 50.96,54.39 50.96,55.41 50.71,55.66 48.17,55.66 47.91,55.92 47.91,60.36 48.17,60.62 49.18,60.62
P2_SW on TOP (solid shape): 52.23,46.65 53.25,46.65 53.37,46.77 55.28,46.77 55.66,46.39 55.66,41.18 55.41,40.93 49.64,40.93 49.5,41.07 49.5,46.33 49.95,46.77 52.1,46.77
P3_SW on TOP (solid shape): 50.33,75.47 50.33,74.53 50.91,73.95 54.37,73.95 54.39,73.95 54.77,73.57 54.77,70.77 54.26,70.27 53.63,70.27 53.37,70.52 53.37,70.9 53.25,71.03 52.23,71.03 52.1,70.9 52.1,70.65 51.98,70.52 48.29,70.52 48.04,70.78 48.04,73.82 48.17,73.95 49.74,73.95 49.74,73.9 49.75,73.85 49.77,73.79 49.79,73.75 49.82,73.7 49.85,73.66 49.9,73.63 49.94,73.6 49.99,73.58 50.04,73.57 50.1,73.57 50.15,73.57 50.2,73.58 50.25,73.6 50.3,73.63 50.34,73.66 50.38,73.7 50.41,73.75 50.43,73.79 50.45,73.85 50.45,73.9 50.45,73.95 50.45,74 50.43,74.05 50.41,74.1 50.38,74.15 50.34,74.19 50.3,74.22 50.25,74.25 50.2,74.27 50.15,74.28 50.1,74.28 50.04,74.28 49.99,74.27 49.94,74.25 49.9,74.22 49.85,74.19 49.82,74.15 49.79,74.1 49.77,74.05 49.75,74 49.74,73.95 48.17,73.95 48.29,74.08 48.93,74.08 49.44,74.59 49.44,75.47 49.56,75.6 50.2,75.6
PBATT+ on BOTTOM (solid shape): 201.2,38.67 201.2,35.24 200.54,34.58 193.71,34.58 193.46,34.83 193.46,38.26 193.58,38.39 195.49,38.39 195.74,38.14 195.74,37.5 196.2,37.04 197.01,37.04 197.42,37.45 197.42,39 197.51,39.09 200.78,39.09
PBATT+_C on TOP (solid shape): outline of 1229 points within 158.53,15.72 204.12,36.74
PBATT+_C on BOTTOM (solid shape): 204.25,32.55 204.25,29.77 204.12,29.64 196.6,29.64 196.43,29.82 196.43,31.49 196.8,31.86 196.8,32.59 197.07,32.87 203.93,32.87
PBATT+_C on IN4 (solid shape): outline of 291 points within 158.53,15.78 204.25,27.72
PBATT_IN_SS on BOTTOM (solid shape): 193.07,37.5 193.07,33.69 192.82,33.44 189.01,33.44 186.85,31.28 185.45,31.28 185.33,31.15 185.33,30.26 185.2,30.14 184.44,30.14 184.18,29.88 184.18,29.12 183.93,28.87 180.25,28.87 179.99,29.12 179.99,30.58 179.6,30.97 177.95,30.97 177.83,31.09 177.83,32.68 177.96,32.8 182.15,32.8 182.53,33.18 182.53,37.03 182.88,37.37 187.62,37.37 188.07,37.82 192.75,37.82
PHASE1 on TOP (solid shape): 43.6,54.9 43.6,54.27 44.74,53.12 44.74,52.49 44.48,52.23 43.98,52.23 42.58,53.63 42.58,54.9 42.83,55.15 43.34,55.15
PHASE1 on TOP (solid shape): 53.2,31.02 53.2,30.29 53.4,30.08 53.4,29.04 53.23,28.88 53.23,27.84 53.18,27.79 53.06,27.79 53.02,27.82 53.02,28.99 52.87,29.14 52.87,29.35 52.94,29.42 52.94,29.73 52.87,29.8 52.87,29.98 52.49,30.36 52.31,30.36 52.28,30.39 52.28,31.02 52.31,31.05 53.17,31.05
PHASE1 on IN3 (solid shape): 45.88,52.23 45.88,51.22 44.99,51.22 43.98,52.23 43.98,53.5 44.1,53.63 44.48,53.63
PHASE1 on IN3 (solid shape): 53.78,31.13 53.78,30.64 53.4,30.26 53.4,29.12 53.27,28.99 53.02,28.99 52.87,29.14 52.87,29.35 52.94,29.42 52.94,29.73 52.87,29.8 52.87,30.9 53.12,31.15 53.76,31.15
PHASE2 on TOP (solid shape): 45.12,40.17 45.12,38.39 44.87,38.14 44.36,38.14 44.1,38.39 44.1,40.11 44.1,40.17 44.36,40.42 44.87,40.42
PHASE2 on TOP (solid shape): 50.96,27.72 51.29,27.72 51.37,27.65 51.37,27.54 51.32,27.49 50.48,27.49 49.49,28.48 48.17,28.48 48.04,28.61 48.04,29.5 48.17,29.63 49.06,29.63
PHASE2 on IN4 (solid shape): 49.84,29.09 49.84,28.84 50.43,28.26 50.43,28.03 50.33,27.93 50.05,27.93 49.49,28.48 49.28,28.48 48.66,29.11 48.66,29.49 48.8,29.63 49.31,29.63
PHASE3 on BOTTOM (solid shape): 38.39,72.5 38.39,71.92 38.52,71.79 39.05,71.79 39.2,71.64 39.53,71.64 39.61,71.56 39.61,70.72 39.53,70.65 38.39,70.65 37.63,71.41 37.63,72.43 37.75,72.55 38.34,72.55
PHASE3 on IN4 (solid shape): 39.28,71.66 39.28,70.9 39.79,70.39 39.79,70.14 39.4,69.76 39.28,69.76 38.52,70.52 38.52,71.66 38.64,71.79 39.15,71.79
PWR_SRC_ON on BOTTOM (solid shape): 53.62,159.24 53.62,155.46 53.21,155.05 52.41,155.05 52.14,155.32 52.14,155.72 52.36,155.95 52.36,157.19 52.1,157.46 51.47,157.46 51.37,157.56 51.37,157.95 51.45,158.03 52.03,158.03 52.44,158.44 52.44,159.08 52.7,159.35 53.51,159.35
SNB_CPU_P1 on TOP (solid shape): 49.06,63.92 49.06,61.25 48.8,61 48.17,61 47.91,61.25 47.91,63.92 48.17,64.17 48.8,64.17
SNB_CPU_P3 on TOP (solid shape): 48.93,75.73 48.93,74.71 48.8,74.59 46.9,74.59 46.77,74.71 46.77,76.24 46.9,76.36 48.29,76.36
SNUB_1.5VSP on BOTTOM (solid shape): 258.53,27.98 258.73,27.98 258.99,27.72 258.99,27.09 258.73,26.83 256.57,26.83 256.32,27.09 256.32,27.72 256.57,27.98 258.51,27.98
SNUB_1.35V on BOTTOM (solid shape): 188.38,74.97 189.14,74.97 189.39,74.71 189.39,73.7 189.14,73.44 186.72,73.44 186.47,73.7 186.47,75.35 186.72,75.6 187.74,75.6
SW1 on BOTTOM (solid shape): 244.34,60.09 244.34,59.7 244.46,59.59 245.4,59.59 245.44,59.55 245.44,59.38 245.41,59.36 244.16,59.36 243.92,59.13 243.18,59.13 242.79,59.51 242.79,60.47 242.99,60.68 243.76,60.68
SW1 on BOTTOM (solid shape): 242.48,55.28 242.48,53.12 242.6,53 242.6,49.82 242.35,49.57 242.35,48.55 242.1,48.3 240.57,48.3 240.19,47.92 240.19,45.38 239.94,45.12 236.13,45.12 235.87,45.38 235.87,50.58 239.94,54.65 239.94,55.41 240.06,55.54 242.22,55.54
SW1 on IN1 (solid shape): 239.69,52.65 239.69,50.69 239.55,50.55 239.14,50.55 238.92,50.77 238.92,52.69 239,52.77 239.56,52.77
SW1 on IN1 (solid shape): 243.99,60.58 243.99,60.27 243.3,59.59 243.3,59.6 242.15,59.6 241.95,59.8 241.95,59.9 242.75,60.7 243.86,60.7
SW2 on BOTTOM (solid shape): 251.11,59.65 251.11,58.71 250.86,58.46 250.35,58.46 249.46,59.35 247.75,59.35 247.68,59.42 247.68,59.49 247.74,59.55 248.75,59.55 249.09,59.89 249.32,59.89 249.34,59.9 250.86,59.9
SW2 on BOTTOM (solid shape): 253.27,55.54 253.27,54.39 254.16,53.5 257.72,53.5 257.97,53.25 257.97,46.01 257.72,45.76 254.03,45.76 253.78,46.01 253.78,49.31 253.4,49.69 252.26,49.69 251.95,49.39 251.95,48.25 251.88,48.17 250.22,48.17 249.97,48.42 249.97,49.95 250.48,50.46 250.48,54.14 252.13,55.79 253.02,55.79
SW2 on IN1 (solid shape): 251.17,59.7 251.17,58.89 251.03,58.75 249.81,58.75 249.09,59.47 249.09,59.65 249.34,59.9 250.97,59.9
SW_1.35V on BOTTOM (solid shape): 185.2,76.11 185.2,72.93 185.45,72.68 190.79,72.68 191.04,72.43 191.04,64.04 190.79,63.79 186.47,63.79 186.22,64.04 186.22,68.11 185.96,68.36 182.91,68.36 182.66,68.62 182.66,76.11 182.91,76.36 184.95,76.36
SW_1.35V on BOTTOM (solid shape): 178.76,76 178.8,75.95 178.8,75.78 179.49,75.09 179.56,75.09 179.92,75.09 180.45,74.56 180.45,73.26 180.25,73.06 178.85,73.06 178.67,73.24 178.67,73.87 178.75,73.95 179.41,73.95 179.64,74.18 179.64,74.48 179.05,75.07 178.68,75.07 178.59,75.16 178.59,75.95 178.64,76
SW_+1.05VSP on TOP (solid shape): 18.83,138.09 18.83,135.34 18.84,135.33 18.84,133.83 19.01,133.66 20.31,133.66 20.65,133.31 20.65,132.17 20.18,131.7 17.34,131.7 13.88,135.16 13.88,137.07 14.13,137.32 15.91,137.32 16.8,138.21 18.7,138.21
SW_+1.05VSP on BOTTOM (solid shape): 21.62,144.56 21.62,143.55 22.39,142.78 22.39,142.15 22.13,141.9 21.12,141.9 20.94,142.07 20.94,143.01 21.32,143.39 21.32,144.56 21.42,144.66 21.52,144.66
SW_+1.05VSP on BOTTOM (solid shape): 25.46,136.3 25.57,136.3 25.69,136.17 25.69,131.54 25.19,131.03 18.01,131.03 17.08,131.97 17.08,134.18 17.44,134.54 18.18,134.54 19.04,133.68 20.16,133.68 20.31,133.83 20.31,134.92 20.51,135.13 21.89,135.13 23.06,136.3 25.46,136.3
SW_+1.05VSP on IN1 (solid shape): 21.46,133.23 21.46,132.81 20.77,132.12 20.1,132.12 19.92,132.31 19.92,132.75 19.96,132.79 19.96,133.29 20.09,133.42 21.27,133.42
SW_+1.05VSP on IN1 (solid shape): 22.26,142.91 22.26,141.9 21.5,141.13 21.24,141.13 20.99,141.39 20.99,141.9 21.62,142.53 21.62,142.91 21.75,143.04 22.13,143.04
UG_3V on BOTTOM (solid shape): 253.42,49.26 253.42,48.04 253.27,47.89 252.81,47.89 252.21,48.5 252.21,49.26 252.36,49.41 253.27,49.41
UG_3V on BOTTOM (solid shape): 249.37,58.24 249.37,57.98 249.31,57.92 248.4,57.92 248.36,57.95 248.3,57.97 247.7,58.58 247.7,58.7 247.75,58.75 248.86,58.75
UG_3V on IN4 (solid shape): 250.13,57.43 250.13,57.25 249.59,56.71 249.5,56.71 248.07,58.15 248.07,58.33 248.56,58.82 248.74,58.82
UG_5V on BOTTOM (solid shape): 243.67,49.52 243.67,48.6 243.49,48.42 242.73,48.42 242.6,48.55 242.6,49.44 242.86,49.69 243.49,49.69
UG_5V on BOTTOM (solid shape): 245.56,58.75 245.56,58.5 245.55,58.46 245.55,58.43 245.55,58.16 245.31,57.92 244.17,57.92 244.04,58.05 244.04,58.43 244.42,58.81 245.5,58.81
UG_5V on IN4 (solid shape): 245.18,58.44 245.18,57.98 245.06,57.86 243.28,57.86 243.15,57.98 243.15,58.75 243.28,58.87 244.75,58.87
UG_5V on IN4 (solid shape): 243.67,49.57 243.67,48.6 243.42,48.35 242.3,48.35 241.99,48.65 241.99,50.02 242.3,50.33 242.91,50.33
UG_+1.05VSP on BOTTOM (solid shape): 20.07,134.89 20.07,134.04 19.85,133.82 19.13,133.82 18.99,133.96 18.99,134.82 19.18,135.01 19.95,135.01
UG_+1.05VSP on BOTTOM (solid shape): 21.12,144.59 21.12,143.44 20.84,143.17 19.97,143.17 19.85,143.29 19.85,143.57 19.95,143.67 20.23,143.67 20.28,143.62 20.58,143.62 20.84,143.88 20.84,144.59 20.89,144.64 21.07,144.64
UG_+1.05VSP on IN1 (solid shape): 19.66,135.6 19.66,134.04 19.45,133.82 19.03,133.82 18.83,134.01 18.83,135.6 18.93,135.7 19.57,135.7
UG_+1.05VSP on IN1 (solid shape): 20.99,143.67 20.99,143.29 20.86,143.17 20.48,143.17 19.85,142.53 19.34,142.53 19.08,142.78 19.08,143.04 19.85,143.8 20.86,143.8
UGATE1 on TOP (solid shape): 54.03,30.01 54.03,29.12 53.64,28.73 53.64,27.84 53.59,27.79 53.46,27.79 53.41,27.84 53.41,28.83 53.53,28.94 53.53,30.03 53.65,30.16 53.88,30.16
UGATE1 on IN1 (solid shape): 54.9,31.02 54.9,29.98 53.91,28.99 53.63,28.99 53.53,29.09 53.53,30.03 54.14,30.64 54.14,31.02 54.24,31.13 54.8,31.13
UGATE2 on TOP (solid shape): 50.45,27.32 51.29,27.32 51.34,27.26 51.34,27.14 51.29,27.09 49.95,27.09 49.18,27.85 49.18,28.1 49.31,28.23 49.54,28.23
UGATE2 on TOP (solid shape): 45.12,41.57 45.12,41.06 44.87,40.8 44.23,40.8 43.98,40.55 43.98,40.17 43.72,39.91 43.21,39.91 42.96,40.17 42.96,41.57 43.21,41.82 44.87,41.82
UGATE2 on IN4 (solid shape): 49.18,28.23 49.54,28.23 50.2,27.57 50.2,27.34 50.07,27.21 49.06,27.21 48.17,28.1 48.17,28.61 48.29,28.74 48.68,28.74
UGATE3 on BOTTOM (solid shape): 39.61,73.65 39.61,72.86 39.56,72.81 39.23,72.81 39.15,72.73 39.15,72.4 39.02,72.27 38.74,72.27 38.64,72.38 38.64,73.59 38.77,73.72 39.53,73.72
UGATE3 on IN4 (solid shape): 40.12,73.42 40.12,72.91 40.01,72.81 39.53,72.81 39,72.27 38.67,72.27 38.52,72.43 38.52,73.32 38.77,73.57 39.96,73.57
VLDOIN_1.35V on BOTTOM (solid shape): 177.15,74.79 177.26,74.81 177.33,74.72 177.33,73.84 177.33,71.92 177.05,71.64 175.01,71.64 174.99,71.61 174.99,71.11 174.96,71.08 174.84,71.08 174.84,71.61 174.81,71.64 174.41,71.64 174.28,71.77 174.28,73.06 174.53,73.32 176.18,73.32 176.56,73.7 176.56,74.46 176.69,74.59 176.95,74.59
N16855849 on TOP (solid shape): 54.52,32.42 54.52,31.79 54.39,31.66 52.36,31.66 52.23,31.79 52.23,32.02 52.23,32.02 52.23,32.42 52.36,32.55 54.39,32.55
N17657331 on BOTTOM (solid shape): 217.71,44.99 217.73,44.99 218.35,44.99 218.47,44.87 218.47,44.11 218.73,43.85 220.25,43.85 220.38,43.72 220.38,42.71 220.63,42.45 222.28,42.45 222.54,42.2 222.54,38.52 222.28,38.26 220.38,38.26 220.13,38.52 220.13,39.66 219.87,39.91 218.22,39.91 217.97,40.17 217.97,43.47 217.46,43.98 215.81,43.98 215.68,44.11 215.68,44.87 215.81,44.99 216.87,44.99
N17657445 on BOTTOM (solid shape): 203.15,44.23 203.15,39.76 202.9,39.52 196.62,39.52 196.25,39.89 196.25,44.61 196.38,44.74 202.64,44.74
N19407600 on BOTTOM (solid shape): 160.16,106.79 160.16,104.65 159.91,104.4 158.81,104.4 157.83,105.38 157.83,106.96 157.86,106.98 159.97,106.98
N20156535 on BOTTOM (solid shape): 259.62,154.66 259.62,152.27 259.59,152.23 259.56,152.2 258.91,152.2 258.53,151.81 258.91,151.43 259.43,151.43 259.43,151.31 259.48,151.07 259.61,150.87 259.62,150.85 259.62,150.79 259.62,150.75 259.62,148.12 260.45,147.29 260.45,145.77 260.19,145.51 258.67,145.51 257.97,146.21 257.97,154.67 258.17,154.87 259.41,154.87
N48711348 on TOP (solid shape): 47.53,29.5 47.53,27.34 47.41,27.21 46.77,27.21 46.64,27.34 46.64,29.5 46.77,29.63 47.41,29.63
N51290432 on BOTTOM (solid shape): 37.12,74.08 37.12,71.66 36.99,71.54 36.36,71.54 36.23,71.66 36.23,74.08 36.36,74.2 36.99,74.2
N51302473 on BOTTOM (solid shape): 40.6,71.59 40.6,70.78 40.32,70.5 40.32,68.97 40.24,68.9 38.72,68.9 38.49,69.12 38.49,69.71 39.18,70.39 39.58,70.39 39.84,70.65 39.84,71.59 39.89,71.64 40.55,71.64
N85751870 on BOTTOM (solid shape): 19.39,142.99 20.28,142.99 20.35,142.91 20.35,142.15 20.23,142.02 18.7,142.02 18.2,142.53 18.2,143.17 18.32,143.29 19.08,143.29

Small or netless copper shapes (teardrops, artwork): 202 on TOP, 13 on BOTTOM, 1 on IN1, 146 on IN2, 1 on IN3, 1 on IN4

## Text on the board
User.Comments: LA9771P | 2013-06-24 | 2014-06-24 | Fisher | VAQ10 | 1.0(A00)
Ref Des/Silkscreen Top: 2 | H3 | 1 | 4 | H5 | H7 | M2x3 | 5 | H8 | 3
