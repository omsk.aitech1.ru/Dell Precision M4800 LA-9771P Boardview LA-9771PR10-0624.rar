# Allegro board LA-9771PR10-0624.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MXM_LVDS_A0+: length 72.1
  TOP w0.089: v1(75.07,102.25) 75.31,102.01 75.31,101.79 74.08,100.56 74.08,97.65 74,97.57 JMXM1.230
  IN1 w0.102: v1(65.02,155.19) 64.83,155.38 64.83,155.48 64.96,155.61 65.79,155.61 66.41,155 66.41,154.87 66.65,154.63 66.78,154.63 66.99,154.41 66.99,154.29 67.23,154.04 67.36,154.04 70.01,151.39 70.01,149.95 72.42,147.53 72.42,133.49 78.19,127.73 78.19,126.84 80.93,124.09 80.93,122.48 80.45,122 80.45,118.09 79.71,117.35 79.71,116.85 79.03,116.16 79.03,108.08 74.91,103.97 74.91,103.16 75.47,102.6 75.47,101.97 75.37,101.86 75.24,101.86 75.07,102.04 v1(75.07,102.25)
  BOTTOM w0.089: v1(65.02,155.19) 64.86,155.03 64.86,154.84 64.94,154.76 U11.18
MXM_LVDS_A0-: length 72
  TOP w0.089: JMXM1.228 74.5,97.56 74.42,97.64 74.42,100.42 75.65,101.65 75.65,102.02 v1(75.88,102.25)
  IN1 w0.102: v1(64.38,155.19) 64.47,155.28 64.47,155.63 64.81,155.97 65.94,155.97 70.37,151.54 70.37,150.09 72.78,147.68 72.78,133.64 78.55,127.87 78.55,126.99 81.29,124.24 81.29,122.34 80.81,121.85 80.81,117.94 80.07,117.21 80.07,116.7 79.38,116.02 79.38,107.94 75.27,103.82 75.27,103.31 75.83,102.75 75.83,102.3 v1(75.88,102.25)
  BOTTOM w0.089: v1(64.38,155.19) 64.52,155.06 64.52,154.87 64.44,154.79 U11.17
MXM_LVDS_A1+: length 65.8
  TOP w0.089: v1(75.55,99.84) 75.75,99.64 75.75,99.22 75.59,99.06 75.59,97.66 75.5,97.57 JMXM1.224
  IN1 w0.102: v1(75.55,99.84) 75.83,99.84 75.9,99.91 75.9,100.24 75.22,100.92 74.94,100.92 73.85,102.02 73.85,104.09 78.19,108.44 78.19,117.49 79.05,118.35 79.05,123.35 76.67,125.74 76.67,127.75 71.56,132.85 71.56,147.03 69.17,149.41 69.17,150.61 68.99,150.79 68.86,150.79 68.62,151.03 68.62,151.16 68.4,151.38 68.28,151.38 68.04,151.62 68.04,151.74 67.76,152.02 67.13,152.02 v1(66.9,151.79)
  BOTTOM w0.089: U11.22 66.42,151.82 66.49,151.9 66.79,151.9 v1(66.9,151.79)
MXM_LVDS_A1-: length 65.9
  TOP w0.089: JMXM1.222 76,97.58 75.93,97.65 75.93,98.92 76.09,99.08 76.09,99.62 v1(76.31,99.84)
  IN1 w0.102: v1(66.9,152.37) 67.91,152.37 69.53,150.75 69.53,149.56 71.92,147.17 71.92,133 77.02,127.89 77.02,125.89 79.41,123.5 79.41,118.2 78.55,117.34 78.55,108.29 74.2,103.95 74.2,102.17 75.09,101.28 75.37,101.28 76.26,100.39 76.26,99.88 v1(76.31,99.84)
  BOTTOM w0.089: U11.21 66.44,152.32 66.52,152.25 66.77,152.25 v1(66.9,152.37)
MXM_LVDS_A2+: length 65.7
  TOP w0.089: JMXM1.218 77,97.57 77.08,97.65 77.08,98.18 v1(76.95,98.31)
  IN1 w0.102: v1(66.9,149.71) 66.9,149.96 67.01,150.07 67.3,150.07 67.58,149.79 67.58,149.66 67.82,149.42 67.95,149.42 68.16,149.2 68.16,149.08 68.41,148.83 68.54,148.83 70.7,146.67 70.7,132.17 75.22,127.65 75.22,125.99 78.22,123 78.22,118.86 76.89,117.54 76.89,115.13 77.35,114.67 77.35,108.8 75.52,106.97 74.92,106.97 74.23,106.28 74.23,105.88 73.01,104.66 73.01,101.39 74.71,99.69 74.71,99.38 75.14,98.94 76.92,98.94 77.2,98.66 77.2,98.57 76.95,98.31 v1(76.95,98.31)
  BOTTOM w0.089: v1(66.9,149.71) 66.7,149.9 66.54,149.9 66.46,149.82 U11.26
MXM_LVDS_A2-: length 65.7
  TOP w0.089: v1(77.56,98.31) 77.42,98.17 77.42,97.64 77.5,97.56 JMXM1.216
  IN1 w0.102: v1(77.56,98.31) 77.56,98.81 77.07,99.3 75.29,99.3 75.07,99.52 75.07,99.83 73.36,101.53 73.36,104.51 74.58,105.73 74.58,106.13 75.07,106.61 75.67,106.61 77.71,108.65 77.71,114.82 77.25,115.28 77.25,117.39 78.57,118.71 78.57,123.14 75.57,126.14 75.57,127.79 71.05,132.31 71.05,146.82 67.44,150.43 66.94,150.43 v1(66.9,150.47)
  BOTTOM w0.089: v1(66.9,150.47) 66.68,150.25 66.52,150.25 66.44,150.32 U11.25
MXM_LVDS_ACLK+: length 73.1
  TOP w0.089: JMXM1.206 80,97.53 80.08,97.61 80.08,97.81 79.98,97.92 79.98,98.18 v1(79.85,98.31)
  IN1 w0.102: v1(63.39,147.42) 63.48,147.51 63.48,147.88 63.87,148.27 67.62,148.27 70.19,145.71 70.19,129.98 73.08,127.09 73.43,127.09 77.73,122.79 77.73,119.22 75.78,117.27 75.78,115.32 76.87,114.23 76.87,109.01 75.31,107.45 74.41,107.45 72.53,105.57 72.53,101.18 74.1,99.6 74.1,98.23 74.81,97.52 79.72,97.52 80.01,97.81 80.01,98.16 v1(79.85,98.31)
  BOTTOM w0.089: U11.31 63.44,147.83 63.52,147.75 63.52,147.55 v1(63.39,147.42)
MXM_LVDS_ACLK-: length 73.1
  TOP w0.089: v1(80.45,98.31) 80.32,98.18 80.32,98.06 80.43,97.96 80.43,97.6 80.5,97.52 JMXM1.204
  IN1 w0.102: v1(63.98,147.42) 63.84,147.56 63.84,147.74 64.02,147.91 67.48,147.91 69.83,145.56 69.83,129.84 72.94,126.73 73.29,126.73 77.38,122.64 77.38,119.37 75.42,117.42 75.42,115.17 76.51,114.08 76.51,109.15 75.17,107.81 74.26,107.81 72.17,105.72 72.17,101.03 73.74,99.46 73.74,98.08 74.66,97.17 79.87,97.17 80.36,97.66 80.36,98.22 v1(80.45,98.31)
  BOTTOM w0.089: U11.30 63.94,147.84 63.86,147.76 63.86,147.54 v1(63.98,147.42)
MXM_LVDS_B0+: length 76.2
  TOP w0.089: v1(75.68,103.49) 75.81,103.63 75.81,104.19 75.75,104.25 JMXM1.225
  IN3 w0.114: v1(67.29,143.98) 67.15,144.12 66.2,144.12 65.99,143.9 65.99,143.44 66.23,143.2 69.32,143.2 72.5,146.38 79.19,146.38 86.74,138.83 86.74,129.84 84.53,127.63 84.53,121.68 84.84,121.36 84.84,111.92 84.2,111.28 84.2,106.55 82.13,104.49 80.06,104.49 78.19,102.63 76.11,102.63 75.69,103.05 75.69,103.48 v1(75.68,103.49)
  BOTTOM w0.089: U13.18 65.89,143.77 65.82,143.85 65.82,144.02 66.2,144.41 67.37,144.41 67.45,144.33 67.45,144.13 v1(67.29,143.98)
MXM_LVDS_B0-: length 76.2
  TOP w0.089: JMXM1.223 76.25,104.29 76.16,104.2 76.16,103.62 v1(76.28,103.49)
  IN3 w0.114: v1(67.29,144.82) 67.37,144.74 67.37,144.56 67.29,144.49 66.05,144.49 65.62,144.05 65.62,143.29 66.07,142.83 69.48,142.83 72.65,146.01 79.04,146.01 86.37,138.68 86.37,130 84.16,127.79 84.16,121.52 84.48,121.21 84.48,112.08 83.83,111.43 83.83,106.71 81.98,104.86 79.91,104.86 79.58,104.54 79.5,104.54 79.44,104.54 79.17,104.27 79.17,104.13 78.93,103.88 78.84,103.88 78.79,103.88 78.52,103.61 78.52,103.47 78.04,102.99 76.26,102.99 76.06,103.2 76.06,103.31 76.23,103.49 v1(76.28,103.49)
  BOTTOM w0.089: U13.17 65.39,143.81 65.47,143.88 65.47,144.17 66.06,144.75 67.23,144.75 v1(67.29,144.82)
MXM_LVDS_B1+: length 64.7
  TOP w0.089: v1(77.2,103.49) 77.42,103.71 77.42,103.95 77.33,104.04 77.33,104.3 77.25,104.38 JMXM1.219
  IN3 w0.114: v1(67.85,140.75) 67.85,140.83 68.04,141.02 69.34,141.02 72.22,143.9 78.25,143.9 79.29,142.86 80.51,142.86 85.09,138.29 85.09,136.26 84.6,135.77 84.6,132.17 83.77,131.34 83.77,128.78 82.91,127.93 82.91,127.01 83.18,126.74 83.18,121.08 83.57,120.69 83.57,116.91 82.11,115.45 82.11,114.64 82.6,114.16 82.6,111.41 82.81,111.2 82.81,106.93 81.62,105.74 79.08,105.74 78.85,105.51 78.72,105.51 78.45,105.25 78.45,105.19 78.45,105.11 78.21,104.86 78.07,104.86 77.8,104.6 77.8,104.54 77.8,104.46 77.52,104.18 77.52,103.6 77.4,103.49 v1(77.2,103.49)
  BOTTOM w0.089: v1(67.85,140.75) 67.69,140.92 67.45,140.92 67.37,140.84 U13.22
MXM_LVDS_B1-: length 64.7
  TOP w0.089: JMXM1.217 77.75,104.4 77.67,104.32 77.67,104.18 77.76,104.09 77.76,103.67 v1(77.94,103.49)
  IN3 w0.114: v1(77.94,103.49) 77.89,103.54 77.89,104.02 79.23,105.37 81.77,105.37 83.18,106.78 83.18,111.35 82.97,111.57 82.97,114.31 82.48,114.79 82.48,115.3 83.94,116.76 83.94,120.84 83.55,121.23 83.55,126.9 83.28,127.16 83.28,127.77 84.13,128.62 84.13,131.18 84.97,132.02 84.97,135.62 85.45,136.1 85.45,138.44 80.67,143.23 79.45,143.23 78.41,144.27 72.07,144.27 69.19,141.39 v1(67.85,141.39)
  BOTTOM w0.089: v1(67.85,141.39) 67.73,141.26 67.47,141.26 67.39,141.34 U13.21
MXM_LVDS_B2+: length 59.9
  TOP w0.089: JMXM1.213 78.75,105.77 78.91,105.93 78.91,106.47 78.79,106.59 v1(78.7,106.59)
  IN3 w0.114: v1(67.85,138.72) 68.06,138.92 68.49,138.92 71.31,141.74 80.35,141.74 84.04,138.05 84.04,136.49 83.08,135.52 83.08,133.22 81.26,131.41 81.26,125.23 82.23,124.27 82.23,120.77 82.67,120.33 82.67,117.96 80.84,116.13 80.84,111.73 81.95,110.63 81.95,107.3 81.5,106.86 80.58,106.86 80.02,107.41 79.4,107.41 78.99,107.01 78.99,106.79 78.79,106.59 v1(78.7,106.59)
  BOTTOM w0.089: U13.26 67.41,138.84 67.57,139 67.77,139 67.85,138.91 v1(67.85,138.72)
MXM_LVDS_B2-: length 60
  TOP w0.089: v1(79.36,106.59) 79.25,106.48 JMXM1.211
  IN3 w0.114: v1(79.36,106.59) 79.36,106.86 79.55,107.05 79.87,107.05 80.43,106.49 81.66,106.49 82.32,107.15 82.32,110.78 81.21,111.89 81.21,115.98 83.04,117.81 83.04,120.48 82.6,120.93 82.6,124.42 81.63,125.39 81.63,131.25 83.45,133.07 83.45,135.37 84.41,136.33 84.41,138.2 80.5,142.11 71.15,142.11 68.33,139.29 68.04,139.29 v1(67.85,139.48)
  BOTTOM w0.089: U13.25 67.71,139.34 v1(67.85,139.48)
MXM_LVDS_BCLK+: length 59.6
  TOP w0.089: v1(80.81,107.4) 80.96,107.26 80.96,106.92 81.82,106.06 81.82,105.83 81.75,105.76 JMXM1.201
  IN3 w0.114: v1(64.35,136.38) 64.45,136.28 64.45,135.72 65.02,135.15 66.8,135.15 72.09,140.45 80.39,140.45 82.15,138.69 82.15,136.48 79.92,134.25 79.92,125.33 81.35,123.9 81.35,119.43 79.7,117.78 79.7,111.12 80.4,110.42 80.4,108.15 80.95,107.6 80.95,107.54 v1(80.81,107.4)
  BOTTOM w0.089: v1(64.35,136.38) 64.47,136.51 64.47,136.76 64.39,136.84 U13.31
MXM_LVDS_BCLK-: length 59.6
  TOP w0.089: v1(81.45,107.4) 81.3,107.26 81.3,107.06 82.16,106.2 82.16,105.87 82.25,105.78 JMXM1.199
  IN3 w0.114: v1(81.45,107.4) 81.32,107.53 81.32,107.75 80.77,108.3 80.77,110.58 80.07,111.28 80.07,117.63 81.72,119.28 81.72,124.05 80.29,125.49 80.29,134.1 82.51,136.33 82.51,138.84 80.54,140.82 71.94,140.82 66.65,135.52 65.17,135.52 64.82,135.87 64.82,136.28 v1(64.93,136.38)
  BOTTOM w0.089: U13.30 64.89,136.85 64.82,136.78 64.82,136.5 v1(64.93,136.38)
MXM_LVDS_DDC_CLK: length 92.6
  TOP w0.102: v1(113.17,116.44) 113.34,116.27 113.34,115.22 116.14,112.43 116.14,109.55 116.06,109.48 116.06,106.89 115.89,106.72 115.89,105.93 115.75,105.79 JMXM1.71
  IN3 w0.127: v1(113.17,116.44) 113.3,116.58 113.3,116.81 113.14,116.98 112.09,116.98 109.66,119.41 109.66,120.15 108.64,121.17 106.94,121.17 106.26,121.85 106.26,124.88 103.95,127.19 103.95,129.34 94.98,138.31 94.98,138.94 92.87,141.04 92.87,144.28 85.99,151.16 85.99,152.21 85.43,152.77 79.68,152.77 79,153.45 77.53,153.45 76.41,154.57 75.5,154.57 75.45,154.62 69.78,154.62 69.35,154.19 61.88,154.19 59.57,151.88 59.57,151.65 59.25,151.32 58.78,151.32 v1(58.77,151.34)
  BOTTOM w0.102: v1(58.77,151.34) 58.78,151.32 U11.5
MXM_LVDS_DDC_DAT: length 88.8
  TOP w0.102: v1(113.75,116.44) 113.57,116.27 113.57,115.31 116.37,112.52 116.37,109.46 116.29,109.38 116.29,106.8 116.12,106.63 116.12,105.92 116.25,105.79 JMXM1.69
  IN3 w0.127: v1(62.44,155.51) 62.44,155.51 62.44,154.9 62.9,154.44 69.25,154.44 69.68,154.87 75.55,154.87 75.6,154.82 76.51,154.82 77.63,153.71 79.1,153.71 79.79,153.02 85.53,153.02 86.24,152.31 86.24,151.27 93.13,144.38 93.13,141.15 95.23,139.04 95.23,138.42 104.2,129.45 104.2,127.29 106.51,124.98 106.51,121.96 107.04,121.42 108.75,121.42 109.91,120.26 109.91,119.52 112.2,117.23 113.24,117.23 113.56,116.92 113.56,116.64 v1(113.75,116.44)
  BOTTOM w0.102: U11.13 62.44,155.51 v1(62.44,155.51)
MXM_MB_DP_AUX: length 228.5
  TOP w0.102: v1(54.94,107.35) 54.78,107.2 54.45,107.2 54.15,106.89 54.15,106.56 54.82,105.89 54.82,105.8 54.75,105.73 JMXM1.309
  IN1 w0.109: v1(240.9,78.65) 241.2,78.35 241.2,77.94 242.29,76.85 242.29,76.56 v1(242.08,76.35)
  IN4 w0.109: v5(239.76,81.13) 239.46,81.43 239.46,81.77 239.07,82.16 234.57,82.16 233.27,83.46 225.59,83.46 222.72,80.58 222.72,78.01 221.12,76.41 219.69,76.41 217.34,74.06 215.97,74.06 214.19,72.28 212.88,72.28 212.39,72.77 212.39,73.28 210.88,74.79 210.88,77.63 209.41,79.11 209.41,81.52 206.92,84.01 204.07,84.01 193.46,94.63 187.72,94.63 182.19,100.15 181.66,100.15 176.99,104.82 165.49,104.82 163.55,106.75 126.95,106.75 125.76,107.94 116.03,107.94 115.91,108.06 83.55,108.06 82.01,109.59 78.04,109.59 77.52,109.07 66.64,109.07 64.55,111.17 60.57,111.17 56.58,107.18 55.11,107.18 v1(54.94,107.35)
  BOTTOM w0.089: 239.56,81.57 239.56,81.74 239.58,81.76 U22.33
  BOTTOM w0.102: Q340.1 241.85,76.58 v1(242.08,76.35) ; C397.1 241.19,79.09 241.19,78.94 240.95,78.7 ; 240.95,78.7 241.18,78.7 241.33,78.55 241.33,78.27 241.22,78.15 240.56,78.15 239.44,79.27 239.44,80.9 239.67,81.13 v5(239.76,81.13) 239.56,81.33 239.56,81.57 ; 240.95,78.7 v1(240.9,78.65)
MXM_MB_DP_AUX#: length 229
  TOP w0.102: JMXM1.307 55.25,105.7 55.05,105.9 55.05,105.99 54.41,106.63 54.41,106.83 54.55,106.97 54.78,106.97 54.94,106.82 v1(54.94,106.77)
  IN1 w0.109: v1(242.72,76.38) 242.53,76.57 242.53,76.95 241.43,78.04 241.43,78.35 v1(241.73,78.65)
  IN4 w0.109: v1(238.9,81.15) 239.03,81.15 239.22,81.35 239.22,81.67 238.97,81.93 234.47,81.93 233.18,83.22 225.69,83.22 222.95,80.48 222.95,77.92 221.21,76.18 219.79,76.18 217.44,73.82 216.07,73.82 214.29,72.05 212.78,72.05 212.15,72.68 212.15,73.18 210.64,74.69 210.64,77.54 209.17,79.01 209.17,81.42 206.82,83.77 203.97,83.77 193.36,94.39 187.62,94.39 182.1,99.91 181.56,99.91 176.89,104.58 165.39,104.58 163.45,106.52 126.85,106.52 125.66,107.71 115.93,107.71 115.81,107.83 83.45,107.83 81.92,109.36 78.14,109.36 77.62,108.83 66.55,108.83 64.45,110.93 60.66,110.93 56.68,106.94 55.11,106.94 v1(54.94,106.77)
  BOTTOM w0.102: C398.1 241.42,79.04 241.42,78.81 241.59,78.65 v1(241.73,78.65) 241.56,78.48 241.56,78.18 241.31,77.93 v3(240.7,77.93) 240.46,77.93 239.21,79.18 239.21,80.86 238.98,81.09 238.98,81.15 ; Q340.4 243.15,75.8 242.72,76.24 v1(242.72,76.38) ; 238.98,81.15 239.03,81.15 239.14,81.04 239.25,81.04 239.33,81.11 239.33,81.65 239.29,81.68 239.15,81.68 239.08,81.76 U22.34 ; 238.98,81.15 v1(238.9,81.15)
MXM_MB_DP_AUX#_C: length 2.3
  BOTTOM w0.102: C398.2 241.45,80.64 241.45,81.76 241.58,81.89 U22.29
MXM_MB_DP_AUX_C: length 2.3
  BOTTOM w0.102: C397.2 241.22,80.64 241.22,81.76 241.08,81.9 U22.30
MXM_MB_DP_HPD: length 208.6
  IN2 w0.127: v1(59.66,101.46) 59.77,101.46 60.94,100.29 66.72,100.29 67.18,100.75 68.33,100.75 71.36,103.78 71.36,105.02 73.39,107.06 79.93,107.06 80.29,106.7 83.08,106.7 84.24,107.86 117.15,107.86 118.08,108.78 118.69,108.78 119.55,107.92 157.11,107.92 158.01,108.82 175.79,108.82 177.86,106.75 182.26,106.75 188.52,100.49 196.45,100.49 199.09,97.85 199.92,97.85 205.13,92.64 206.94,92.64 209.7,89.89 217.92,89.89 218.46,89.34 228.08,89.34 230.01,91.27 241.11,91.27 v1(242.08,90.31)
  BOTTOM w0.102: D8.2 57.64,103.55 56.35,103.55 55.58,102.79 55.58,101.61 55.79,101.41 56.37,101.41 56.68,101.71 U27.2 56.68,102.7 57.05,103.08 57.48,103.08 59.01,101.55 v2(59.11,101.55) 59.57,101.55 v1(59.66,101.46) ; v1(242.08,90.31) U22.9
MXM_MB_DP_HPD_GATE: length 7.6
  TOP w0.102: JMXM1.304 55.5,97.57 55.37,97.7 55.37,99.39 55.79,99.81 v1(58.45,99.81)
  BOTTOM w0.102: U27.4 58.17,100.51 58.45,100.23 v1(58.45,99.81)
MXM_MB_DP_N0: length 6.3
  TOP w0.102: C284.1 63.36,109.89 63.36,109.48 61.13,107.26 v3(61.13,106.83) 61.13,105.87 61.25,105.75 JMXM1.283
MXM_MB_DP_N0_C: length 191
  TOP w0.102: C284.2 63.35,111.42 63.35,111.61 v1(63.53,111.8)
  IN4 w0.117: v1(63.53,111.8) 63.36,111.97 63.36,112.16 63.6,112.4 64.05,112.4 66.88,109.57 74.3,109.57 74.97,110.24 77.12,110.24 77.25,110.12 82.19,110.12 83.74,108.57 117.2,108.57 117.53,108.9 118.82,108.9 119.24,108.48 126.49,108.48 127.06,107.91 157.94,107.91 158.6,107.25 164.04,107.25 165.82,105.47 177.09,105.47 181.86,100.7 182.34,100.7 187.91,95.13 194.6,95.13 197.16,92.57 197.16,91.94 202.43,86.68 210.17,86.68 211.01,85.84 223.07,85.84 223.55,86.32 227.02,86.32 228.78,84.56 232.98,84.56 234.32,83.23 235.64,83.23 235.95,83.54 235.95,83.86 v5(236.13,84.03)
  BOTTOM w0.102: U22.39 236.82,84.14 236.74,84.06 236.74,83.86 236.36,83.48 235.9,83.48 235.78,83.59 235.78,83.74 236.08,84.03 v5(236.13,84.03)
MXM_MB_DP_N1: length 6.2
  TOP w0.102: C283.1 61.58,109.89 61.58,109.32 v3(60.2,107.94) 59.63,107.37 59.63,105.87 59.75,105.75 JMXM1.289
MXM_MB_DP_N1_C: length 193
  TOP w0.102: v1(61.73,111.8) 61.57,111.64 61.57,111.42 C283.2
  IN4 w0.117: v5(236.1,86.22) 235.92,86.04 235.92,85.71 235.64,85.43 234.58,85.43 233.81,86.2 232.62,86.2 232.04,85.62 229.13,85.62 227.62,87.13 223.04,87.13 222.61,86.7 211.54,86.7 210.68,87.56 204.79,87.56 203.17,89.18 201.03,89.18 198.28,91.94 198.28,92.63 194.25,96.66 190.51,96.66 189.8,97.37 186.8,97.37 176.97,107.2 165.87,107.2 163.89,109.18 127.39,109.18 125.65,110.92 90.03,110.92 89.59,110.48 82.97,110.48 82.53,110.92 77.62,110.92 77.51,111.03 74.65,111.03 73.97,110.36 67.36,110.36 64.52,113.19 62.59,113.19 61.58,112.18 61.58,111.95 v1(61.73,111.8)
  BOTTOM w0.102: v5(236.1,86.22) 236.05,86.22 235.73,85.9 235.73,85.74 236.07,85.4 236.63,85.4 236.69,85.46 236.69,85.56 236.77,85.64 U22.42
MXM_MB_DP_N2: length 6.1
  TOP w0.102: JMXM1.295 58.25,105.78 58.13,105.89 58.13,107.21 59.8,108.88 v3(59.8,109.21) 59.8,109.89 C286.1
MXM_MB_DP_N2_C: length 193.5
  TOP w0.102: v1(59.98,111.8) 59.79,111.61 59.79,111.42 C286.2
  IN4 w0.117: v1(59.98,111.8) 59.8,111.97 59.8,112.13 61.65,113.98 64.91,113.98 67.41,111.47 70.96,111.47 71.02,111.54 73.56,111.54 73.84,111.82 77.94,111.82 78.04,111.72 82.84,111.72 83.24,111.31 88.96,111.31 89.37,111.72 126.27,111.72 127.54,110.45 157.69,110.45 157.95,110.2 164.81,110.2 167.02,107.99 177.3,107.99 187,98.28 194.52,98.28 199.32,93.49 199.32,93.08 201.13,91.27 207.25,91.27 209.74,88.78 229.06,88.78 230.16,87.68 233.91,87.68 234.61,86.98 235.86,86.98 236.13,87.24 236.13,87.57 v1(236.33,87.77)
  BOTTOM w0.102: U22.45 236.74,87.14 236.69,87.08 236.69,86.98 236.61,86.9 236.43,86.9 236.04,87.3 236.04,87.65 236.15,87.77 v1(236.33,87.77)
MXM_MB_DP_N3: length 5.9
  TOP w0.102: C282.1 58.02,109.89 v3(58.02,109.14) 58.02,108.47 56.63,107.08 56.63,105.9 56.75,105.78 JMXM1.301
MXM_MB_DP_N3_C: length 198.5
  TOP w0.102: C282.2 58.02,111.42 58.02,111.64 v1(58.17,111.8)
  IN4 w0.117: v1(58.17,111.8) 58.02,111.95 58.02,112.18 60.61,114.77 65.24,114.77 67.25,112.76 70.5,112.76 70.92,112.34 73.25,112.34 73.51,112.6 82.73,112.6 83.24,113.12 83.75,113.12 83.99,112.88 89.71,112.88 90.09,112.51 128.3,112.51 129.08,111.73 139.23,111.73 140.8,113.29 145.81,113.29 146.54,112.56 151.63,112.56 152.19,113.12 153.73,113.12 154.17,112.67 156.4,112.67 156.84,113.12 159.05,113.12 159.89,112.27 164.25,112.27 167.75,108.77 178.34,108.77 179.1,108.02 179.1,107.38 187.31,99.17 195,99.17 202.07,92.11 208.24,92.11 210.78,89.57 234.2,89.57 234.5,89.27 234.5,88.66 234.97,88.19 235.84,88.19 236.25,88.61 236.25,89.06 236,89.31 v5(236,89.52)
  BOTTOM w0.102: v5(236,89.52) 235.9,89.42 235.9,89.21 236.58,88.53 236.75,88.53 236.86,88.64 U22.48
MXM_MB_DP_P0: length 6.3
  TOP w0.102: C285.1 63.09,109.88 63.09,109.6 v3(62.11,108.62) 60.87,107.37 60.87,105.88 60.75,105.76 JMXM1.285
MXM_MB_DP_P0_C: length 191.1
  TOP w0.102: v1(62.9,111.8) 63.08,111.61 63.08,111.42 C285.2
  IN4 w0.117: v1(235.52,84.06) 235.67,83.91 235.67,83.65 235.53,83.51 234.44,83.51 233.1,84.85 228.89,84.85 227.14,86.6 223.44,86.6 222.95,86.12 211.12,86.12 210.29,86.96 202.54,86.96 197.44,92.06 197.44,92.69 194.72,95.41 188.03,95.41 182.46,100.99 181.97,100.99 177.21,105.76 165.94,105.76 164.16,107.53 158.72,107.53 158.05,108.19 127.18,108.19 126.61,108.77 119.36,108.77 118.94,109.18 117.42,109.18 117.08,108.85 83.86,108.85 82.31,110.4 77.37,110.4 77.24,110.53 74.86,110.53 74.18,109.85 67,109.85 64.16,112.69 63.48,112.69 63.07,112.27 63.07,111.97 v1(62.9,111.8)
  BOTTOM w0.102: v1(235.52,84.06) 235.52,83.48 235.79,83.21 236.47,83.21 236.9,83.64 U22.38
MXM_MB_DP_P1: length 6.2
  TOP w0.102: C280.1 61.31,109.88 61.31,109.43 59.37,107.49 v3(59.37,106.88) 59.37,105.85 59.25,105.74 JMXM1.291
MXM_MB_DP_P1_C: length 193.1
  TOP w0.102: v1(61.15,111.8) 61.31,111.64 61.31,111.42 C280.2
  IN4 w0.117: v1(235.47,86.22) 235.64,86.05 235.64,85.83 235.52,85.71 234.69,85.71 233.92,86.48 232.5,86.48 231.93,85.91 229.25,85.91 227.74,87.42 222.92,87.42 222.49,86.99 211.66,86.99 210.79,87.85 204.91,87.85 203.28,89.47 201.15,89.47 198.56,92.06 198.56,92.75 194.36,96.94 190.63,96.94 189.92,97.65 186.92,97.65 177.09,107.48 165.99,107.48 164.01,109.46 127.51,109.46 125.77,111.2 89.91,111.2 89.47,110.76 83.08,110.76 82.64,111.2 77.74,111.2 77.62,111.32 74.53,111.32 73.86,110.64 67.48,110.64 64.64,113.48 62.48,113.48 61.29,112.29 61.29,111.94 v1(61.15,111.8)
  BOTTOM w0.102: U22.41 235.96,85.14 235.47,85.63 v1(235.47,86.22)
MXM_MB_DP_P2: length 6.1
  TOP w0.102: C281.1 59.53,109.88 59.53,108.99 57.87,107.32 v3(57.87,106.89) 57.87,105.87 57.75,105.76 JMXM1.297
MXM_MB_DP_P2_C: length 193.6
  TOP w0.102: C281.2 59.53,111.42 59.53,111.61 v1(59.34,111.8)
  IN4 w0.117: v1(59.34,111.8) 59.52,111.97 59.52,112.24 61.54,114.26 65.02,114.26 67.53,111.76 70.84,111.76 70.9,111.82 73.44,111.82 73.72,112.1 78.06,112.1 78.16,112 82.96,112 83.36,111.6 88.84,111.6 89.25,112 126.39,112 127.66,110.73 157.81,110.73 158.06,110.48 164.93,110.48 167.14,108.27 177.42,108.27 187.12,98.57 194.64,98.57 199.6,93.61 199.6,93.2 201.24,91.56 207.37,91.56 209.86,89.07 229.18,89.07 230.28,87.96 234.02,87.96 234.73,87.26 235.75,87.26 235.85,87.36 235.85,87.56 v1(235.64,87.77)
  BOTTOM w0.102: U22.44 236.32,86.64 235.77,87.19 235.77,87.64 v1(235.64,87.77)
MXM_MB_DP_P3: length 6
  TOP w0.102: JMXM1.303 56.25,105.76 56.37,105.88 v3(56.37,106.82) 56.37,107.19 57.76,108.58 57.76,109.88 C279.1
MXM_MB_DP_P3_C: length 198.4
  TOP w0.102: v1(57.59,111.8) 57.75,111.64 57.75,111.42 C279.2
  IN4 w0.117: v1(57.59,111.8) 57.74,111.94 57.74,112.29 60.5,115.05 65.35,115.05 67.37,113.04 70.62,113.04 71.04,112.62 73.13,112.62 73.4,112.88 82.61,112.88 83.13,113.4 83.87,113.4 84.1,113.17 89.83,113.17 90.2,112.79 128.41,112.79 129.19,112.01 139.12,112.01 140.68,113.58 145.92,113.58 146.66,112.84 151.51,112.84 152.07,113.4 153.85,113.4 154.29,112.96 156.28,112.96 156.72,113.4 159.17,113.4 160.01,112.56 164.37,112.56 167.87,109.06 178.46,109.06 179.38,108.14 179.38,107.5 187.43,99.46 195.12,99.46 202.18,92.4 208.36,92.4 210.9,89.86 234.31,89.86 234.79,89.38 234.79,88.78 235.09,88.48 235.72,88.48 235.97,88.73 235.97,88.94 235.77,89.14 235.59,89.14 v1(235.52,89.06)
  BOTTOM w0.102: U22.47 236.87,88.14 236.75,88.26 236.47,88.26 235.67,89.06 v1(235.52,89.06)
MXM_OVERT#: length 42.8
  TOP w0.102: JMXM1.56 119.5,98.12 118.53,99.1 110.88,99.1 109.53,100.44 89.39,100.44 v1(86.88,97.93)
  BOTTOM w0.102: R10.2 85.07,101.36 85.07,100.3 v2(85.71,99.66) 86.88,98.49 v1(86.88,97.93) 87.9,98.95 Q4.3
MXM_PANEL_BKEN: length 110.6
  TOP w0.102: JMXM1.61 118.25,105.78 117.95,106.08 117.69,106.08 117.28,106.49 117.28,107.08 117.52,107.32 117.52,113.99 v2(117.34,114.18) v1(115.07,116.44)
  IN3 w0.127: v1(46.59,140.04) 46.59,140.29 48.78,142.48 49.41,142.48 50.28,143.34 50.28,144.77 51.19,145.68 55.74,145.68 58.48,148.42 67.06,148.42 71.53,152.9 77,152.9 77.26,152.64 78.73,152.64 80.39,150.98 85.1,150.98 90.86,145.21 90.86,139.18 97.81,132.23 98.39,132.23 101.33,129.29 101.33,126.3 104.1,123.53 104.1,122.57 107.53,119.14 108.7,119.14 112.18,115.66 114.46,115.66 115.07,116.27 v1(115.07,116.44)
  BOTTOM w0.102: D64.2 46.42,139.87 v1(46.59,140.04)
MXM_PRESENTL#: length 69.1
  TOP w0.102: UH1.G15 27.16,95.8 v1(26.78,95.42) ; JMXM1.310 54.25,105.65 53.74,106.16 v1(53.16,106.16)
  IN1 w0.109: v1(53.16,106.16) 52.56,106.16 51.32,107.4 51.32,109.4 50.25,110.48 48.89,110.48 48.44,110.03 43.68,110.03 42.71,111 35.76,111 34.45,109.69 29.96,109.69 28.84,108.57 28.84,107.68 28.13,106.97 28.13,106.77 27.62,106.26 27.62,105.67 27.21,105.27 26.6,105.27 25.85,104.52 25.6,104.52 25.35,104.26 25.35,103.43 26.53,102.25 27.57,102.25 27.92,101.89 27.92,101.67 28.62,100.98 28.62,100.73 27.9,100.01 27.9,99.6 27.49,99.2 27.01,99.2 25.42,97.61 25.42,96.92 26.78,95.57 v1(26.78,95.42)
  IN3 w0.127: v1(11.68,94.71) 11.95,94.98 14.61,94.98 15.5,94.09 23.61,94.09 24.93,95.42 v1(26.78,95.42)
  BOTTOM w0.102: RPH8.8 13.34,94.56 13.03,94.24 12.05,94.24 11.68,94.61 v1(11.68,94.71)
MXM_PRESENTR#: length 131
  TOP w0.102: v1(27.36,94.35) 27.16,94.55 UH1.G13 ; JMXM1.38 v1(124,103.44)
  IN2 w0.127: v1(27.36,94.35) 27.17,94.15 27.17,92.79 27.77,92.19 27.77,91.65 29.08,90.34 31.2,90.34 31.77,89.77 37.05,89.77 38.58,88.24 42.81,88.24 43.05,88.48 45.08,88.48 49.45,92.85 62.8,92.85 66.66,96.71 67.75,96.71 69.26,98.21 69.45,98.21 72.79,101.55 76.18,101.55 76.85,102.22 78.72,102.22 80.3,103.8 80.95,103.8 81.57,104.42 115.03,104.42 115.25,104.2 120.68,104.2 121.93,102.96 123.52,102.96 v1(124,103.44)
  BOTTOM w0.102: RPH9.7 14.58,97.83 15.85,96.56 17.01,96.56 17.55,96.02 18.96,96.02 20.54,94.45 24,94.45 v2(24.26,94.71) 24.41,94.85 26.44,94.85 26.57,94.73 26.98,94.73 v1(27.36,94.35)
MXM_PWR_LEVEL: length 10.1
  TOP w0.102: JMXM1.54 v1(120,97.93)
  BOTTOM w0.102: v2(124.49,102.63) 123.8,101.93 123.8,101.67 123.37,101.24 U17.4 123.92,100.61 R37.2 123.96,99.76 123.17,99.76 121.34,97.93 v1(120,97.93)
MXM_RSVD1: length 4.8
  TOP w0.102: v1(64.47,99.23) 64.76,98.94 64.76,98.05 64.5,97.79 JMXM1.268
  BOTTOM w0.102: v1(64.47,99.23) 64.81,98.9 v2(64.81,98.32) 64.81,97.33 R6.2
MXM_RSVD2: length 4.7
  TOP w0.102: JMXM1.270 64,98.32 v1(64.34,98.66)
  BOTTOM w0.102: v1(64.34,98.66) 64.34,98.09 63.79,97.54 R1979.2 62.94,97.27 v2(62.8,97.13)
MXM_SRC_EN#: length 5.7
  TOP w0.102: v2(148.54,110.37) 149.21,109.7 C774.1
  TOP w0.508: C774.1 150.17,109.7 150.54,109.33 R944.1 R940.2 149.41,108.93 Q186.4
NB_LAN_TX0+: length 9.8
  TOP w0.229: T156.24 156.82,155.6 157.23,156.02 157.23,156.75 162.18,161.7 JLOM1.1
NB_LAN_TX0-: length 9.8
  TOP w0.229: JLOM1.2 162.97,161.45 162.42,161.45 157.58,156.61 157.58,156.03 158.09,155.52 T156.23
NB_LAN_TX1+: length 9.5
  TOP w0.229: v1(162.21,156.75) 162.36,156.61 162.36,156.27 161.9,155.8 T156.20
  IN1 w0.178: v1(162.21,156.75) 162.37,156.91 162.37,157.72 164.05,159.4 164.58,159.4 164.84,159.65 164.84,159.94 164.22,160.56 JLOM1.3
NB_LAN_TX1-: length 9.5
  TOP w0.229: T156.19 163.17,155.8 162.7,156.27 162.7,156.61 v1(162.85,156.75)
  IN1 w0.178: JLOM1.6 166.48,161.22 165.16,159.9 165.16,159.52 164.71,159.08 164.18,159.08 162.69,157.59 162.69,156.91 v1(162.85,156.75)
NB_LAN_TX2+: length 8.2
  TOP w0.229: T156.18 164.44,155.75 164.92,156.24 164.92,159.34 166.05,160.47 166.05,161.2 165.72,161.53 165.55,161.53 JLOM1.4
NB_LAN_TX2-: length 8.3
  TOP w0.229: T156.17 165.71,155.8 165.27,156.24 165.27,159.2 166.39,160.32 166.39,162.19 JLOM1.5
NB_LAN_TX3+: length 8.8
  TOP w0.229: JLOM1.7 168.19,162.21 168.19,160.42 169,159.61 169.56,159.61 169.9,159.28 169.9,155.95 169.52,155.57 T156.14
NB_LAN_TX3-: length 8.8
  TOP w0.229: JLOM1.8 169.06,161.48 168.82,161.48 168.54,161.2 168.54,160.56 169.15,159.95 169.71,159.95 170.24,159.42 170.24,155.97 170.79,155.42 T156.13
NB_PSID: length 11.7
  TOP w0.102: v1(4.86,73.43) PL3.2
  BOTTOM w0.102: v1(4.86,73.43) 5.73,74.3 PJPDC1.2 14.13,74.3 v2(14.77,74.94)
NB_PSID_TS5A63157: length 5.7
  TOP w0.102: PU1.3 3.81,86.81 3.59,87.03 2.32,87.03 PR8.1 ; PR8.1 1.81,87.78 3.08,89.05 v2(3.08,89.08) ; PR8.1 1.79,87.51 PR9.2
NTC: length 50.9
  TOP w0.102: PU500.6 53.53,22.69 PR528.1 v1(54.14,22.77) ; v1(40.14,41.23) 40.72,41.82 v2(40.72,42.43) 40.72,43.09 42.2,44.56 42.2,48.93 40.06,51.06 40.06,55.18 41.44,56.55 PH500.1
  IN4 w0.102: v1(54.14,22.77) 52.92,21.55 48.88,21.55 47.33,23.1 47.33,26.83 46.35,27.81 44.36,27.81 43.04,29.13 43.04,33.13 41.37,34.8 41.37,38.66 40.14,39.89 v1(40.14,41.23)
NUM_LED: length 85.2
  TOP w0.102: JIO1.92 v1(14.31,84)
  IN2 w0.127: v1(14.31,84) 13.27,85.04 13.27,90.73 12.12,91.87 12.12,92.91 11.14,93.9 11.14,95.41 10.75,95.79 10.75,103.98 10.31,104.42 10.31,105.07 9.15,106.23 9.15,109.84 11.49,112.17 11.49,113.3 12.67,114.48 13.53,114.48 15.07,116.03 15.32,116.03 16.09,116.8 16.09,117.69 14.66,119.12 14.66,123.76 11.82,126.6 11.82,133.23 13.62,135.04 13.62,138.55 14.23,139.16 14.23,140.9 12.89,142.25 12.89,151.54 11.36,153.07 10.68,153.07 8.92,151.32 v1(8.92,151.22)
  BOTTOM w0.102: v2(8.67,149.88) 8.67,150.19 8.29,150.57 R942.2 8.75,151.04 v1(8.92,151.22)
NUM_LED#: length 301
  IN1 w0.109: v1(38.06,165.71) 37.28,166.48 28.08,166.48 26.21,164.61 19.12,164.61 15.18,160.67 15.18,155.63 13.86,154.31 v1(13.86,150.73)
  IN3 w0.127: v1(202.93,90) 202.78,89.85 199.72,89.85 197.8,91.77 197.8,92.68 196.99,93.48 196.09,93.48 193.62,95.95 192.7,95.95 191.79,96.86 185.55,96.86 184.66,95.97 180.98,95.97 175.19,101.76 172.21,101.76 159.08,114.9 159.08,116.72 157.3,118.5 157.3,121.17 152.51,125.96 151.31,125.96 150.16,127.11 150.16,129.43 135.92,143.67 133.05,143.67 132.05,142.67 118.27,142.67 117.44,143.5 101.21,143.5 98.05,146.66 97.55,146.66 96.65,147.56 94.74,147.56 92.85,149.46 92.85,149.92 92.45,150.32 92.3,150.32 88.56,154.06 88.56,154.49 85.95,157.1 85.95,159.23 85.07,160.11 78.8,160.11 78.28,159.59 64.98,159.59 63.07,157.68 60.97,157.68 57.27,153.99 52.05,153.99 50.35,152.29 50.35,150.05 48.78,148.47 46.99,148.47 44.83,150.63 43.14,150.63 41.36,152.41 41.36,163.37 39.44,165.29 38.48,165.29 v1(38.06,165.71)
  BOTTOM w0.102: U46.A2 221.17,75.47 221.73,74.91 221.73,72.15 221.44,71.86 221.24,71.86 221.19,71.82 220.55,71.82 219.25,70.52 214.8,70.52 v2(214.21,69.93) 213.51,69.23 207.25,69.23 202.7,73.77 202.7,88.01 203.06,88.36 203.06,89.88 v1(202.93,90) ; Q84.3 v1(13.86,150.73)
NVRAM_PWR_EN: length 80.5
  TOP w0.102: v1(263.23,56.75) 260.31,59.68 258.66,59.68 253.63,64.7 247.54,64.7 247.28,64.45 244.56,64.45 240.14,68.87 227.46,68.87 227.18,68.59 218.75,68.59 216.01,71.33 213.65,71.33 211.08,73.9 211.08,76.9 209.76,78.22 209.76,80.38 210.52,81.14 214.82,81.14 215.4,81.72 215.4,82.92 214.59,83.73 v1(214.59,83.75)
  BOTTOM w0.102: v1(263.23,56.75) 263.57,56.41 R720.1 263.88,56.08 264.17,55.79 264.91,55.79 265.34,56.22 U43.3 ; U46.B32 214.25,84.27 214.56,83.96 214.56,83.78 v1(214.59,83.75)
P1_SW: length 28.6
  TOP w0.102: v1(55.79,38.52) v2(55.79,39.41)
  TOP w0.254: v1(52.74,58.48) 52.72,58.48 52.74,58.46 PL502.2 ; v1(55.79,38.52) 55.41,38.14 PR553.1
  IN1 w0.254: v1(52.74,58.48) 53.4,58.48 55,56.88 55.55,56.88 56.38,56.06 56.38,49.77 57.31,48.84 57.31,40.77 55.91,39.38 55.91,38.64 v1(55.79,38.52)
  BOTTOM w0.254: PR553.1 55.79,38.2 v1(55.79,38.52)
P2_SW: length 15.4
  TOP w0.254: PL501.2 v1(52.74,47.66) ; PR539.1 53.12,38.14 v1(53.5,38.52)
  IN1 w0.254: v1(53.5,38.52) 53.63,38.64 53.63,39.31 54.77,40.45 54.77,47.03 54.39,47.41 53.22,47.41 52.96,47.66 v1(52.74,47.66)
  BOTTOM w0.254: PR539.1 53.5,38.2 v1(53.5,38.52)
  vias: v2(55.01,41.65)
P3_SW: length 41.3
  TOP w0.102: PC507.1 50.96,75.09 v2(51.3,75.44)
  TOP w0.254: v1(52.36,69.25) 52.74,69.63 PL500.2 ; PR510.2 57.69,38.14 v1(58.07,38.52)
  IN1 w0.254: v1(58.07,38.52) 58.2,38.64 58.2,49.66 57.18,50.68 57.18,66.58 55.66,68.11 53,68.11 52.55,68.56 52.55,69.06 v1(52.36,69.25)
  BOTTOM w0.254: v1(58.07,38.52) 58.07,38.2 PR510.2
P33ALW: length 3.4
  BOTTOM w0.254: PR1025.1 147.25,123.92 v2(147.56,123.62) 147.56,123.05 148.32,122.28 PU1001.18
P33ALW2: length 3.1
  BOTTOM w0.254: PR1022.2 148.24,115.54 v2(148.76,116.06) 149.7,117 PU1001.9
P50ALW: length 3.9
  BOTTOM w0.254: PR1012.1 155.86,124.9 v2(155.58,124.62) 155.46,124.5 154.58,124.5 153.7,123.62 PU1001.27
PANEL_BKEN_EC: length 214.5
  IN3 w0.127: v1(215.17,87.46) 214.61,86.9 213.11,86.9 211.69,88.33 200.16,88.33 193.31,95.18 180.69,95.18 174.87,101 171.83,101 157.5,115.33 157.5,117.22 156.54,118.18 156.54,120.85 152.19,125.2 150.99,125.2 149.4,126.79 149.4,127.88 141.15,136.13 139.47,136.13 137.93,137.67 137.93,138.58 135.37,141.14 134.5,141.14 133.76,141.88 117.98,141.88 117.12,142.73 100.22,142.73 97.77,145.18 96.98,145.18 95.74,146.43 93.65,146.43 85.96,154.12 85.96,154.44 84.66,155.74 81.8,155.74 81.19,155.13 80.27,155.13 79.13,156.27 60.64,156.27 57.58,153.21 52.35,153.21 51.67,152.53 51.67,151.83 51.82,151.67 51.82,149.54 47.68,145.4 47.68,142.56 v1(46.82,141.69)
  BOTTOM w0.102: v1(215.17,87.46) 215.17,87.49 215.17,87.49 U46.A35 ; D69.2 47.57,142.44 v1(46.82,141.69) 46.82,141.43 v2(47.38,140.87)
PANEL_BKEN_PCH: length 89.5
  TOP w0.102: v1(28.2,104.86) 28.2,104.44 28.36,104.29
  IN3 w0.127: v1(33.56,134.12) 34.03,134.12 36.04,132.12 42.29,132.12 42.67,132.5 48.11,132.5 49.52,131.09 55.26,131.09 56.78,129.57 56.78,117.97 53.65,114.84 53.65,108.51 52.65,107.5 49.1,107.5 45.98,104.38 40.62,104.38 39.56,103.31 38.39,103.31 38.11,103.03 36.15,103.03 35.87,102.75 35.54,102.75 35.24,103.06 35.24,106.36 34.86,106.74 33.77,106.74 33.54,106.97 32.8,106.97 32.57,106.74 31.38,106.74 30.95,106.31 29.98,106.31 29.57,106.72 29.07,106.72 28.71,106.36 28.71,105.37 28.2,104.86 v1(28.2,104.86)
  BOTTOM w0.102: v1(33.56,134.12) 34.55,135.11 34.55,137.1 36.3,138.85 v2(36.86,138.85) 37.07,139.05 U54.2
PANEL_BKEN_SW: length 47.6
  IN4 w0.109: v1(76.13,151.42) 76.13,151.29 75.55,150.71 73.97,150.71 71.1,147.84 55.74,147.84 54.97,147.08 53.7,147.08 52.77,146.15 51.23,146.15 49.69,144.61 49.69,142.83 49.18,142.33 48.29,142.33 45.21,139.24 v1(45.21,138.91)
  BOTTOM w0.102: U23.44 75.89,151.1 76.13,151.34 v1(76.13,151.42) ; U54.1 39.24,138.4 39.77,138.94 41.08,138.94 v2(42.05,137.97) 42.31,137.7 R432.1 44.92,138.33 45.21,138.62 v1(45.21,138.91)
PBA_GPU_SEL#: length 247.9
  TOP w0.102: v1(43.29,147.33) 43.11,147.15 42.1,147.15 v2(41.34,146.39) 38.47,143.52 37.56,143.52 37.04,143 35.89,143 34.98,143.9 34.98,147.13 35.63,147.77 U629.54
  IN3 w0.127: v1(43.29,147.33) 43.7,146.92 48.47,146.92 50.63,149.08 50.63,152.21 52.15,153.73 57.38,153.73 60.43,156.78 78.67,156.78 79.31,157.41 80.81,157.41 81.97,156.25 84.87,156.25 86.47,154.65 86.47,154.33 93.49,147.31 96.54,147.31 97.44,146.4 97.95,146.4 101.11,143.24 117.34,143.24 118.16,142.42 132.25,142.42 133.26,143.42 134.6,143.42 138.44,139.58 138.44,137.88 139.65,136.68 141.32,136.68 149.91,128.09 149.91,127.01 151.21,125.71 152.4,125.71 157.05,121.06 157.05,118.39 158.82,116.62 158.82,114.79 172.11,101.51 175.08,101.51 180.88,95.72 184.77,95.72 185.66,96.61 191.68,96.61 192.6,95.69 193.52,95.69 195.98,93.23 196.89,93.23 197.54,92.57 197.54,91.67 199.66,89.55 204.63,89.55 v1(205.04,89.14)
  BOTTOM w0.102: U46.A15 214.67,74.54 213.32,73.19 213.32,72.65 211.77,71.11 211.07,71.11 210.65,71.52 207.63,71.52 205.09,74.07 205.09,78.76 205.65,79.32 205.65,80.46 205.14,80.97 205.14,89.04 v1(205.04,89.14)
PBAT_PRES#: length 310.3
  TOP w0.102: v1(258.07,63.64) 257.64,63.64 257.31,63.31 256.11,63.31 254.26,65.16 247.35,65.16 247.1,64.91 244.77,64.91 243.75,65.93 243.75,70.77 241.68,72.83 236.38,72.83 236.18,72.63 228.02,72.63 225.28,75.37 225.28,77.46 222.54,80.2 220.05,80.2 215.91,84.34 215.91,84.8 v1(216.32,85.2)
  IN1 w0.109: v1(216.32,85.2) 215.87,85.64 211.93,85.64 210.87,86.7 202.16,86.7 197.54,91.33 197.54,94.15 192.78,98.9 186.04,98.9 176.56,108.38 175.7,108.38 172.13,111.95 172.13,119.76 169.92,121.97 169.92,127.24 167.3,129.86 167.3,131.4 165.85,132.84 159.09,132.84 154.79,137.14 154.79,139.34 150.07,144.06 150.07,145.83 150.91,146.67 150.91,148.63 148.83,150.71 148.83,151.29 v1(148.8,151.32)
  IN3 w0.127: v1(258.07,63.64) 258.28,63.84 268.44,63.84 270.01,62.27 270.01,46.12 264.39,40.5 252.36,40.5 248.27,36.41 237.98,36.41 228.44,26.87 199.57,26.87 196.15,23.45 189.79,23.45 185.96,27.29 185.28,27.29 v1(184.87,27.7)
  BOTTOM w0.102: U46.B40 216.42,85.31 v1(216.32,85.2) ; PR2.2 174.63,28.48 174.68,28.53 176.34,28.53 176.44,28.43 PD5.1 176.44,27.77 177.77,26.44 v2(180.12,26.44) 183.17,26.44 183.39,26.66 PR3.7 184.45,26.66 184.74,26.96 184.74,27.57 v1(184.87,27.7) ; PU1081.1 152.07,152.14 151.62,152.59 150.07,152.59 v1(148.8,151.32)
PBAT_SMBCLK: length 217.2
  TOP w0.102: RP5.8 102.64,164.76 102.5,164.63 102.5,164.52 103.25,163.78 103.25,163.14 v1(103.72,162.67)
  IN1 w0.109: v1(161.1,96.1) 161.34,95.85 161.34,95.71 161.2,95.57 161.02,95.57 159.8,96.79 136.59,96.79 136.05,96.25 125.1,96.25 123.05,98.31 123.05,98.61 122,99.65 122,101.74 120.91,102.83 120.91,107.12 122.85,109.06 122.85,123.09 123.63,123.87 123.63,125.74 117.61,131.76 117.61,136.87 114.86,139.62 114.86,142.43 117.2,144.77 117.2,154.98 115.27,156.91 115.27,160.11 114.53,160.85 112.32,160.85 111.48,161.69 104.51,161.69 103.72,162.48 v1(103.72,162.67)
  BOTTOM w0.102: U51.A56 103.5,162.45 v1(103.72,162.67) ; PR3.5 183.83,25.66 183.69,25.8 173.16,25.8 172.35,26.61 172.35,30.52 171.31,31.56 171.31,34.43 170.93,34.81 169.41,34.81 167.75,36.47 164.28,39.93 164.28,43.96 165.9,45.57 165.9,50.4 166.45,50.95 167.72,50.95 167.99,51.22 167.99,53.14 166.53,54.6 166.53,67.3 161.3,72.53 161.3,95.9 v1(161.1,96.1)
PBAT_SMBDAT: length 221.2
  TOP w0.102: v1(103.89,159.88) 103.79,159.88 103.46,160.21 103.46,162.35 103.31,162.5 103.31,162.76 103.02,163.05 103.02,163.68 102.27,164.43 102.27,164.63 102.14,164.76 RP5.7
  IN1 w0.109: v1(161.73,96.1) 161.58,95.95 161.58,95.62 161.3,95.34 160.92,95.34 159.7,96.56 136.69,96.56 136.15,96.02 125.01,96.02 122.81,98.21 122.81,98.51 121.77,99.56 121.77,101.64 120.68,102.73 120.68,107.22 122.61,109.15 122.61,123.19 123.39,123.97 123.39,125.65 117.37,131.67 117.37,136.77 114.62,139.53 114.62,142.52 116.97,144.87 116.97,154.88 115.04,156.81 115.04,160.01 114.44,160.61 112.23,160.61 111.39,161.45 105.06,161.45 104.3,160.69 104.3,160.23 103.92,159.85 v1(103.89,159.88)
  BOTTOM w0.102: U51.B59 103.25,160.35 103.72,159.88 v1(103.89,159.88) ; PR3.6 183.84,26.16 183.7,26.03 173.25,26.03 172.58,26.71 172.58,30.62 171.53,31.66 171.53,34.52 171.02,35.04 169.5,35.04 167.98,36.56 167.98,36.56 164.51,40.03 164.51,43.86 166.12,45.48 166.12,50.3 166.54,50.72 167.81,50.72 168.22,51.13 168.22,53.24 166.76,54.7 166.76,67.4 161.53,72.63 161.53,95.9 v1(161.73,96.1)
PBATT+: length 153
  IN1 w0.254: v1(159.14,120.25) 157.92,119.04 157.92,118.58 158.71,117.79 158.71,117.41 160.08,116.04 160.08,114.74 161.78,113.04 161.78,110.69 169.65,102.83 172.72,102.83 184.9,90.65 184.9,85.53 v1(184.84,85.48)
  IN2 w0.254: v1(195.84,34.96) 195.84,33.28 194.57,32.01 189.66,32.01 188.8,31.15 186.6,31.15 186.41,30.96 176.28,30.96 175.22,32.02 175.22,45.55 172.78,47.99 172.78,52.37 170.24,54.91 170.24,57.83 170.91,58.5 170.91,78.44 172.55,80.07 173.69,80.07 174.83,81.21 v3(174.83,81.22)
  IN4 w0.254: v3(174.83,81.22) 181.51,81.22 184.26,78.47 v1(188.78,78.47)
  BOTTOM w0.254: v1(184.84,85.48) 184.79,85.43 184.79,82.46 v4(186.43,80.83) v1(188.78,78.47) ; PR1008.2 158.49,122.59 159.22,121.87 159.22,120.33 v1(159.14,120.25)
PBATT+_C:
  vias: v2(162.71,22.06) v3(201.33,32.51) v3(201.33,31.87) v3(201.33,31.24) v3(201.96,32.5) v3(201.96,31.86) v3(201.96,31.23) v3(202.6,32.5) v3(202.6,31.86) v3(202.6,31.23) v3(203.23,32.5) v3(203.23,31.86) v3(203.23,31.23) v3(203.87,32.5) v3(203.87,31.86)
PBATT_IN_SS:
  vias: v2(183.45,29.84)
PCH_ALW_ON: length 194.2
  TOP w0.102: v1(111.53,149.64) 112.07,150.19 v2(112.07,151.33) 112.07,151.71 114.61,154.25 114.61,156.37 115.48,157.23 115.48,168.08 v1(116.37,168.97)
  IN2 w0.127: v1(30.54,139.05) 30.54,139.22 32.39,141.08 32.39,143.84 34.79,146.24 38.71,146.24 41.11,148.64 41.11,152.2 43.7,154.8 46.68,154.8 47.94,156.06 49.41,156.06 50.08,156.73 51.9,156.73 54.61,159.45 61.04,159.45 63.2,161.61 63.2,163.06 65.1,164.96 66.32,164.96 70.03,168.67 87.97,168.67 88.73,167.9 94.04,167.9 97.61,171.47 113.86,171.47 v1(116.37,168.97)
  IN3 w0.127: v1(57.29,109.42) 57.13,109.27 56.68,109.27 55.48,110.47 55.48,113.77 57.03,115.33 57.03,129.68 55.37,131.35 49.62,131.35 48.19,132.78 42.57,132.78 42.22,132.43 36.39,132.43 34.12,134.71 34.12,135.54 30.61,139.05 v1(30.54,139.05) ; v1(104.5,150.33) 104.9,149.93 104.9,149.2 105.28,148.82 108.01,148.82 108.03,148.84 108.33,148.84 109.42,149.92 111.25,149.92 v1(111.53,149.64)
  BOTTOM w0.102: U51.A23 v1(104.5,150.33) ; PR23.1 31.28,139.79 v1(30.54,139.05) ; RP7.8 111.92,149.25 v1(111.53,149.64) ; U34.5 56.4,109.44 56.5,109.34 57.21,109.34 v1(57.29,109.42)
PCH_AZ_BITCLK: length 6
  TOP w0.102: RH65.2 20.13,100.92 20.76,100.92 21.04,100.65 21.04,100.44 21.76,99.72 22.58,99.72 22.63,99.77 23.78,99.77 23.8,99.78 24.47,99.78 24.62,99.93 UH1.B25
PCH_AZ_CODEC_BITCLK: length 6.8
  TOP w0.102: JIO1.36 14.44,100.8 14.77,101.13 v2(15.82,101.13) CH9.1 17.38,101.79 18.65,101.79 19.01,101.43 RH65.1
PCH_AZ_CODEC_RST#: length 6.4
  TOP w0.102: JIO1.40 14.5,99.6 14.83,99.27 16.01,99.27 16.42,98.87 17.94,98.87 18.3,99.22 RH63.1
PCH_AZ_CODEC_SDIN0: length 21.6
  TOP w0.102: UH1.L22 28.55,98.38 v1(28.05,98.38) ; v1(11.34,99.17) 12.11,98.4 JIO1.44
  IN3 w0.127: v1(11.34,99.17) 11.49,99.17 12.99,100.67 16.49,100.67 16.75,100.42 19.36,100.42 19.76,100.01 23.98,100.01 25.48,98.51 26.74,98.51 27.01,98.78 27.66,98.78 v1(28.05,98.38)
PCH_AZ_CODEC_SDOUT: length 4
  TOP w0.102: RH59.1 16.32,99.76 v2(15.77,99.76) 15.05,99.76 14.6,100.2 JIO1.38
PCH_AZ_CODEC_SYNC: length 6.3
  TOP w0.102: JIO1.42 14.42,99 15.1,98.32 v2(15.87,98.32) 16.39,98.32 16.46,98.38 18.96,98.38 RH61.1
PCH_AZ_RST#: length 6.2
  TOP w0.102: RH63.2 20.75,99.22 21.17,98.8 v2(22.12,98.8) 22.2,98.8 22.79,99.39 23.94,99.39 23.96,99.4 24.3,99.4 24.5,99.19 24.76,99.19 25.07,99.5 UH1.C24
PCH_AZ_SDOUT: length 8.8
  TOP w0.102: UH1.A24 24.54,99.59 23.88,99.59 23.86,99.58 22.71,99.58 22.41,99.29 21.4,99.29 v2(20.79,99.9) 20.57,100.11 RH35.2 19.41,100.62 18.7,100.62 18.53,100.44 17.84,100.44 RH45.2 RH59.2
PCH_AZ_SYNC: length 5.7
  TOP w0.102: RH61.2 20.72,98.33 v2(20.9,98.16) 22.14,98.16 22.63,98.64 22.63,98.96 22.86,99.2 23.38,99.2 24.01,98.56 24.5,98.56 UH1.A22
PCH_BATLOW#: length 9.8
  TOP w0.102: UH1.K7 28.47,92.31 v1(28.25,92.53)
  BOTTOM w0.102: RH112.2 21.73,92.62 21.97,92.87 v2(22.47,92.87) 24.53,92.87 25.22,93.56 26.04,93.56 26.6,93 26.93,93 27.49,92.44 28.16,92.44 v1(28.25,92.53)
PCH_CL_CLK1: length 162.5
  TOP w0.102: UH1.AF11 35.5,93.83 v1(35.79,93.83)
  IN3 w0.089: 42.69,95.96 42.67,95.94 42.67,95.86 42.25,95.44 41.76,95.44 41.34,95.86 39.5,95.86 38.78,95.13 36.42,95.13 36.21,94.92 36.21,93.69 36.12,93.61 36,93.61 35.79,93.81 v1(35.79,93.83)
  IN3 w0.127: v1(79.41,139.33) 79.56,139.48 79.71,139.48 80.05,139.14 81.39,137.8 81.39,136.84 78.49,133.95 78.49,127.14 79.07,126.57 79.07,121.29 75.42,117.64 75.42,116.31 76.59,115.15 76.59,108.32 75.24,106.97 74.91,106.97 74.34,106.4 74.34,105.69 72.86,104.21 72.86,102.95 71.29,101.38 69.88,101.38 67.8,99.3 67.8,98.36 67.59,98.16 66.76,98.16 64.42,95.82 56.58,95.82 54.21,98.18 52.1,98.18 49.89,95.97 49.89,95.62 49.46,95.18 46.67,95.18 45.72,96.14 42.87,96.14 42.69,95.96
  IN4 w0.109: v1(79.41,139.33) 79.6,139.53 80.39,139.53 89.77,148.91 89.77,156.47 97.03,163.73 111.11,163.73 111.42,164.04 122.34,164.04 124.1,162.28 127.47,162.28 128.51,161.24 132.12,161.24 133.74,159.62 134.35,159.62 v1(134.53,159.45)
  BOTTOM w0.102: JMINI4.45 135.29,159.34 135,159.63 134.71,159.63 v1(134.53,159.45)
PCH_CL_DATA1: length 163.3
  TOP w0.102: UH1.AF10 35.46,93.51 v1(35.79,93.18)
  IN3 w0.089: 42.9,95.74 42.8,95.74 42.32,95.26 41.68,95.26 41.27,95.68 39.58,95.68 38.85,94.96 36.5,94.96 36.39,94.85 36.39,93.62 36.19,93.43 36,93.43 35.79,93.23 v1(35.79,93.18)
  IN3 w0.127: v1(79.41,139.94) 79.61,139.74 79.82,139.74 81.64,137.91 81.64,136.74 78.75,133.84 78.75,127.25 79.32,126.67 79.32,121.18 75.68,117.54 75.68,116.42 76.84,115.25 76.84,108.21 75.35,106.72 75.02,106.72 74.59,106.29 74.59,105.58 73.11,104.1 73.11,102.84 71.4,101.13 69.99,101.13 68.06,99.2 68.06,98.26 67.7,97.9 66.86,97.9 64.52,95.56 56.47,95.56 54.11,97.93 52.21,97.93 50.15,95.87 50.15,95.51 49.57,94.93 46.57,94.93 45.61,95.89 43.05,95.89 42.9,95.74
  IN4 w0.109: v1(134.53,160.04) 134.35,159.86 133.84,159.86 132.22,161.48 128.61,161.48 127.57,162.52 124.19,162.52 122.44,164.27 111.32,164.27 111.01,163.97 96.94,163.97 89.54,156.57 89.54,149 80.29,139.76 79.59,139.76 v1(79.41,139.94)
  BOTTOM w0.102: JMINI4.47 135.23,160.14 134.94,159.86 134.71,159.86 v1(134.53,160.04)
PCH_CL_RST1#: length 164.4
  TOP w0.102: v1(35.8,92.59) 35.51,92.59 UH1.AF7
  IN3 w0.127: v1(35.8,92.59) 36.64,92.59 37.19,93.15 37.19,93.86 37.42,94.09 38.29,94.09 38.52,93.86 41.46,93.86 41.54,93.79 42.51,93.79 45.05,91.25 49.08,91.25 51.09,89.24 51.09,88.4 51.47,88.02 52.23,88.02 52.97,88.76 52.97,90.26 55.33,92.62 56.39,92.62 56.82,93.05 63.71,93.05 64.17,93.51 67.19,93.51 67.85,94.17 67.85,95.18 70.07,97.4 70.22,97.4 71.85,99.03 72.21,99.03 74.93,101.75 78.03,101.75 80.25,103.97 82.32,103.97 84.7,106.35 84.7,111.04 85.66,112 85.66,115.3 87.79,117.43 93.46,117.43 v1(94.24,116.65)
  IN4 w0.109: v1(130.35,151.81) 130.35,150.77 135.59,145.53 135.59,137.41 129.88,131.7 128.15,131.7 121.4,124.94 121.4,121.97 116.5,117.07 109.94,117.07 109.51,117.51 101.02,117.51 100.52,117 94.6,117 v1(94.24,116.65)
  BOTTOM w0.102: v1(130.35,151.81) 130.35,155.03 130.13,155.24 130.13,158.61 v2(131.27,159.74) 131.83,160.31 133.51,160.31 134.35,161.15 134.95,161.15 135.15,160.94 JMINI4.49
PCH_CLK_BIASREF: length 3
  TOP w0.102: UH1.AN44 38.03,109.8 v1(38.01,109.81)
  BOTTOM w0.102: v1(38.01,109.81) 38.26,109.56 RH165.1
PCH_CRT_BLU: length 94.8
  TOP w0.102: RH115.2 25.99,112.43 25.99,113.7 v1(26.45,114.16)
  TOP w0.178: UH1.T45 31.1,109.13 30.41,109.81 29.24,109.81 28.09,110.97 27.46,110.97 RH115.2
  IN4 w0.109: v1(81.95,154.85) 81.75,154.85 81.21,154.32 81.21,153.76 80.67,153.21 80.67,151.01 79.75,150.09 79.75,147.72 77.14,145.11 71.46,145.11 69.93,146.64 55.85,146.64 55.4,146.2 54.19,146.2 53.23,145.25 51.6,145.25 50.56,144.21 50.56,141.98 49.54,140.96 48.77,140.96 45.95,138.14 44.4,138.14 43.75,138.8 42.68,138.8 41.33,137.45 39.07,137.45 37.73,136.1 37.73,135.27 32.58,130.12 32.58,123.19 30.23,120.85 30.23,119.32 26.73,115.82 26.73,114.44 v1(26.45,114.16)
  BOTTOM w0.102: v1(81.95,154.85) 82.2,155.1 U19.19
PCH_CRT_DDC_CLK: length 95.6
  TOP w0.102: v1(24.55,114.13) 24.77,113.9 24.77,112.51 27.07,110.22 27.72,110.22 28.38,109.56 28.71,109.56 29.04,109.23 29.04,108.4 29.47,107.97 UH1.M43
  IN4 w0.109: v1(83.9,154.32) 83.73,154.49 83.73,155.23 82.99,155.97 81.29,155.97 78.93,153.61 73.95,153.61 68.92,148.58 54.09,148.58 52.38,146.87 49.64,146.87 48.21,145.45 48.21,144.33 45.75,141.87 44.91,141.87 44.11,141.06 43.37,141.06 40.88,138.58 38.11,138.58 35.06,135.52 35.06,134.63 33.71,133.28 33.71,132.82 31.47,130.58 31.47,123.65 29.12,121.3 29.12,119.78 25.25,115.91 25.25,115.26 24.74,114.75 24.74,114.33 v1(24.55,114.13)
  BOTTOM w0.102: U19.15 83.8,155.18 83.73,155.1 83.73,154.49 v1(83.9,154.32)
PCH_CRT_DDC_DAT: length 93.8
  TOP w0.102: UH1.M45 29.47,108.41 29.36,108.41 29.27,108.5 29.27,109.33 28.81,109.79 28.48,109.79 27.81,110.45 27.16,110.45 25,112.61 25,113.96 v1(25.18,114.13)
  IN4 w0.109: v1(83.32,154.32) 83.5,154.49 83.5,155.13 82.89,155.74 81.39,155.74 79.03,153.38 74.05,153.38 69.02,148.35 54.19,148.35 52.48,146.64 49.73,146.64 48.45,145.35 48.45,144.23 45.85,141.63 45.01,141.63 44.2,140.83 43.47,140.83 40.98,138.34 38.21,138.34 35.3,135.43 35.3,134.54 33.94,133.18 33.94,132.73 31.7,130.49 31.7,123.55 29.35,121.2 29.35,119.68 25.48,115.81 25.48,115.16 24.98,114.66 24.98,114.33 v1(25.18,114.13)
  BOTTOM w0.102: U19.16 83.4,155.18 83.5,155.08 83.5,154.49 v1(83.32,154.32)
PCH_CRT_GRN: length 92.5
  TOP w0.102: v1(27.47,114.16) 26.96,113.65 26.96,112.48 RH116.2
  TOP w0.178: RH116.2 28,111.44 28.63,111.44 v2(29.26,110.81) 29.83,110.25 30.59,110.25 31.53,109.31 UH1.U44
  IN4 w0.109: v1(27.47,114.16) 27.47,115.68 30.85,119.07 30.85,120.29 33.2,122.63 33.2,129.86 38.69,135.35 40.71,135.35 42.86,137.5 46.19,137.5 49.03,140.35 49.79,140.35 51.18,141.73 51.18,142.63 51.93,143.38 52.24,143.38 54.44,145.59 58.24,145.59 58.58,145.93 69.77,145.93 71.21,144.49 77.39,144.49 80.37,147.47 80.37,149.84 81.28,150.75 81.28,151.93 82.13,152.77 82.13,154.32 82.55,154.74 v1(82.55,154.82)
  BOTTOM w0.102: v1(82.55,154.82) 82.6,154.87 U19.18
PCH_CRT_HSYNC: length 90.4
  IN4 w0.109: v1(23.43,114.21) 23.45,114.21 23.86,114.62 23.86,115.39 28.5,120.03 28.5,121.57 30.85,123.92 30.85,131.41 33.08,133.64 33.08,135.43 36.42,138.77 37.4,138.77 38.21,139.58 40.85,139.58 42.95,141.68 43.85,141.68 44.8,142.63 45.59,142.63 47.56,144.6 47.56,145.68 50.87,149 51.87,149 52.64,149.77 56.42,149.77 60.02,153.37 69.01,153.37 69.02,153.35 72.7,153.35 74.13,154.78 76.62,154.78 79.26,157.41 82.42,157.41 84.57,155.27 84.57,154.86 v1(84.6,154.82)
  BOTTOM w0.102: U19.13 v1(84.6,154.82) ; RH94.1 23.81,113.37 23.81,113.78 23.43,114.16 v1(23.43,114.21)
PCH_CRT_RED: length 91.9
  TOP w0.102: v1(28.43,114.16) 28.02,113.75 28.02,112.43 RH117.2
  TOP w0.178: 31.91,108.41 32.04,108.54 32.04,109.36 30.82,110.58 30.51,110.58 29.12,111.97 RH117.2
  IN4 w0.109: v1(28.43,114.16) 28.43,114.54 28.56,114.67 28.56,115.9 31.47,118.81 31.47,120.03 33.82,122.38 33.82,129.47 39.07,134.72 40.95,134.72 43.11,136.88 46.76,136.88 48.88,139 49.43,139 51.79,141.36 51.79,142.37 52.19,142.76 52.49,142.76 54.7,144.97 59.11,144.97 59.46,145.31 69.51,145.31 70.95,143.88 77.65,143.88 78.49,144.71 79.33,144.71 80.98,146.37 80.98,149.18 82.74,150.95 82.74,154.16 v1(82.69,154.21)
  BOTTOM w0.102: U19.17 83,154.53 v1(82.69,154.21)
PCH_CRT_VSYNC: length 93.9
  IN4 w0.109: v1(84.59,154.21) 85.01,154.64 85.01,155.41 81,159.42 78.42,159.42 75.26,156.27 74.2,156.27 71.7,153.76 69.19,153.76 69.18,153.78 58.6,153.78 55.01,150.18 52.47,150.18 51.7,149.41 50.7,149.41 46.59,145.31 46.59,145.13 44.52,143.06 43.06,143.06 40.72,140.73 40.55,140.73 39.82,140 37.06,140 32.62,135.56 32.62,133.77 30.44,131.58 30.44,125.76 29.75,125.08 29.75,123.41 28.09,121.74 28.09,120.2 23.43,115.54 v1(23.43,114.79)
  BOTTOM w0.102: v1(23.43,114.79) 23,114.36 23,113.29 RH95.1 ; U19.14 84.2,154.6 v1(84.59,154.21)
PCH_DDPD_AUX: length 102.9
  TOP w0.076: UH1.J44 28.32,107.91 28.46,107.91 28.53,107.99 28.53,108.11 28.31,108.33 28.31,108.59 28.13,108.78 28.13,109.18 v1(27.73,109.58)
  TOP w0.102: v1(34.45,163) 34.25,162.8 33.94,162.8 33.41,162.27 33.41,161.38 C535.1
  IN4 w0.109: v1(27.73,109.58) 27.55,109.39 26.63,109.39 24.44,107.2 24.44,102.5 23.46,101.52 19.4,101.52 18.22,102.71 18.22,109.54 18.63,109.94 18.63,114.49 19.21,115.07 19.21,115.5 19.83,116.12 19.83,117.01 20.99,118.17 20.99,118.7 23.66,121.37 23.66,122.41 24.37,123.12 24.37,126.53 27.62,129.78 27.62,132.79 28.05,133.22 28.05,134.16 28.99,135.1 28.99,136.62 30.08,137.72 30.64,137.72 35.14,142.21 35.14,143.11 37.04,145.02 39.18,145.02 42.4,148.25 42.4,156.88 44.13,158.61 44.13,160.95 41.11,163.97 37.22,163.97 36.05,162.8 34.65,162.8 v1(34.45,163)
PCH_DDPD_AUX#: length 102.8
  TOP w0.076: v1(27.73,108.91) 27.76,108.91 28.15,108.52 28.15,108.29 27.97,108.12 27.97,107.83 28.25,107.55 UH1.J42
  TOP w0.102: v1(34.45,162.37) 34.3,162.52 34.25,162.57 34.04,162.57 33.64,162.17 33.64,161.22 33.71,161.15 C536.1
  IN4 w0.109: v1(27.73,108.91) 27.5,109.15 26.73,109.15 24.67,107.1 24.67,102.4 23.56,101.29 19.31,101.29 17.98,102.61 17.98,109.63 18.39,110.04 18.39,114.59 18.97,115.17 18.97,115.6 19.59,116.22 19.59,117.11 20.75,118.27 20.75,118.8 23.42,121.47 23.42,122.51 24.13,123.22 24.13,126.63 27.38,129.88 27.38,132.89 27.81,133.32 27.81,134.26 28.75,135.2 28.75,136.72 29.98,137.95 30.54,137.95 34.9,142.31 34.9,143.21 36.94,145.26 39.08,145.26 42.17,148.34 42.17,156.98 43.89,158.71 43.89,160.85 41.01,163.73 37.31,163.73 36.15,162.56 34.65,162.56 v1(34.45,162.37)
