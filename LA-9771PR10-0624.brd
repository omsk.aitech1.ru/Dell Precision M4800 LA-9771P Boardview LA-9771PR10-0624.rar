# Allegro board LA-9771PR10-0624.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
RD20  -  [R0402_0OHM]  131.99 31.61 270 bottom
RD26  -  [R0402_0OHM]  163.69 31.66 180 top
RD27  -  [R0402_0OHM]  163.69 30.77 180 top
RD36  -  [R0402_0OHM]  170.72 32.6 90 bottom
RD37  -  [R0402_0OHM]  167.67 33.51 270 bottom
RD41  -  [R_0402]  127.03 83.91 90 top
RD43  -  [R_0402]  129.07 84.82 270 top
RD44  -  [R_0402]  128.05 83.91 90 top
RD45  -  [R_0402]  127.29 48.12 270 top
RD46  -  [R_0402]  128.3 47.2 90 top
RD47  -  [R_0402]  129.32 48.12 270 top
RD48  -  [R_0402]  179.99 87.21 90 bottom
RD49  -  [R_0402]  179.99 90.03 270 bottom
RD50  -  [R_0402]  178.98 89.11 90 bottom
RE1  -  [R_0402]  48.68 93.56 90 bottom
RE2  -  [R_0402]  55.79 93.56 90 bottom
RE5  -  [R_0402]  159.97 113.85 180 bottom
RE11  -  [R_0402]  96.17 113.14 270 bottom
RE12  -  [R_0402]  91.09 113.14 270 bottom
RH3  -  [R_0402]  30.64 122.77 90 bottom
RH4  -  [R_0402]  29.75 123.68 270 bottom
RH5  -  [R_0402]  16.85 94.52 0 bottom
RH6  -  [R_0402]  28.86 122.77 90 bottom
RH7  -  [R_0402]  27.97 122.77 90 bottom
RH8  -  [R_0402]  26.07 123.68 270 bottom
RH9  -  [R_0402]  25.18 122.77 90 bottom
RH10  -  [R_0402]  23.28 122.77 90 bottom
RH11  -  [R_0402]  37.32 118.4 180 top
RH12  -  [R_0402]  37.32 120.18 180 top
RH13  -  [R_0402]  37.32 119.29 180 top
RH14  -  [R_0402]  37.32 121.07 180 top
RH16  -  [R_0402]  20.74 113.75 90 top
RH17  -  [R_0402]  24.29 122.77 90 bottom
RH19  -  [R_0402]  14.69 114.72 0 top
RH20  -  [R_0402]  16.8 113.75 90 top
RH22  -  [R_0402]  17.69 113.75 90 top
RH24  -  [R_0402]  37.32 116.62 180 top
RH25  -  [R_0402]  37.32 117.51 180 top
RH26  -  [R_0402]  20.99 123.68 270 bottom
RH27  -  [R_0402]  19.85 113.75 90 top
RH28  -  [R_0402]  22.01 122.77 90 bottom
RH30  -  [R_0402]  20.04 122.77 90 bottom
RH31  -  [R_0402]  19.08 122.77 90 bottom
RH32  -  [R_0402]  18.83 114.67 270 top
RH34  -  [R_0402]  39.79 84.16 90 bottom
RH35  -  [R_0402]  19.01 100.11 0 top
RH36  -  [R_0402]  44.99 82.28 270 top
RH37  -  [R_0402]  37.88 82.92 270 top
RH39  -  [R_0402]  23.28 90.22 270 bottom
RH40  -  [R_0402]  19.01 97.32 0 top
RH42  -  [R_0402]  16.85 93.51 0 bottom
RH43  -  [R_0402]  19.01 92.62 0 top
RH44  -  [R_0402]  17.76 92.62 180 top
RH45  -  [R_0402]  16.72 100.24 0 top
RH46  -  [R_0603]  31.34 82.21 0 bottom
RH47  -  [R_0402]  31.78 85.08 270 top
RH48  -  [R_0402]  33.82 82 90 top
RH50  -  [R_0402]  34.71 82 90 top
RH52  -  [R_0402]  32.67 82 90 top
RH54  -  [R_0402]  33.82 85.08 270 top
RH55  -  [R_0402]  34.71 85.08 270 top
RH56  -  [R_0402]  32.8 85.08 270 top
RH57  -  [R_0402]  41.11 90.08 0 bottom
RH59  -  [R_0402]  16.72 99.35 0 top
RH60  -  [R_0402]  22.51 99.78 0 bottom
RH61  -  [R_0402]  19.01 98.33 0 top
RH62  -  [R_0402]  37.88 85.08 270 top
RH63  -  [R_0402]  19.01 99.22 0 top
RH65  -  [R_0402]  19.01 101.13 0 top
RH67  -  [R_0402]  19.92 91.73 180 top
RH74  -  [R_0402]  17.69 97.83 180 top
RH75  -  [R_0402]  20.99 82 90 top
RH76  -  [R_0402]  40.93 82.92 270 bottom
RH77  -  [R_0402]  16.72 100.75 0 bottom
RH78  -  [R_0402]  23.78 82 90 top
RH79  -  [R_0402]  23.67 85.08 270 bottom
RH80  -  [R_0402]  19.59 89.75 270 bottom
RH81  -  [R_0402]  19.01 90.84 0 top
RH83  -  [R_0402]  16.72 99.86 0 bottom
RH84  -  [R_0402]  28.86 84.16 90 bottom
RH86  -  [R_0402]  16.72 98.97 0 bottom
RH87  -  [R_0402]  13.88 129.88 90 top
RH90  -  [R_0402]  41.82 84.16 90 bottom
RH91  -  [R_0402]  21.26 84.21 0 top
RH94  -  [R_0402]  24.29 112.89 270 bottom
RH95  -  [R_0402]  23.4 112.89 270 bottom
RH97  -  [R_0402]  31.66 107.81 270 bottom
RH99  -  [R_0402]  40.04 107.78 90 bottom
RH100  -  [R_0402]  43.67 95.67 180 bottom
RH101  -  [R0402_0OHM]  21.9 82 90 top
RH106  -  [R0402_0OHM]  25.56 83.3 270 bottom
RH107  -  [R_0402]  70.39 17.77 270 bottom
RH108  -  [R_0402]  71.28 17.77 270 bottom
RH112  -  [R_0402]  19.01 92.62 0 bottom
RH113  -  [R_0402]  15.07 94.4 0 top
RH115  -  [R_0402]  26.45 112.89 270 top
RH116  -  [R_0402]  27.47 112.89 270 top
RH117  -  [R_0402]  28.48 112.89 270 top
RH118  -  [R_0402]  25.23 104.68 0 bottom
RH119  -  [R_0402]  16.85 93.56 0 top
RH120  -  [R_0402]  36.74 82.92 270 top
RH123  -  [R_0402]  31.78 82.92 270 top
RH124  -  [R_0402]  35.85 85.08 270 top
RH125  -  [R_0402]  29.5 82 90 top
RH128  -  [R_0402]  51.93 94.52 180 top
RH129  -  [R_0402]  24.67 82.92 270 top
RH130  -  [R_0402]  27.47 82 90 top
RH131  -  [R_0402]  22.77 84.16 90 bottom
RH132  -  [R_0402]  15.38 95.36 90 top
RH140  -  [R_0402]  36.74 85.08 270 top
RH142  -  [R_0402]  22.77 82.92 270 bottom
RH144  -  [R_0402]  30.77 85.08 270 top
RH145  -  [R_0402]  29.5 85.08 270 top
RH146  -  [R_0402]  23.4 111.97 90 top
RH147  -  [R_0402]  24.39 103.54 180 bottom
RH148  -  [R_0402]  24.39 104.43 180 bottom
RH149  -  [R_0402]  46.95 90.08 0 top
RH150  -  [R_0402]  46.95 89.06 0 top
RH153  -  [R_0402]  38.69 112.05 0 top
RH155  -  [R_0402]  19.39 110.4 0 top
RH157  -  [R_0402]  22.44 105.32 0 bottom
RH158  -  [R_0402]  22.72 109 180 bottom
RH159  -  [R_0402]  21.8 109.89 0 bottom
RH160  -  [R_0402]  21.62 111.97 90 top
RH161  -  [R_0402]  22.44 106.21 0 bottom
RH162  -  [R_0402]  22.72 108.11 180 bottom
RH164  -  [R_0402]  20.37 108.94 180 top
RH165  -  [R_0402]  38.26 108.82 270 bottom
RH166  -  [R_0402]  25.56 84.16 90 bottom
RH168  -  [R_0402]  38.9 84.16 90 bottom
RH170  -  [R_0402]  24.67 84.16 90 bottom
RH171  -  [R_0402]  21.88 84.16 90 bottom
RH174  -  [R_0402]  28.48 82 90 bottom
RH175  -  [R_0402]  27.34 82 90 bottom
RH176  -  [R_0402]  46.82 109.51 0 top
RH177  -  [R0402_0OHM]  54.09 80.43 180 top
RH178  -  [R0402_0OHM]  51.98 81.71 180 top
RH179  -  [R0402_0OHM]  51.09 82.57 90 top
RH180  -  [R_0402]  47.79 82.66 270 bottom
RH181  -  [R0402_0OHM]  51.09 84.41 90 top
RH182  -  [R0402_0OHM]  51.09 86.19 90 top
RH183  -  [R0402_0OHM]  51.09 87.97 90 top
RH184  -  [R0402_0OHM]  51.09 89.75 90 top
RH185  -  [R0402_0OHM]  52.87 91.17 270 bottom
RH186  -  [R_0402]  54.64 82.66 270 bottom
RH187  -  [R_0402]  28.69 99.1 180 bottom
RH192  -  [R_0402]  49.26 101.26 180 bottom
RH195  -  [R0402_0OHM]  43.14 87.62 180 bottom
RH200  -  [R_0402]  39.79 84.16 90 top
RH202  -  [R_0402]  40.93 85.08 270 bottom
RH205  -  [R_0402]  41.82 85.08 270 top
RH206  -  [R_0402]  47.86 87.03 180 top
RH208  -  [R_0402]  45.75 85.08 270 bottom
RH209  -  [R_0402]  45.84 87.63 180 bottom
RH210  -  [R_0402]  30.77 82 90 top
RH211  -  [R_0402]  34.71 82.92 270 bottom
RH212  -  [R_0402]  32.8 84.16 90 bottom
RH213  -  [R_0402]  33.69 84.16 90 bottom
RH216  -  [R_0402]  26.58 85.08 270 bottom
RH217  -  [R_0402]  23.35 95.79 180 bottom
RH219  -  [R0402_0OHM]  47.86 88.17 180 top
RH222  -  [R_0402]  35.85 85.08 270 bottom
RH223  -  [R_0402]  36.86 85.08 270 bottom
RH225  -  [R_0402]  38.77 82.92 270 top
RH226  -  [R_0402]  40.93 82.92 270 top
RH228  -  [R_0402]  43.85 85.08 270 top
RH229  -  [R_0402]  45.44 85.24 270 top
RH230  -  [R_0402]  43.85 82.28 270 top
RH232  -  [R_0402]  30.82 95.07 0 bottom
RH234  -  [R_0402]  33.18 98.21 270 bottom
RH236  -  [R_0603]  34.39 110.53 180 bottom
RH238  -  [R0603_0OHM]  20.33 97.5 270 bottom
RH239  -  [R_0402]  32.11 113.07 180 bottom
RH240  -  [R0603_0OHM]  21.18 103.67 0 bottom
RH241  -  [R0603_0OHM]  46.58 114.46 180 top
RH242  -  [R0805_0OHM]  15.79 103.1 0 bottom
RH244  -  [R0805_0OHM]  36.06 115.61 180 bottom
RH245  -  [R0805_0OHM]  15.88 106.91 0 bottom
RH246  -  [R_0402]  29.75 84.16 90 bottom
RH247  -  [R_0402]  28.48 84.16 90 top
RH248  -  [R_0402]  27.09 122.77 90 bottom
RH249  -  [R_0402]  24.67 84.16 90 top
RH254  -  [R_0402]  30.77 85.08 270 bottom
RH255  -  [R_0402]  22.51 112.89 270 bottom
RH256  -  [R_0402]  21.37 112.89 270 bottom
RH328  -  [R_0402]  19.47 94.91 0 top
RP1  -  [RP_0804_8P4R]  226.29 84.22 180 bottom
RP2  -  [RP_0804_8P4R]  223.11 70.13 180 bottom
RP3  -  [RP_0804_8P4R]  208.75 78.66 0 bottom
RP4  -  [RP_0804_8P4R]  227.76 69.95 270 bottom
RP5  -  [RP_0804_8P4R]  102.64 166.22 270 top
RP6  -  [RP_0804_8P4R]  92.42 156.49 0 top
RP7  -  [RP_0804_8P4R]  113.32 149.25 180 bottom
RP8  -  [RP_0804_8P4R]  218.59 91.03 90 bottom
RP9  -  [RP_0804_8P4R]  171.8 118.13 0 top
RPH1  -  [RP_0804_8P4R]  13.56 101.62 180 bottom
RPH3  -  [RP_0804_8P4R]  41.83 99.16 270 bottom
RPH5  -  [RP_0804_8P4R]  21.56 87.65 180 bottom
RPH7  -  [RP_0804_8P4R]  27.33 85.32 270 top
RPH8  -  [RP_0804_8P4R]  12.4 94.56 0 bottom
RPH9  -  [RP_0804_8P4R]  12.41 97.33 0 bottom
RPH10  -  [RP_0804_8P4R]  44.47 84.3 90 bottom
T1  -  [TPC12]  68.51 79.4 180 bottom
T2  -  [TPC12]  71.56 74.08 180 bottom
T3  -  [TPC12]  78.44 81.06 0 top
T4  -  [TPC12]  70.23 74.18 180 bottom
T5  -  [TPC12]  79.49 79.64 0 top
T6  -  [TPC12]  71.15 78.38 180 bottom
T57  -  [TPC12]  41.94 91.17 180 bottom
T58  -  [TPC12]  43.37 90.7 180 bottom
T59  -  [TPC12]  22.26 100.37 90 top
T60  -  [TPC12]  100.62 62.27 180 bottom
T61  -  [TPC12]  70.84 166.37 0 top
T64  -  [TPC12]  99.68 67.3 180 bottom
T65  -  [TPC12]  40.48 96.8 180 bottom
T66  -  [TPC12]  41.31 111.86 0 top
T67  -  [TPC12]  38.74 95.71 180 bottom
T68  -  [TPC12]  32.17 91.51 180 bottom
T69  -  [TPC12]  80.68 54.27 180 bottom
T70  -  [TPC12]  109.62 80.88 0 top
T71  -  [TPC12]  107.5 80.99 0 top
T72  -  [TPC12]  97.57 63.28 180 bottom
T73  -  [TPC12]  73.57 40.3 180 bottom
T74  -  [TPC12]  71.42 40.03 180 bottom
T75  -  [TPC12]  78.3 57.97 180 bottom
T76  -  [TPC12]  79.62 58.28 180 bottom
T77  -  [TPC12]  80.68 50.33 180 bottom
T78  -  [TPC12]  84.62 41.31 180 bottom
T79  -  [TPC12]  76.73 70.23 180 bottom
T80  -  [TPC12]  78.52 70.27 180 bottom
T81  -  [TPC12]  72.55 41.31 180 bottom
T82  -  [TPC12]  70.42 42.38 180 bottom
T83  -  [TPC12]  75.61 58.18 180 bottom
T84  -  [TPC12]  76.96 58.27 180 bottom
T85  -  [TPC12]  82.58 70.27 180 bottom
T86  -  [TPC12]  83.59 42.21 180 bottom
T87  -  [TPC12]  83.17 43.47 180 bottom
T88  -  [TPC12]  84.62 43.22 180 bottom
T89  -  [TPC12]  82.38 72.29 180 bottom
T90  -  [TPC12]  101.63 46.26 180 bottom
T91  -  [TPC12]  73.59 75.26 180 bottom
T92  -  [TPC12]  80.59 72.27 180 bottom
T93  -  [TPC12]  102.65 45.25 180 bottom
T94  -  [TPC12]  101.63 49.31 180 bottom
T95  -  [TPC12]  105.57 71.28 180 bottom
T96  -  [TPC12]  89.07 44.37 180 bottom
T97  -  [TPC12]  97.57 53.25 180 bottom
T98  -  [TPC12]  97.57 56.3 180 bottom
T99  -  [TPC12]  107.12 75.4 180 bottom
T100  -  [TPC12]  106.84 39.15 180 bottom
T101  -  [TPC12]  87.54 44.23 180 bottom
T102  -  [TPC12]  86.01 44.41 180 bottom
T103  -  [TPC12]  31.78 84.62 180 bottom
T104  -  [TPC12]  21.66 86.18 0 top
T105  -  [TPC12]  55.93 154.82 0 top
T110  -  [TPC12]  79.59 49.25 180 bottom
T112  -  [TPC12]  79.52 55.56 180 bottom
T113  -  [TPC12]  80.55 57.31 180 bottom
T114  -  [TPC12]  73.64 70.15 180 bottom
T115  -  [TPC12]  81.57 52.23 180 bottom
T118  -  [TPC12]  19.68 89.55 90 top
T119  -  [TPC12]  224.44 81.06 180 bottom
T120  -  [TPC12]  46.76 105.87 0 top
T121  -  [TPC12]  46.78 107.21 0 top
T122  -  [TPC12]  30.41 103.97 180 bottom
T123  -  [TPC12]  28.86 103.38 180 bottom
T124  -  [TPC12]  46.82 102.65 0 top
T125  -  [TPC12]  41.33 102.35 180 bottom
T126  -  [TPC12]  46.05 87.89 0 top
T127  -  [TPC12]  218 88.57 180 bottom
T129  -  [TPC12]  43.67 88.57 180 bottom
T130  -  [TPC12]  46.59 111.86 0 top
T131  -  [TPC12]  47.65 110.54 0 top
T132  -  [TPC12]  47.94 111.82 0 top
T133  -  [TPC12]  46.33 110.41 0 top
T134  -  [TPC12]  36.9 107.81 180 bottom
T135  -  [TPC12]  222.28 73.95 180 bottom
T136  -  [TPC12]  211.3 79.98 180 bottom
T137  -  [TPC12]  106.33 154.04 0 top
T138  -  [TPC12]  102.4 153.2 0 top
T139  -  [TPC12]  221.5 88.66 180 bottom
T140  -  [TPC12]  53.77 16.77 0 top
T141  -  [TPC12]  34.2 92.75 180 bottom
T142  -  [TPC12]  120.75 144.65 180 bottom
T143  -  [TPC12]  120.53 146.71 180 bottom
T144  -  [TPC12]  33.19 95.02 180 bottom
T145  -  [TPC12]  25.94 88.68 270 bottom
T146  -  [TPC12]  32.38 89.88 180 bottom
T147  -  [TPC12]  35.25 105.29 180 bottom
T148  -  [TPC12]  35.25 106.69 180 bottom
T149  -  [TPC12]  46.54 108.56 0 top
T150  -  [TPC12]  47.89 108.11 0 top
T151  -  [TPC12]  79.6 71.19 180 bottom
T152  -  [TPC12]  80.55 69.25 180 bottom
T153  -  [TPC12]  90.59 44.23 180 bottom
T154  -  [TPC12]  94.65 70.27 180 bottom
T155  -  [TPC12]  227.91 83.83 180 bottom
T156  -  [TAIMA_IH-115-F_24P]  156.82 145.34 0 top
T157  -  [TPC12]  72.55 80.05 0 top
T158  -  [TPC12]  71.83 78.98 0 top
T159  -  [TPC12]  91.6 70.27 180 bottom
T160  -  [TPC12]  74.28 58.23 180 bottom
T162  -  [TPC12]  75.6 74.33 180 bottom
T163  -  [TPC12]  81.54 71.26 180 bottom
T164  -  [TPC12]  80.68 48.3 180 bottom
T166  -  [TPC12]  26.21 99.55 180 bottom
T167  -  [TPC12]  27.67 100.3 180 bottom
T171  -  [TPC12]  119.44 144.73 180 bottom
T172  -  [TPC12]  119.45 146.01 180 bottom
U2  -  [SLG55594AVTR_TDFN8_2X2]  255.16 108.11 0 bottom
U3  -  [TC7SH125FU_SSOP5]  49.42 152.62 0 bottom
U4  -  [RT9818A-44GU3_SC70-3]  146.44 138.68 270 top
U5  -  [AP2330W-7_SC59-3]  24.8 166.08 180 bottom
U6  -  [AP2330W-7_SC59-3]  80.93 162.67 180 top
U7  -  [TC7SH08FU_SSOP5]  143.69 140.53 0 top
U8  -  [AP2337SA-7_SOT23-3]  261.03 149.48 180 bottom
U9  -  [PS8339BQFN56GTR2-A0_QFN56_7X7]  24.86 160.61 180 top
U10  -  [TC7SH08FU_SSOP5]  166.72 138.83 90 top
U11  -  [TS3DV20812RHHR_VQFN36_6X6]  60.04 149.32 90 bottom
U13  -  [TS3DV20812RHHR_VQFN36_6X6]  60.99 138.34 90 bottom
U14  -  [SN74AHC1G08DCKR_SC70-5]  60.98 102.28 0 bottom
U15  -  [TC7SH08FU_SSOP5]  126.08 146.61 270 top
U16  -  [74AHC1G09GW_TSSOP5]  82.32 103.93 0 bottom
U17  -  [74AHC1G09GW_TSSOP5]  122.07 102.4 0 bottom
U19  -  [MAX14885EETLLFT_TQFN40_5X5]  86.08 159.95 270 bottom
U20  -  [PI3C3125LEX_TSSOP14]  79.26 112.2 90 top
U22  -  [PS8330BQFN48GTR-A0_QFN48_7X7]  238.08 89.36 0 bottom
U23  -  [RTD2136S-CG_QFN48_6X6]  78.27 149.39 270 bottom
U25  -  [SN74AHC1G08DCKR_SC70-5]  65.3 102.28 0 bottom
U27  -  [SN74AHC1G08DCKR_SC70-5]  56.03 102.4 0 bottom
U29  -  [EMC4021-1-EZK-TR_QFN32_5X5]  170.82 135.73 180 top
U31  -  [WGI217LM-QPN9-A2_QFN48_6X6]  120.14 154.01 0 bottom
U32  -  [PI3L720ZHEX_TQFN42_9X3P5]  124.43 140.32 0 bottom
U34  -  [TPS22966DPUR_SON14_2X3]  56.04 111.04 270 bottom
U35  -  [TPS22966DPUR_SON14_2X3]  119.81 107.47 90 bottom
U37  -  [TPS22965DSGR_SON8_2X2]  51.94 74.69 180 bottom
U38  -  [TPS22965DSGR_SON8_2X2]  84.34 135.55 180 bottom
U39  -  [AT97SC3204-X2A14-AB_TSSOP28]  167.76 118.55 270 bottom
U43  -  [TPS22965DSGR_SON8_2X2]  266.34 56.97 180 bottom
U45  -  [TPS2560DRCR-PG1P1_SON10_3X3]  257.83 98.89 180 bottom
U46  -  [ECE5048-LZY_DQFN132_11X11]  221.67 75.82 180 bottom
U48  -  [TPS2560DRCR-PG1P1_SON10_3X3]  67.07 163.03 0 top
U50  -  [TC7SH08FU_SSOP5]  92.89 146.03 180 bottom
U51  -  [MEC5075-LZY_DQFN132_11X11]  109.2 160.27 270 bottom
U52  -  [W25Q64FVSSIQ_SO8]  51.34 84.49 180 bottom
U53  -  [W25Q32FVSSIQ_SO8]  58.2 84.49 180 bottom
U54  -  [TC7SH08FU_SSOP5]  38.15 138.4 90 bottom
U56  -  [TPS22965DSGR_SON8_2X2]  112.52 144.92 90 bottom
U57  -  [TPS22966DPUR_SON14_2X3]  43.08 31.17 0 top
U58  -  [74AHC1G08GW_SOT353-5]  16.97 153.96 0 bottom
U62  -  [APL3512ABI-TRG_SOT23-5]  47.23 152.37 270 bottom
U63  -  [TPS22966DPUR_SON14_2X3]  125.9 164.04 90 top
U88  -  [LNG3DMTR_LGA16_3X3]  170.2 39.92 180 bottom
U629  -  [PS8331BQFN60GTR-A0_QFN60_5X9]  38.72 149.4 90 top
U637  -  [ASM1467_QFN20_4X4]  215.37 64.06 90 bottom
U638  -  [PS8723BTQFN32GTR-A0_TQFN32_3X6]  229.05 87.92 0 bottom
UC2  -  [74AHC1G09GW_TSSOP5]  111.53 81.32 0 bottom
UH1  -  [DH82LPMS-QC4C-A1_FCBGA_695P]  24.63 89.78 90 top
UH2  -  [TC7SH08FU_SSOP5]  10.56 129.52 0 top
UH3  -  [TC7SH08FU_SSOP5]  12.47 108.43 0 bottom
Y3  -  [Y_X3G025000DI1H-H_4P]  129.15 158.24 270 bottom
Y6  -  [Y_Q13FC135000040_2P]  108.13 167.04 0 bottom
YH1  -  [Y_Q13FC135000040_2P]  21.5 91.65 270 bottom
YH2  -  [Y_Q22FA2380049900_4P]  41.01 116.22 180 top

## Library data of the parts
C1 C3 C328 C332 = C_0603: room: MXM
C2 = C_0805: room: MXM
C4 C7 C8 C90 = C_0402: room: MXM
C14 C15 C20 C22 C23 C1181 = C_0402: room: CRT
C16 C95 C547 C624 C626 C634 C636-C639 C773 CC138 CD45 CH39 CH42 CH58 PC4 PC5 PC11 PC16 PC105-PC107 PC204 PC205 PC209 PC211 PC214-PC217 PC219 PC220 PC302 PC303 PC307 PC309 PC402 PC406 PC407 PC509 PC510 PC515 PC516 PC520 PC522 PC525-PC528 PC539 PC541-PC544 PC546 PC547 PC702-PC705 PC717 PC727-PC733 PC735 PC736 PC744 PC746 PC783 PC1002 PC1003 PC1009 PC1080 PC1081 = C_0402
C45 C48 C550-C553 CE3 = C_0402: room: TPM
C46 C86 C402 C405 C410 C437 C1332-C1340 = C_0402: room: HDMI_DEMUX
C47 = C_0805: room: HDMI_DEMUX
C52 C53 C56 = C_0402: room: USH
C87 C88 C313 C496 C497 C1341 = C_0402: room: DP
C97 C494 C495 C499 C504 = C_0402: room: DP_MUX
C100 C101 C103-C105 C118 = C_0402: room: EDP_LVDS; signal model: C_0402NEW
C106 C109 C113 C115 = C_0603: room: EDP_LVDS
C107 C108 C110-C112 C114 C116 C117 = C_0402: room: EDP_LVDS
C119 = C_0603: room: SIM
C243 C248 C298 C726 C1323-C1327 = C_0402: room: LVDS
C249 C296 = C_0603: room: LVDS
C271-C273 C278 C287 C288 C291 C315 C318 C319 C327 C335 C339 C340 C364 C370 C1180 = C_0402: room: THERMAL
C279-C286 C397 C398 = C_0402: room: DP; signal model: C_0402NEW
C289 C290 = C_0402: room: RSMRST
C295 C302-C304 C306-C309 = C_0402: room: DP; signal model: C_0402NEW_C_0402NEW
C297 = C_1206: room: LVDS
C299 C301 = C_0402: room: CAM
C300 = C_0805: room: CAM
C305 C312 C314 C316 C317 C320-C322 = C_0402: room: EDP; signal model: C_0402NEW_C_0402NEW
C323 C324 = C_D2: room: USB3.0
C329 C330 = C_0805: room: THERMAL
C356 = C_0805: room: +5V_MXM SOURCE
C357 = C_0805: room: +5V_RUN SOURCE
C358 = C_0805: room: +3.3V_RUN SOURCE
C359 C387 C388 C1174 = C_0402: room: DP_SW
C360 = C_0805: room: +3.3V_M_SOURCE
C361 = C_0805: room: +3.3V_SUS SOURCE
C366-C369 C424-C427 C431 C438-C444 C697-C700 = C_0402: room: DOCKING; signal model: C_0402NEW
C383-C386 = C_0402: room: HDD; signal model: C_0402NEW
C391 = C_0402: room: FFS
C392 = C_0603: room: FFS
C395 C403 C404 C406 = C_0402: room: HDD
C428 C429 = C_0402: room: ODD
C430 C432-C434 = C_0402: room: ODD; signal model: C_0402NEW
C435 = C_0402: room: +3V_MXM SOURCE
C436 = C_0402: room: +5V_MXM SOURCE
C449 = C_0805: room: +3V_MXM SOURCE
C450 C453 C670 C715 = C_0402: room: USB3.0
C452 C454 C456 C457 C465 C487-C493 = C_0402: room: USB3.0; signal model: C_0402NEW
C458-C461 = C_0402: room: LAN; signal model: C_0402NEW
C462 C464 = C_0603: room: LAN
C463 C466-C474 C478 = C_0402: room: LAN
C479-C481 C484 C486 = C_0603: room: LOM
C482 = C_0805: room: DP
C483 C1167 = C_0402: room: LOM
C485 = C_1808: room: LOM
C500 C501 = C_0402: signal model: C_0402NEW
C505-C512 C536 = C_0402: room: HDMI_DEMUX; signal model: C_0402NEW
C513 C514 C533 C534 C537-C540 = C_0402: room: MSATA; signal model: C_0402NEW
C515-C532 C535 = C_0402: room: DP_MUX; signal model: C_0402NEW
C541 = C_0402: room: +5V_RUN SOURCE
C542 = C_0402: room: +3.3V_RUN SOURCE
C543 C555 = C_0402: room: +3.3V_M_SOURCE
C544 = C_0402: room: +3.3V_SUS SOURCE
C545 = C_0402: room: WLAN_PWR
C546 = C_0402: room: WWAN_PWR
C548 = C_0402: room: +3.3V_ALW_PCH SOURCE
C549 = C_0402: room: +5VMOD SOURCE
C554 = C_0402: room: +3.3V_LAN PWR
C593 C594 C610-C612 C614 = C_0402: room: WWAN
C595 C604-C607 = C_0402: room: WLAN
C596 C598 = C_0402: room: WLAN; signal model: C_0402NEW
C608 = C_0603: room: WLAN
C613 = C_0805: room: WWAN
C615 CC78 CC79 PC14 PC30 PC104 PC109 PC110 PC202 PC203 PC207 PC208 PC304 PC305 PC400 PC403 PC404 PC502-PC504 PC512-PC514 PC533-PC535 PC707 PC708 PC715 PC718 PC719 PC900-PC904 PC909-PC914 PC917-PC926 PC935-PC943 PC1001 = C_0805
C616 C617 C628-C631 = C_0402: room: SIM
C633 C765 C772 CC137 CD1 CD19 CD22 CD26 CD41 CD44 CD63 CD66 CD71 CD85 CD88 CH26 CH31-CH33 CH41 PC2 PC7-PC9 PC15 PC31 PC111 PC112 PC114 PC116-PC120 PC206 PC210 PC212 PC213 PC306 PC308 PC500 PC501 PC507 PC508 PC511 PC519 PC521 PC523 PC532 PC538 PC540 PC545 PC700 PC701 PC706 PC734 PC745 PC786 PC791 PC792 PC1004-PC1008 PC1099 = C_0603
C667 = C_D2: room: ESATA
C668 C675 = C_0402: room: ESATA
C669 = C_0805: room: USB3.0
C671-C674 = C_0402: room: ESATA; signal model: C_0402NEW
C676 = C_0805: room: ESATA
C695 C696 C704 CE8 CE9 = C_0402: room: DOCKING
C702 C703 = C_0603: room: DOCKING
C708-C710 C712 C713 C716-C719 = C_0402: room: SIO
C714 = C_0603: room: SIO
C721-C725 C763 = C_0402: room: IO
C734-C737 C739-C744 C747 C757 C777 C780 C781 C1343 C1345-C1353 C1355 = C_0402: room: KBC
C746 C1216 CE1 = C_0402: room: FLASH ROM
C756 C758 = C_0402: room: KB
C760 C769 = C_0603: room: +3.3V_ALW_PCH SOURCE
C761 = C_0603: room: WLAN_PWR
C764 = C_0603: room: WWAN_PWR
C766 = C_0603: room: HDMI_DEMUX
C767 = C_0603: room: +5VMOD SOURCE
C770 = C_0603: room: +3.3V_LAN PWR
C774 = C_0402: room: MXM_PWR_SRC SOURCE
C776 = C_1206: room: MXM_PWR_SRC SOURCE
C779 C782 = C_0603: room: KBC
C783 = C_0603: room: DP_MUX
C793 C794 = C_0603: room: USB3.0
C1145 C1149 = C_0402: room: LVDS SW
C1176 C1179 = C_D2E: room: WWAN
C1177 = C_0805: room: LAN
C1178 = C_0805: room: +3.3V_LAN SOURCE
C1182 = C_0603: room: CRT
C1312 C1313 = C_0402: room: MSATA
CC1-CC32 CC44-CC64 CC67-CC77 = C_0402: room: CPU; signal model: C_0402NEW
CC33-CC43 CC161-CC166 CC168-CC171 = C_0805: room: CPU
CC65 = C_0402: room: XDP1
CC66 = C_0603: room: XDP1
CC167 = C_X: room: CPU
CC172 = C_X
CD2-CD6 CD15-CD18 CD20 CD21 CD89 CD90 = C_0402: room: DIMM1
CD7-CD13 = C_0603: room: DIMM1
CD14 = C_APXK2R5ARA331MF451: room: DIMM1
CD23-CD25 CD27 CD28 CD37-CD40 CD42 CD43 = C_0402: room: DIMM2
CD29-CD35 = C_0603: room: DIMM2
CD36 = C_APXK2R5ARA331MF451: room: DIMM2
CD46-CD50 CD59-CD62 CD64 CD65 CD91 = C_0402: room: DIMM3
CD51-CD57 = C_0603: room: DIMM3
CD58 CD80 = C_APXK2R5ARA331MF451: room: DIMM3
CD67-CD70 CD72 CD81-CD84 CD86 CD87 = C_0402: room: DIMM4
CD73-CD79 = C_0603: room: DIMM4
CE2 = C_0402: room: PCHFLASH ROM
CH2 = C_0402: room: XDP2
CH4-CH7 CH9 CH13-CH19 CH22-CH25 CH27 CH29 CH30 CH34-CH37 CH40 CH43-CH51 CH53-CH57 CH59-CH62 CH64-CH80 = C_0402: room: PCH
CH20 CH21 CH38 CH52 CH63 = C_0603: room: PCH
CH28 = C_0805: room: PCH
CH93 = C_B2
CMOS1 ME1 = SHORTPADS: User Part Number: PART#; room: PCH
D6 = BAT54CW_SOT323-3: room: LVDS
D7 D8 D18 = DB2J31400L_SOD323-2: room: MXM
D14 D16 = TVWDF1004AD0_DFN9: room: USB3.0
D15 D17 = L30ESDL5V0C3-2_SOT23-3: room: USB3.0
D29-D31 = RB751S40T1G_SOD523-2: room: WLAN
D32 = RB751S40T1G_SOD523-2: room: DOCKING
D33 = L30ESD24VC3-2_SOT23-3: room: DOCKING
D53 D64 D66-D69 D71 = DB2J31400L_SOD323-2: room: LVDS
D59 D62 = RB751S40T1G_SOD523-2: room: LED
D73 = L30ESDL5V0C3-2_SOT23-3: room: ESATA
D88 = L30ESDL5V0C3-2_SOT23-3: room: DP_SW
D90 = RB751S40T1G_SOD523-2: room: THERMAL
D91 = BAT1000-7-F_SOT23-3
F3 = F_1206L150THWR: room: DP
FD1-FD4 = FIDUCIAL_C40M80: room: FD
H1 = H_3P2X6P2N: room: H
H2 H9-H11 H17 H19 H25 = H_2P8: room: H
H3 = H_3P3: room: H
H4 H20 = H_2P3: room: H
H5 H7 H8 H13-H16 = H_3P8: room: H
H12 = H_2P1X4P1N
H18 = H_3P2: room: H
H21-H24 = H_4P1: room: H
JAPS1 = ACES_88512-01601-071_16P: room: TPM
JCPU1 = FOX_PZ94726-362R-41H_947P-T: room: CPU
JCRT1 = SUYIN_070449HR015M221ZR_15P: room: CRT
JDEG2 = ACES_87152-10071_10P: room: KBC
JDIMM1 = FOX_AS0A621-N2R6-7H_204P: room: DIMM1
JDIMM2 = FOX_AS0A621-N2S6-7H_204P: room: DIMM2
JDIMM3 = TYCO_2-2013311-1_204P: room: DIMM3
JDIMM4 = FOX_AS0A621-N2R6-7H_204P: room: DIMM4
JDOCK1 = JAE_WD2F144WB5R400_144P: room: DOCKING
JDP1 = FOX_3V11211-NBYD7-7H_20P: room: DP
JEPWR1 = ACES_50228-0067N-001_6P
JESA1 = TAIWI_EU093-117CRL-TW_11P: room: ESATA
JFAN1 JFAN2 = ACES_50271-0040N-001_4P: room: THERMAL
JHDMI1 = CONCR_099AAAC19BBLCNF_19P: room: HDMI_DEMUX
JIO1 = FOX_QTSA1401-7011-9H_140P-T: room: ETY-ROOM
JKB1 = E-T_6900K-G10N-40R_10P: room: KB
JLOM1 = SANTA_130454-H_13P: room: LOM
JLVDS1 = ACES_50398-04071-001_40P: room: LVDS
JMINI2 = LOTES_AAA-PCI-092-P01-A_52P: room: WWAN
JMINI3 = LOTES_AAA-PCI-092-P01-A_52P: room: PP
JMINI4 = LOTES_AAA-PCI-092-P01-A_52P: room: WLAN
JMXM1 = JAE_MM70-314-310B1-1-R300_310P: room: MXM
JODD1 = OCTEK_SLS-13ADAB_13P: room: ODD
JPB1 = ACES_50228-0067N-001_6P: room: PWR_BTN
JRTC1 = ACES_50271-0020N-001_2P
JSATA1 = OCTEK_SAT-22PDAB_22P: room: HDD
JSIM1 = T-SOL_159-1000302602_10P-T: room: SIM
JSPI1 = TYCO_2-2041070-0_20P-T: room: FLASH ROM
JTAG1 = SHORTPADS: User Part Number: PART#; room: KBC
JUSB1 JUSB2 = LOTES_AUSB0041-P002A_9P: room: USB3.0
JUSH1 = E-T_6712K-Y20N-07L_20P: room: USH
JWL1 = ACES_50228-0034N-001_3P: room: ETY-ROOM
JXDP1 = SAMTE_BSH-030-01-L-D-A_60P: room: XDP1
JXDP2 = SAMTE_BSH-030-01-L-D-A_60P: room: XDP2
L1-L3 = MURAT_BLM15BB470SN1D_2P: room: CRT; signal model: MURAT_BLM18BB470SN1D_2P
L4 L5 = MURAT_BLM15AG121SN1D_L0402_2P: room: CRT; signal model: MURAT_BLM18AG121SN1D_L0603_2P
L10 = MURAT_DLW21HN900SQ2L_4P: room: CAM; signal model: MURAT_DLW21SN121SQ2L_4P
L19 L23-L25 = MURAT_DLW21SN900HQ2L-0805_4P: room: HDMI_DEMUX; signal model: MURAT_DLW21SN900HQ2L_0805_4P
L29 = TAIYO_CBC2012T4R7M_2P: room: LAN
L39 L41 = MURAT_DLW21HN900SQ2L_4P: room: USB3.0; signal model: MURAT_DLW21SN900SQ2L_0805_4P
L40 L42-L44 = MURAT_DLW21SN900HQ2L-0805_4P: room: USB3.0; signal model: MURAT_DLW21SN900HQ2L_0805_4P
L51 = MURAT_DLW21HN900SQ2L_4P: room: ESATA; signal model: MURAT_DLW21SN900SQ2L_0805_4P
L60 L61 = KC_FBMA-L11-201209-221LMA30_2P: room: EDP_LVDS
L62 = CYNTE_PG031B-4R7MS_2P: room: EDP_LVDS
L63-L70 = DELTA_0603CS-120EJTS_2P
LH1 = MURAT_BLM18PG181SN1D_2P: room: PCH
LH2 = MURAT_LQM18FN4R7M00D_2P
PBATT1 = SUYIN_200045GR009M28QZR_9P
PC1 PC529-PC531 = C_EEEFK1E101YP
PC101 PC102 = C_APXK6R3ARA221MF451
PC201 PC301 = C_APXK2R5ARA331MF451
PC905 PC907 PC908 PC916 = C_D2
PD1 = RB715FGT106_UMD3
PD2 PD3 = TVNST52302AB0_SOT523-3
PD5 PD703 PD1099 PD1100 = SDMK0340L-7-F_SOD323-2
PD8 = D_0603
PD700 = SBR3A40SA-13_SMA2
PD701 PD1010 = BAT54CW_SOT323-3
PD1001 PD1002 = PDS5100H-13_POWERDI5-3
PH500 PH501 PR1 PR2 PR7-PR13 PR15-PR18 PR20-PR23 PR100-PR102 PR104-PR106 PR112 PR119 PR201 PR204-PR209 PR211 PR213 PR216-PR225 PR300 PR302 PR303 PR305-PR307 PR400 PR402-PR405 PR500 PR503 PR504 PR507 PR509 PR512 PR514 PR516-PR519 PR521 PR523 PR525 PR528 PR529 PR531 PR533 PR536 PR537 PR541 PR543-PR547 PR550 PR551 PR555-PR558 PR704 PR706-PR709 PR712 PR713 PR715-PR717 PR732 PR734-PR738 PR740 PR741 PR743-PR749 PR757 PR758 PR760 PR762 PR764 PR771 PR772 PR1001 PR1003 PR1013 PR1018 PR1024 PR1026 PR1028 PR1030-PR1032 PR1071-PR1073 PR1081 PR1083 PR1097-PR1100 R15 R19 R29 R36 R39 R161 R162 R227 R230-R236 R431 R432 R504 R515 R551 R564 R695 R696 R733 R761 R784 R808 R815 R909 R931 R933 R944 R1000 R1611 R2189 RC72 RC73 RD5 RH79 RH91 RH131 RH132 RH147-RH150 RH209 RH234 RH239 = R_0402
PJP1 PJP2 PJP5-PJP9 PJP300-PJP302 PJP400 PJP401 = JUMP_43X79
PJP3 PJP4 PJP201 PJP202 = JUMP_43X39
PJP29 = JUMP_43X39: room: SIO
PJP33 = JUMP_43X79: room: +5V_HDD SOURCE
PJP65 = JUMP_43X39: room: KBC
PJP77 = JUMP_43X39: room: TPM
PJP100-PJP103 PJP200 PJP203 PJP204 = JUMP_43X118
PJPDC1 = ACES_50493-0110N-001_11P
PL1 = TAI-T_HCB2012KF-121T50_2P
PL2 PL6 = TAIYO_FBMJ4516HS720NT_2P
PL3 = MURAT_BLM15HG601SN1D_2P
PL4 = CHT_C8BBPH853025_2P
PL100 PL700 = CYNTE_PCMB053T-1R0MS_2P
PL102 = TOKO_FDV0630-3R3M-P3_2P
PL103 = TOKO_FDSD0630-H-2R2M-P3_2P
PL201 = CYNTE_PCMC104T-1R0MN_2P
PL301 = TAI-T_VMPI0703AR-4R7M-Z01_2P
PL401 = CYNTE_PH041H-1R0MS_2P
PL500-PL502 = NEC_MPC0740LR42C_2P
PL510 = L_1812-1806
PL701 = CYNTE_PCMB104T-5R6MS_2P
PQ1 PQ700 PQ702 PQ1070 PQ1072 = NTR4502PT1G_SOT23-3
PQ2 = FDV301N_NL_SOT23-3
PQ3 = MMST3904-7-F_SOT323-3
PQ4 = TP0610K-T1-E3_SOT23-3
PQ5 PQ701 PQ1001 PQ1003 PQ1004 PQ1008 PQ1009 = SI7447DP_SO8_5P
PQ7 PQ1010 PQ1011 PQ1082 = SSM3K7002FU_SC70-3
PQ8 PQ1083 = IMD2AT-108_SC74-6
PQ101 PQ102 PQ301 = SIS412DN-T1-GE3_POWERPAK8-5
PQ103 PQ104 PQ303 = SI7716ADN-T1-GE3_POWERPAK8-5
PQ201 PQ202 PQ704 = SIR472DP-T1-GE3_POWERPAK8-5
PQ204 PQ205 PQ706 PQ707 PQ710 PQ1071 PQ1080 Q6 Q81 Q304 = DMN66D0LDW-7_SOT363-6
PQ500 PQ502 PQ504 = CSD86350Q5D_SON8
PQ703 = NTGD4161PT1G_TSOP6
PQ705 = FDMC7692S_MLP8-5
PQ1002 PQ1005 = SI4835DDY-T1-E3_SO8
PR3 = RP_0804_8P4R
PR19 PR1011 = R_0805
PR33 PR103 PR111 PR118 PR240 PR315 PR406 PR501 PR513 PR522 PR524 PR526 PR548 PR700 PR702 PR703 PR705 PR710 PR711 PR714 PR718 PR739 PR742 PR763 PR766 PR1002 PR1004 PR1006-PR1010 PR1012 PR1014-PR1017 PR1019-PR1023 PR1025 PR1027 PR1029 PR1033 PR1070 R563 R760 R802 R844 RD12 RH101 = R0402_0OHM
PR107 PR108 PR200 PR203 PR301 PR401 PR502 PR510 PR511 PR534 PR535 PR539 PR549 PR552 PR553 PR759 PR761 PR765 RC99 RC106 RH236 = R_0603
PR109 PR110 PR202 PR304 PR515 PR542 PR554 PR724 PR775 PR1005 = R_1206
PR505 PR506 PR508 = R0402_0OHM: signal model: R_0402NEW
PR520 R709 RH240 = R0603_0OHM
PR701 PR723 = R_1206_4P-D
PU1 = TS5A63157DCKR_SC70-6
PU101 = TPS51225CRUKR_QFN20_3X3
PU200 = RT8207MZQW_WQFN20_3X3
PU300 = TPS51212DSCR_SON10_3X3
PU400 = SY8033BDBC_DFN10_3X3
PU500 = ISL95812HRZ-T_QFN32_4X4
PU501 = ISL6208BCRZ-T_QFN8_2X2
PU700 = BQ24737RGRR_VQFN20_3P5X3P5
PU701 = INA199A1DCKR_SC70-6
PU703 = LM393DR_SO8
PU704 PU1080 PU1081 = TC7SH08FU_SSOP5
PU1001 = CD3301RHHR_QFN36_6X6
PWRSW1 = SHORTPADS: User Part Number: PART#; room: PWR_BTN
Q4 Q5 = DMN65D8LW-7_SOT323-3: room: MXM
Q14-Q17 Q26-Q28 = PMST3904_SOT323-3: room: THERMAL
Q21 = FDC654P-G_SSOT-6: room: LVDS
Q22 = DMN65D8LW-7_SOT323-3: room: LVDS
Q24 = PMV65XP_SOT23-3: room: CAM
Q29 = DMN66D0LDW-7_SOT363-6: room: FFS
Q45 Q52 = DMN65D8LW-7_SOT323-3: room: KBC
Q55 Q338 = DMN65D8LW-7_SOT323-3: room: USB3.0
Q63 = SI4164DY-T1-GE3_SO8
Q74 Q344 = DMN66D0LDW-7_SOT363-6: room: LED
Q75 Q79 Q80 Q86 = PDTA114EU_SC70-3: room: LED
Q77 = DMN65D8LW-7_SOT323-3: room: WWAN
Q78 Q84 Q318 Q326 Q328 = DMN65D8LW-7_SOT323-3: room: LED
Q87 = DMN65D8LW-7_SOT323-3: room: MXM_PWR_SRC SOURCE
Q89 = L2N7002WT1G_SC-70-3: room: WLAN
Q110 Q113 = DMN66D0LDW-7_SOT363-6: room: DP_SW
Q124 = DMN66D0LDW-7_SOT363-6: room: WLAN
Q186 = SI4835DDY-T1-GE3_SO8: room: MXM_PWR_SRC SOURCE
Q295 = DMN66D0LDW-7_SOT363-6: room: MXM
Q322 = DMN65D8LW-7_SOT323-3: room: MSATA
Q325 = DMN66D0LDW-7_SOT363-6: room: LAN
Q327 = DMN65D8LW-7_SOT323-3: room: LAN
Q335-Q337 Q345 Q346 = DMN66D0LDW-7_SOT363-6: room: HDMI_DEMUX
Q339 Q340 = DMN66D0LDW-7_SOT363-6: room: DP
QC5 = DMN65D8LW-7_SOT323-3: room: PCH
QC6 = LBSS138LT1G_SOT23-3: room: EDP
QH2 = BSS138_NL_SOT23-3: room: PCH
QH3 = L2N7002WT1G_SC-70-3: room: PCH
QH4 = DMN66D0LDW-7_SOT363-6: room: PCH
R1-R6 R10 R11 R37 R38 R1972 R1973 R1977-R1979 = R_0402: room: MXM
R7-R9 R895 R897 R899-R901 R936 R3664-R3670 RE1 RE2 RH180 RH186 = R_0402: room: FLASH ROM
R12-R14 R20 R21 R57 R58 R61 R63-R74 R82 R460 R461 R491 R518 R1128 R1164 R1165 R2151-R2154 R2157 R2161 = R_0402: room: HDMI_DEMUX
R17 R102 R763 R768 R775 R782 R794 R795 R798 R803-R805 R807 = R_0402: room: SIO
R18 R22-R28 R30 R747 R816 R1614 R2141 = R_0402: room: USB3.0
R45 = R_0402: room: HDD
R53-R55 = R_0402: room: CRT
R56 R59 R62 R75-R81 R415 R2190-R2193 = R_0402: room: DP
R96 R98 R99 R115-R124 = R_0402: room: DP_MUX
R101 R127 R1990 R1993-R1995 = R_0402: room: EDP_LVDS
R105 = R0603_0OHM: room: CPU
R159 R160 R422 R423 R1137 R1138 = R_0402: room: LVDS
R209 = R0603_0OHM: room: LAN
R222 R336 R339 RC65 RC75 = R_0402: room: EDP
R301 = R_0402: room: +3V_MXM SOURCE
R392 R394-R396 R399 R402 R405 R407-R410 R418 R420 R424 R426 R430 R818 R820 R1983 = R_0402: room: THERMAL
R429 R759 R799 R810 R811 R814 R817 R819 R822 R825 R829 R835 R838-R841 R843 R847-R849 R854 R855 R864 R869-R876 R883-R885 R887 R892 R893 R1069 R1118 R1125 R1197 R1980-R1982 R1984 R1986 = R_0402: room: KBC
R451-R456 R458 R459 = R_0402: room: HDMI_DEMUX; signal model: R_0402NEW
R492 R1530 R1532 R1537 R1539 = R_0402: room: DP_SW
R501-R503 R513 = R_0402: room: FFS
R514 = R_0402: room: +5VMOD SOURCE
R549 R553 R554 R561 R562 R566 = R_0402: room: LAN
R550 R560 R568 R757 R785 = R_0402: room: MSATA
R555 R556 R558 = R0402_0OHM: room: LAN
R571-R574 R1167 R1170 R1171 = R_0402: room: LOM
R585 R589 = R_0402: room: USH
R656 RE5 = R_0402: room: TPM
R692 R705 R706 R718 R725 R823 R824 = R_0402: room: WLAN
R717 = R_0402: room: WLAN_PWR
R719 R1159 R1160 = R_0402: room: WWAN
R720 = R_0402: room: WWAN_PWR
R755 R756 R2160 RE11 RE12 = R_0402: room: DOCKING
R783 = R_0402: room: ESATA
R796 = R_0402: room: ODD
R801 = R_0603: room: DP
R866 = R0402_0OHM: room: KBC
R932 R934 R937-R939 R941-R943 R955 R956 = R_0402: room: LED
R935 R940 = R_0402: room: MXM_PWR_SRC SOURCE
R952 = R_0402: room: KBC; signal model: R_0402NEW
R1123 R1124 = R_0402: room: LVDS SW
R1622 R1629 R1630 = R_0402: room: RSMRST
R1626 = R0402_0OHM: room: USB3.0
R1970 = R0402_0OHM: room: MXM
R2164-R2179 = R_0402: room: DOCKING; signal model: R_0402NEW
R2188 = R0402_0OHM: room: TPM
R2195 R2196 = R_0402: room: EDP_LVDS; signal model: R_0402NEW
RC1 RC2 RC14 RC16 RC18 RC19 RC23 RC24 RC27 RC29-RC32 RC35 RC40-RC42 RC44 RC45 RC47-RC50 RC55-RC60 RC62 RC63 RC66 RC69-RC71 RC76 RC77 RC128 RC130 = R_0402: room: CPU
RC5-RC9 RC64 RC124 = R_0402: room: XDP1
RC26 = R0402_0OHM: room: CPU
RC61 = R_0402: room: CPU; signal model: R_0402NEW
RC109 RC110 RD41 RD43-RD47 = R_0402: room: DIMM1
RC111 RD48-RD50 = R_0402: room: DIMM3
RC125 RC127 RH107 RH108 = R_0402: room: XDP1; signal model: R_0402NEW
RC126 RH5 RH34-RH37 RH39 RH40 RH42-RH45 RH47 RH48 RH50 RH52 RH54-RH57 RH60 RH62 RH67 RH74-RH78 RH80 RH81 RH83 RH84 RH86 RH87 RH90 RH97 RH99 RH100 RH112 RH113 RH115-RH120 RH123-RH125 RH128-RH130 RH140 RH142 RH144-RH146 RH153 RH155 RH157-RH162 RH164-RH166 RH168 RH170 RH171 RH174-RH176 RH187 RH192 RH200 RH202 RH205 RH206 RH208 RH210-RH213 RH216 RH217 RH222 RH223 RH225 RH226 RH228-RH230 RH232 RH246-RH249 RH254-RH256 RH328 = R_0402: room: PCH
RD8 RD11 = R0402_0OHM: room: DIMM1
RD19 RD20 = R0402_0OHM: room: DIMM2
RD26 RD27 = R0402_0OHM: room: DIMM3
RD36 RD37 = R0402_0OHM: room: DIMM4
RH3 RH4 RH6-RH14 RH16 RH17 RH19 RH20 RH22 RH24-RH28 RH32 = R_0402: room: XDP2
RH30 RH31 = R_0402: room: XDP2; signal model: R_0402NEW
RH46 = R_0603: room: PCH
RH59 RH61 RH63 RH65 RH94 RH95 = R_0402: room: PCH; signal model: R_0402NEW
RH106 RH195 RH219 = R0402_0OHM: room: PCH
RH177-RH179 RH181-RH185 = R0402_0OHM: room: FLASH ROM
RH238 RH241 = R0603_0OHM: room: PCH
RH242 RH244 RH245 = R0805_0OHM: room: PCH
RP1-RP4 RP8 = RP_0804_8P4R: room: SIO
RP5 RP6 RPH1 RPH3 RPH5 RPH7-RPH10 = RP_0804_8P4R: room: PCH
RP7 = RP_0804_8P4R: room: KBC
RP9 = RP_0804_8P4R: room: ETY-ROOM
T1-T6 T103-T105 T127 T135-T140 T166 T167 T171 T172 = TPC12
T57-T59 T61 T65-T68 T118 T120-T126 T129-T134 T141 T144-T150 = TPC12: room: PCH
T60 T64 T69-T102 T110 T112-T115 T151-T154 T157-T160 T162-T164 = TPC12: room: CPU
T119 T155 = TPC12: room: SIO
T142 T143 = TPC12: room: LAN
T156 = TAIMA_IH-115-F_24P: room: LOM
U2 = SLG55594AVTR_TDFN8_2X2: room: USB3.0
U3 = TC7SH125FU_SSOP5: room: LVDS
U4 = RT9818A-44GU3_SC70-3: room: RSMRST
U5 = AP2330W-7_SC59-3: room: HDMI_DEMUX
U6 = AP2330W-7_SC59-3: room: CRT
U7 = TC7SH08FU_SSOP5: room: RSMRST
U8 = AP2337SA-7_SOT23-3
U9 = PS8339BQFN56GTR2-A0_QFN56_7X7: room: HDMI_DEMUX
U10 = TC7SH08FU_SSOP5: room: THERMAL
U11 U13 = TS3DV20812RHHR_VQFN36_6X6: room: LVDS SW
U14 U25 U27 = SN74AHC1G08DCKR_SC70-5: room: MXM
U15 = TC7SH08FU_SSOP5: room: LAN
U16 U17 = 74AHC1G09GW_TSSOP5: room: MXM
U19 = MAX14885EETLLFT_TQFN40_5X5: room: CRT
U20 = PI3C3125LEX_TSSOP14: room: DP_SW
U22 = PS8330BQFN48GTR-A0_QFN48_7X7: room: DP
U23 = RTD2136S-CG_QFN48_6X6: room: EDP_LVDS
U29 = EMC4021-1-EZK-TR_QFN32_5X5: room: THERMAL
U31 = WGI217LM-QPN9-A2_QFN48_6X6: room: LAN
U32 = PI3L720ZHEX_TQFN42_9X3P5: room: LAN
U34 = TPS22966DPUR_SON14_2X3: room: +3V_MXM SOURCE
U35 = TPS22966DPUR_SON14_2X3: room: +5V_MXM SOURCE
U37 = TPS22965DSGR_SON8_2X2: room: +5V_RUN SOURCE
U38 = TPS22965DSGR_SON8_2X2: room: +3.3V_RUN SOURCE
U39 = AT97SC3204-X2A14-AB_TSSOP28: room: TPM
U43 = TPS22965DSGR_SON8_2X2: room: WWAN_PWR
U45 = TPS2560DRCR-PG1P1_SON10_3X3: room: USB3.0
U46 = ECE5048-LZY_DQFN132_11X11: room: SIO
U48 = TPS2560DRCR-PG1P1_SON10_3X3: room: ESATA
U50 = TC7SH08FU_SSOP5: room: KBC
U51 = MEC5075-LZY_DQFN132_11X11: room: KBC
U52 = W25Q64FVSSIQ_SO8: room: FLASH ROM
U53 = W25Q32FVSSIQ_SO8: room: FLASH ROM
U54 = TC7SH08FU_SSOP5: room: LVDS
U56 = TPS22965DSGR_SON8_2X2
U57 = TPS22966DPUR_SON14_2X3: room: +5VMOD SOURCE
U58 = 74AHC1G08GW_SOT353-5: room: LED
U62 = APL3512ABI-TRG_SOT23-5: room: ETY-ROOM
U63 = TPS22966DPUR_SON14_2X3: room: +3.3V_LAN PWR
U88 = LNG3DMTR_LGA16_3X3: room: FFS
U629 = PS8331BQFN60GTR-A0_QFN60_5X9: room: DP_MUX
U637 = ASM1467_QFN20_4X4: room: MSATA
U638 = PS8723BTQFN32GTR-A0_TQFN32_3X6: room: USB3.0
UC2 = 74AHC1G09GW_TSSOP5: room: CPU
UH1 = DH82LPMS-QC4C-A1_FCBGA_695P: room: PCH
UH2 UH3 = TC7SH08FU_SSOP5: room: PCH
Y3 = Y_X3G025000DI1H-H_4P: room: LAN
Y6 = Y_Q13FC135000040_2P: room: KBC
YH1 = Y_Q13FC135000040_2P: room: PCH
YH2 = Y_Q22FA2380049900_4P: room: PCH

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
74AHC1G08GW_SOT353-5
  oval 0.381x0.813 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.8) 5(0,1.8)
74AHC1G09GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
ACES_50228-0034N-001_3P
  oval 0.61x1.549 smd: 1(0,0) 2(1,0) 3(2,0)
  rect 1.194x1.803 smd: 4(-1.3,2.525) 5(3.3,2.525)
ACES_50228-0067N-001_6P
  oval 0.61x1.549 smd: 1(0,0) 2(-1,0) 3(-2,0) 4(-3,0) 5(-4,0) 6(-5,0)
  rect 1.194x1.803 smd: 7(1.3,2.525) 8(-6.3,2.525)
ACES_50271-0020N-001_2P
  oval 0.787x1.6 smd: 1(0,0) 2(1.25,0)
  rect 2.108x2.997 smd: 3(3.8,-2.9) 4(-2.55,-2.9)
ACES_50271-0040N-001_4P
  oval 0.787x1.6 smd: 1(0,0) 2(-1.25,0) 3(-2.5,0) 4(-3.75,0)
  rect 2.108x2.997 smd: 5(2.55,-2.9) 6(-6.3,-2.9)
ACES_50398-04071-001_40P
  oval 0.254x1.295 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0) 11(-5,0) 12(-5.5,0) 13(-6,0) 14(-6.5,0) 15(-7,0) 16(-7.5,0) 17(-8,0) 18(-8.5,0) 19(-9,0) 20(-9.5,0) 21(-10,0) 22(-10.5,0) 23(-11,0) 24(-11.5,0) 25(-12,0) 26(-12.5,0) 27(-13,0) 28(-13.5,0) 29(-14,0) 30(-14.5,0) 31(-15,0) 32(-15.5,0) 33(-16,0) 34(-16.5,0) 35(-17,0) 36(-17.5,0) 37(-18,0) 38(-18.5,0) 39(-19,0) 40(-19.5,0)
  rect 1.194x3.2 smd: 41(-21.9,1.95) 45(2.4,1.95)
  rect 2.311x1.295 smd: 42(-18.65,3.9) 43(-9.75,3.9) 44(-0.85,3.9)
ACES_50493-0110N-001_11P
  rect 0.838x7.01 smd: 1(0,0) 2(1.5,0) 3(3,0) 4(4.5,0) 5(6,0) 6(7.5,0) 7(9,0) 8(10.5,0) 9(12,0) 10(13.5,0) 11(15,0)
ACES_87152-10071_10P
  oval 0.305x1.092 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0)
  custom 0.6x0.6 smd: 11(-6.6,-1.95) 12(2.1,-1.95)
ACES_88512-01601-071_16P
  oval 0.305x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0)
  rect 2.159x2.21 smd: 17(-2.325,-3.05) 18(9.825,-3.05)
AP2330W-7_SC59-3
  oval 0.787x0.991 smd: 1(0,0) 2(-0.95,-2.4) 3(0.95,-2.4)
AP2337SA-7_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
APL3512ABI-TRG_SOT23-5
  oval 0.61x1.041 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.7) 5(0,2.7)
ASM1467_QFN20_4X4
  oval 0.254x0.991 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 11(2,4) 12(1.5,4) 13(1,4) 14(0.5,4) 15(0,4)
  oval 0.991x0.254 smd: 6(3,1) 7(3,1.5) 8(3,2) 9(3,2.5) 10(3,3) 16(-1,3) 17(-1,2.5) 18(-1,2) 19(-1,1.5) 20(-1,1)
  rect 2.108x2.108 smd: 21(1,2)
AT97SC3204-X2A14-AB_TSSOP28
  oval 0.381x1.626 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(2.6,0) 6(3.25,0) 7(3.9,0) 8(4.55,0) 9(5.2,0) 10(5.85,0) 11(6.5,0) 12(7.15,0) 13(7.8,0) 14(8.45,0) 15(8.45,5.8) 16(7.8,5.8) 17(7.15,5.8) 18(6.5,5.8) 19(5.85,5.8) 20(5.2,5.8) 21(4.55,5.8) 22(3.9,5.8) 23(3.25,5.8) 24(2.6,5.8) 25(1.95,5.8) 26(1.3,5.8) 27(0.65,5.8) 28(0,5.8)
BAT54CW_SOT323-3
  oval 0.66x0.864 smd: 1(0,0) 2(-0.65,-1.85) 3(0.65,-1.85)
BAT1000-7-F_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BQ24737RGRR_VQFN20_3P5X3P5
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 11(2,3.45) 12(1.5,3.45) 13(1,3.45) 14(0.5,3.45) 15(0,3.45)
  oval 1.041x0.254 smd: 6(2.725,0.725) 7(2.725,1.225) 8(2.725,1.725) 9(2.725,2.225) 10(2.725,2.725) 16(-0.725,2.725) 17(-0.725,2.225) 18(-0.725,1.725) 19(-0.725,1.225) 20(-0.725,0.725)
  rect 2.057x2.057 smd: 21(1,1.725)
BSS138_NL_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
C_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
C_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
C_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
C_1808
  rect 1.041x2.311 smd: 1(0,0) 2(4.35,0)
C_APXK2R5ARA331MF451
  oval 3.15x1.6 smd: 1(0,0) 2(-5.05,0)
C_APXK6R3ARA221MF451
  oval 3.15x1.6 smd: 1(0,0) 2(5.05,0)
C_B2
  rect 1.346x2.692 smd: 1(0,0) 2(-2.75,0)
C_D2
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_D2E
  rect 2.388x2.896 smd: 1(0,0) 2(6.1,0)
C_EEEFK1E101YP
  oval 3.2x1.6 smd: 1(0,0) 2(5,0)
C_X
  rect 1.803x2.896 smd: 1(0,0) 2(6,0)
CD3301RHHR_QFN36_6X6
  oval 0.254x1.194 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 19(4,5.8) 20(3.5,5.8) 21(3,5.8) 22(2.5,5.8) 23(2,5.8) 24(1.5,5.8) 25(1,5.8) 26(0.5,5.8) 27(0,5.8)
  oval 1.194x0.254 smd: 10(4.9,0.9) 11(4.9,1.4) 12(4.9,1.9) 13(4.9,2.4) 14(4.9,2.9) 15(4.9,3.4) 16(4.9,3.9) 17(4.9,4.4) 18(4.9,4.9) 28(-0.9,4.9) 29(-0.9,4.4) 30(-0.9,3.9) 31(-0.9,3.4) 32(-0.9,2.9) 33(-0.9,2.4) 34(-0.9,1.9) 35(-0.9,1.4) 36(-0.9,0.9)
  rect 4.089x4.089 smd: 37(2,2.9)
CHT_C8BBPH853025_2P
  rect 2.54x1.397 smd: 1(-3.81,0) 2(3.81,0)
CONCR_099AAAC19BBLCNF_19P
  round 0.813 hole 0.559: 1(0,0) 2(-0.5,-1) 3(-1,0) 4(-1.5,-1) 5(-2,0) 6(-2.5,-1) 7(-3,0) 8(-3.5,-1) 9(-4,0) 10(-4.5,-1) 11(-5,0) 12(-5.5,-1) 13(-6,0) 14(-6.5,-1) 15(-7,0) 16(-7.5,-1) 17(-8,0) 18(-8.5,-1) 19(-9,0)
  oval 1.499x3.302 hole 0.787x2.388: 20(-11.75,-1.41) 21(2.75,-1.41)
  oval 1.499x2.692 hole 0.787x1.397: 22(-11.75,-7.37) 23(2.75,-7.37)
CSD86350Q5D_SON8
  oval 2.032x0.889 smd: 1(0,0)
  oval 0.711x0.889 smd: 2(1.98,0) 3(3.3,0) 4(3.3,5.39) 5(1.98,5.39) 6(0.66,5.39) 7(-0.66,5.39)
  custom 0.883x0.883 smd: 8(1.32,2.695)
CYNTE_PCMB053T-1R0MS_2P
  rect 1.905x2.794 smd: 1(0,0) 2(4.1,0)
CYNTE_PCMB104T-5R6MS_2P
  rect 3.81x3.988 smd: 1(0,0) 2(9.2,0)
CYNTE_PCMC104T-1R0MN_2P
  rect 2.489x3.505 smd: 1(0,0) 2(9,0)
CYNTE_PG031B-4R7MS_2P
  rect 0.889x1.194 smd: 1(0,0) 2(2.2,0)
CYNTE_PH041H-1R0MS_2P
  rect 1.295x3.81 smd: 1(0,0) 2(3.1,0)
D_0603
  oval 0.864x1.219 smd: 1(-0.711,0) 2(0.711,0)
DB2J31400L_SOD323-2
  rect 0.991x1.092 smd: 1(0,0)
  rect 0.991x0.889 smd: 2(2.1,0)
DELTA_0603CS-120EJTS_2P
  rect 0.635x1.016 smd: 1(0,0) 2(1.28,0)
DH82LPMS-QC4C-A1_FCBGA_695P
  round 0.483 smd: A2(0.624,0) A44(18.101,0) B1(0,-0.624) B45(18.625,-0.524) BD1(0,-18.101) BD45(18.625,-18.101) BE2(0.524,-18.625) BE44(18.101,-18.625)
  round 0.356 smd: A4(1.217,0) A5(1.81,0) A41(16.915,0) A43(17.508,0) B2(0.603,-0.603) B44(18.022,-0.603) BA1(0,-16.915) BA45(18.625,-16.915) BC1(0,-17.508) BC45(18.625,-17.508) BD2(0.603,-18.022) BD44(18.022,-18.022) BE3(1.117,-18.625) BE5(1.71,-18.625) BE41(16.915,-18.625) BE43(17.508,-18.625) C45(18.625,-1.117) D1(0,-1.217) E1(0,-1.81) E45(18.625,-1.71)
  round 0.33 smd: A6(2.483,0) A40(16.242,0) AY1(0,-16.242) AY45(18.625,-16.242) B4(1.315,-0.586) B42(17.233,-0.637) BA2(0.551,-16.664) BB2(0.563,-17.31) BB44(17.988,-17.233) BD4(1.391,-17.988) BD41(16.664,-18.074) BD42(17.31,-18.061) BE6(2.383,-18.625) BE40(16.242,-18.625) D2(0.637,-1.391) D44(18.061,-1.315) E44(18.074,-1.96) F1(0,-2.483) F45(18.625,-2.383)
  round 0.305 smd: A8(3.216,0) A10(4.029,0) A12(4.842,0) A14(5.655,0) A16(6.468,0) A18(7.28,0) A20(8.093,0) A22(8.906,0) A24(9.719,0) A26(10.532,0) A28(11.344,0) A30(12.157,0) A32(12.97,0) A34(13.783,0) A36(14.596,0) A38(15.408,0) AA2(0.452,-8.478) AA4(1.336,-8.5) AA14(5.515,-8.827) AA16(6.328,-8.827) AA18(7.141,-8.827) AA20(7.954,-8.827) AA22(8.766,-8.827) AA24(9.579,-8.827) AA26(10.392,-8.827) AA28(11.205,-8.827) AA30(12.018,-8.827) AA32(12.83,-8.827) AA42(17.289,-8.5) AA44(18.173,-8.521) AB1(0,-8.906) AB3(0.904,-8.906) AB6(1.934,-9.008) AB7(2.531,-9.008) AB8(3.128,-9.008) AB10(3.724,-9.008) AB11(4.321,-9.008) AB12(4.918,-9.008) AB34(13.707,-9.008) AB35(14.304,-9.008) AB36(14.9,-9.008) AB38(15.497,-9.008) AB39(16.094,-9.008) AB40(16.691,-9.008) AB43(17.721,-8.906) AB45(18.625,-8.906) AC2(0.472,-9.312) AC44(18.152,-9.312) AD1(0,-9.719) AD3(0.904,-9.719) AD6(1.934,-9.617) AD7(2.531,-9.617) AD8(3.128,-9.617) AD10(3.724,-9.617) AD11(4.321,-9.617) AD12(4.918,-9.617) AD14(5.515,-9.488) AD16(6.328,-9.488) AD18(7.141,-9.488) AD20(7.954,-9.488) AD22(8.766,-9.488) AD24(9.579,-9.488) AD26(10.392,-9.488) AD28(11.205,-9.488) AD30(12.018,-9.488) AD32(12.83,-9.488) AD34(13.707,-9.617) AD35(14.304,-9.617) AD36(14.9,-9.617) AD38(15.497,-9.617) AD39(16.094,-9.617) AD40(16.691,-9.617) AD43(17.721,-9.719) AD45(18.625,-9.719) AE2(0.452,-10.103) AE4(1.336,-10.125) AE14(5.515,-10.148) AE16(6.328,-10.148) AE18(7.141,-10.148) AE20(7.954,-10.148) AE22(8.766,-10.148) AE24(9.579,-10.148) AE26(10.392,-10.148) AE28(11.205,-10.148) AE30(12.018,-10.148) AE32(12.83,-10.148) AE42(17.289,-10.125) AE44(18.173,-10.147) AF1(0,-10.532) AF3(0.904,-10.532) AF6(1.934,-10.595) AF7(2.531,-10.595) AF8(3.128,-10.595) AF10(3.724,-10.595) AF11(4.321,-10.595) AF12(4.918,-10.595) AF34(13.707,-10.595) AF35(14.304,-10.595) AF36(14.9,-10.595) AF38(15.497,-10.595) AF39(16.094,-10.595) AF40(16.691,-10.595) AF43(17.721,-10.532) AF45(18.625,-10.532) AG2(0.472,-10.938) AG14(5.515,-10.808) AG16(6.328,-10.808) AG18(7.141,-10.808) AG20(7.954,-10.808) AG22(8.766,-10.808) AG24(9.579,-10.808) AG26(10.392,-10.808) AG28(11.205,-10.808) AG30(12.018,-10.808) AG32(12.83,-10.808) AG44(18.152,-10.938) AH1(0,-11.344) AH3(0.904,-11.344) AH43(17.721,-11.344) AH45(18.625,-11.344) AJ2(0.452,-11.729) AJ4(1.336,-11.751) AJ6(1.934,-11.573) AJ7(2.531,-11.573) AJ8(3.128,-11.573) AJ10(3.724,-11.573) AJ11(4.321,-11.573) AJ12(4.918,-11.573) AJ14(5.515,-11.469) AJ16(6.328,-11.469) AJ18(7.141,-11.469) AJ20(7.954,-11.469) AJ22(8.766,-11.469) AJ24(9.579,-11.469) AJ26(10.392,-11.469) AJ28(11.205,-11.469) AJ30(12.018,-11.469) AJ32(12.83,-11.469) AJ34(13.707,-11.573) AJ35(14.304,-11.573) AJ36(14.9,-11.573) AJ38(15.497,-11.573) AJ39(16.094,-11.573) AJ40(16.691,-11.573) AJ42(17.289,-11.751) AJ44(18.173,-11.773) AK1(0,-12.157) AK3(0.904,-12.157) AK14(5.515,-12.129) AK16(6.328,-12.129) AK18(7.141,-12.129) AK20(7.954,-12.129) AK22(8.766,-12.129) AK24(9.579,-12.129) AK26(10.392,-12.129) AK28(11.205,-12.129) AK30(12.018,-12.129) AK32(12.83,-12.129) AK43(17.721,-12.157) AK45(18.625,-12.157) AL2(0.472,-12.564) AL6(1.934,-12.551) AL7(2.531,-12.551) AL8(3.128,-12.551) AL10(3.724,-12.551) AL11(4.321,-12.551) AL12(4.918,-12.551) AL34(13.707,-12.551) AL35(14.304,-12.551) AL36(14.9,-12.551) AL38(15.497,-12.551) AL39(16.094,-12.551) AL40(16.691,-12.551) AL44(18.152,-12.564) AM1(0,-12.97) AM3(0.904,-12.97) AM14(5.515,-12.79) AM16(6.328,-12.79) AM18(7.141,-12.79) AM20(7.954,-12.79) AM22(8.766,-12.79) AM24(9.579,-12.79) AM26(10.392,-12.79) AM28(11.205,-12.79) AM30(12.018,-12.79) AM32(12.83,-12.79) AM43(17.721,-12.97) AM45(18.625,-12.97) AN2(0.452,-13.355) AN4(1.336,-13.376) AN6(1.934,-13.529) AN7(2.531,-13.529) AN8(3.128,-13.529) AN10(3.724,-13.529) AN11(4.321,-13.529) AN34(13.656,-13.529) AN35(14.304,-13.529) AN36(14.9,-13.529) AN38(15.497,-13.529) AN39(16.094,-13.529) AN40(16.691,-13.529) AN42(17.289,-13.376) AN44(18.173,-13.398) AP1(0,-13.783) AP3(0.904,-13.783) AP13(5.096,-13.656) AP15(6.074,-13.707) AP17(7.052,-13.707) AP20(8.03,-13.707) AP22(9.008,-13.707) AP24(9.617,-13.707) AP26(10.595,-13.707) AP29(11.573,-13.707) AP31(12.551,-13.707) AP43(17.721,-13.783) AP45(18.625,-13.783) AR2(0.472,-14.189) AR13(5.096,-14.304) AR15(6.074,-14.304) AR17(7.052,-14.304) AR20(8.03,-14.304) AR22(9.008,-14.304) AR24(9.617,-14.304) AR26(10.595,-14.304) AR29(11.573,-14.304) AR31(12.551,-14.304) AR33(13.529,-14.304) AR44(18.152,-14.189) AT1(0,-14.596) AT3(0.904,-14.596) AT6(1.934,-14.507) AT7(2.531,-14.507) AT8(3.128,-14.507) AT10(4.118,-14.9) AT13(5.096,-14.9) AT15(6.074,-14.9) AT17(7.052,-14.9) AT20(8.03,-14.9) AT22(9.008,-14.9) AT24(9.617,-14.9) AT26(10.595,-14.9) AT29(11.573,-14.9) AT31(12.551,-14.9) AT33(13.529,-14.9) AT36(14.9,-14.507) AT38(15.497,-14.507) AT39(16.094,-14.507) AT40(16.691,-14.507) AT43(17.721,-14.596) AT45(18.625,-14.596) AU2(0.452,-14.98) AU4(1.336,-15.002) AU42(17.289,-15.002) AU44(18.173,-15.024) AV1(0,-15.408) AV3(0.904,-15.408) AV6(1.934,-15.485) AV7(2.531,-15.485) AV10(4.118,-15.497) AV13(5.096,-15.497) AV15(6.074,-15.497) AV17(7.052,-15.497) AV20(8.03,-15.497) AV22(9.008,-15.497) AV24(9.617,-15.497) AV26(10.595,-15.497) AV29(11.573,-15.497) AV31(12.551,-15.497) AV33(13.529,-15.497) AV36(14.507,-15.497) AV40(16.691,-15.485) AV43(17.721,-15.408) AV45(18.625,-15.408) AW2(0.472,-15.815) AW8(3.14,-16.094) AW10(4.118,-16.094) AW13(5.096,-16.094) AW15(6.074,-16.094) AW17(7.052,-16.094) AW20(8.03,-16.094) AW22(9.008,-16.094) AW24(9.617,-16.094) AW26(10.595,-16.094) AW29(11.573,-16.094) AW31(12.551,-16.094) AW33(13.529,-16.094) AW36(14.507,-16.094) AW38(15.485,-16.094) AW40(17.123,-16.221) AW44(18.152,-15.815) AY3(0.978,-16.221) AY5(1.743,-16.051) AY7(2.404,-17.123) AY8(3.14,-16.691) AY10(4.118,-16.691) AY13(5.096,-16.691) AY15(6.074,-16.691) AY17(7.052,-16.691) AY20(8.03,-16.691) AY22(9.008,-16.691) AY24(9.617,-16.691) AY26(10.595,-16.691) AY29(11.573,-16.691) AY31(12.551,-16.691) AY33(13.529,-16.691) AY36(14.507,-16.691) AY38(15.485,-16.691) AY43(17.721,-16.221) B5(1.96,-0.586) B7(2.739,-0.552) B9(3.645,-0.452) B11(4.436,-0.472) B13(5.27,-0.452) B15(6.061,-0.472) B17(6.896,-0.452) B19(7.687,-0.472) B21(8.521,-0.452) B23(9.312,-0.472) B25(10.147,-0.452) B27(10.938,-0.472) B29(11.773,-0.452) B31(12.564,-0.472) B33(13.398,-0.452) B35(14.189,-0.472) B37(15.024,-0.452) B39(15.815,-0.472) BA40(16.051,-16.882) BB4(1.391,-17.302) BB9(3.623,-17.289) BB13(5.248,-17.289) BB17(6.874,-17.289) BB21(8.5,-17.289) BB25(10.125,-17.289) BB29(11.751,-17.289) BB33(13.376,-17.289) BB37(15.002,-17.289) BB42(17.302,-17.233) BC6(2.404,-17.721) BC8(3.216,-17.721) BC10(4.029,-17.721) BC12(4.842,-17.721) BC14(5.655,-17.721) BC16(6.468,-17.721) BC18(7.28,-17.721) BC20(8.093,-17.721) BC22(8.906,-17.721) BC24(9.719,-17.721) BC26(10.532,-17.721) BC28(11.344,-17.721) BC30(12.157,-17.721) BC32(12.97,-17.721) BC34(13.783,-17.721) BC36(14.596,-17.721) BC38(15.408,-17.721) BC40(16.221,-17.647) BD7(2.81,-18.152) BD9(3.601,-18.173) BD11(4.436,-18.152) BD13(5.227,-18.173) BD15(6.061,-18.152) BD17(6.852,-18.173) BD19(7.687,-18.152) BD21(8.478,-18.173) BD23(9.312,-18.152) BD25(10.103,-18.173) BD27(10.938,-18.152) BD29(11.729,-18.173) BD31(12.564,-18.152) BD33(13.355,-18.173) BD35(14.189,-18.152) BD37(14.98,-18.173) BD39(15.815,-18.152) BE8(3.216,-18.625) BE10(4.029,-18.625) BE12(4.842,-18.625) BE14(5.655,-18.625) BE16(6.468,-18.625) BE18(7.28,-18.625) BE20(8.093,-18.625) BE22(8.906,-18.625) BE24(9.719,-18.625) BE26(10.532,-18.625) BE28(11.344,-18.625) BE30(12.157,-18.625) BE32(12.97,-18.625) BE34(13.783,-18.625) BE36(14.596,-18.625) BE38(15.408,-18.625) C6(2.37,-1.017) C8(3.216,-0.904) C10(4.029,-0.904) C12(4.842,-0.904) C14(5.655,-0.904) C16(6.468,-0.904) C18(7.28,-0.904) C20(8.093,-0.904) C22(8.906,-0.904) C24(9.719,-0.904) C26(10.532,-0.904) C28(11.344,-0.904) C30(12.157,-0.904) C32(12.97,-0.904) C34(13.783,-0.904) C36(14.596,-0.904) C38(15.408,-0.904) C40(16.221,-0.904) D4(1.323,-1.391) D9(3.623,-1.336) D13(5.248,-1.336) D17(6.874,-1.336) D21(8.5,-1.336) D25(10.125,-1.336) D29(11.751,-1.336) D33(13.376,-1.336) D37(15.002,-1.336) D42(17.233,-1.323) E6(2.574,-1.743) F3(0.978,-2.359) F8(3.14,-1.934) F10(4.118,-1.934) F13(5.096,-1.934) F15(6.074,-1.934) F17(7.052,-1.934) F20(8.03,-1.934) F22(9.008,-1.934) F24(9.617,-1.934) F26(10.595,-1.934) F29(11.573,-1.934) F31(12.551,-1.934) F33(13.529,-1.934) F36(14.507,-1.934) F38(15.485,-1.934) F39(16.221,-1.502) F41(16.882,-2.574) F43(17.647,-2.404) G2(0.532,-2.752) G5(1.562,-2.48) G8(3.14,-2.531) G10(4.118,-2.531) G13(5.096,-2.531) G15(6.074,-2.531) G17(7.052,-2.531) G20(8.03,-2.531) G22(9.008,-2.531) G24(9.617,-2.531) G26(10.595,-2.531) G29(11.573,-2.531) G31(12.551,-2.531) G33(13.529,-2.531) G36(14.507,-2.531) G38(15.485,-2.531) G44(18.152,-2.81) H1(0,-3.216) H3(0.904,-3.216) H6(1.934,-3.14) H7(2.531,-3.14) H10(4.118,-3.128) H13(5.096,-3.128) H15(6.074,-3.128) H17(7.052,-3.128) H20(8.03,-3.128) H22(9.008,-3.128) H24(9.617,-3.128) H26(10.595,-3.128) H29(11.573,-3.128) H31(12.551,-3.128) H33(13.529,-3.128) H36(14.507,-3.128) H39(16.094,-3.14) H40(16.691,-3.14) H43(17.721,-3.216) H45(18.625,-3.216) J2(0.452,-3.601) J4(1.336,-3.623) J42(17.289,-3.623) J44(18.173,-3.645) K1(0,-4.029) K3(0.904,-4.029) K6(1.934,-4.118) K7(2.531,-4.118) K8(3.128,-4.118) K10(3.724,-4.118) K13(5.096,-3.724) K15(6.074,-3.724) K17(7.052,-3.724) K20(8.03,-3.724) K22(9.008,-3.724) K24(9.617,-3.724) K26(10.595,-3.724) K29(11.573,-3.724) K31(12.551,-3.724) K33(13.529,-3.724) K36(14.507,-3.724) K38(15.497,-4.118) K39(16.094,-4.118) K40(16.691,-4.118) K43(17.721,-4.029) K45(18.625,-4.029) L2(0.472,-4.436) L13(5.096,-4.321) L15(6.074,-4.321) L17(7.052,-4.321) L20(8.03,-4.321) L22(9.008,-4.321) L24(9.617,-4.321) L26(10.595,-4.321) L29(11.573,-4.321) L31(12.551,-4.321) L33(13.529,-4.321) L44(18.152,-4.436) M1(0,-4.842) M3(0.904,-4.842) M15(6.074,-4.918) M17(7.052,-4.918) M20(8.03,-4.918) M22(9.008,-4.918) M24(9.617,-4.918) M26(10.595,-4.918) M29(11.573,-4.918) M31(12.551,-4.918) M33(13.529,-4.969) M43(17.721,-4.842) M45(18.625,-4.842) N2(0.452,-5.227) N4(1.336,-5.248) N6(1.934,-5.096) N7(2.531,-5.096) N8(3.128,-5.096) N10(3.724,-5.096) N11(4.321,-5.096) N12(4.969,-5.096) N35(14.304,-5.096) N36(14.9,-5.096) N38(15.497,-5.096) N39(16.094,-5.096) N40(16.691,-5.096) N42(17.289,-5.248) N44(18.173,-5.27) P1(0,-5.655) P3(0.904,-5.655) P14(5.515,-5.525) P16(6.328,-5.525) P18(7.141,-5.525) P20(7.954,-5.525) P22(8.766,-5.525) P24(9.579,-5.525) P26(10.392,-5.525) P28(11.205,-5.525) P30(12.018,-5.525) P32(12.83,-5.525) P43(17.721,-5.655) P45(18.625,-5.655) R2(0.472,-6.061) R6(1.934,-6.074) R7(2.531,-6.074) R8(3.128,-6.074) R10(3.724,-6.074) R11(4.321,-6.074) R12(4.918,-6.074) R14(5.515,-6.186) R16(6.328,-6.186) R18(7.141,-6.186) R20(7.954,-6.186) R22(8.766,-6.186) R24(9.579,-6.186) R26(10.392,-6.186) R28(11.205,-6.186) R30(12.018,-6.186) R32(12.83,-6.186) R34(13.707,-6.074) R35(14.304,-6.074) R36(14.9,-6.074) R38(15.497,-6.074) R39(16.094,-6.074) R40(16.691,-6.074) R44(18.152,-6.061) T1(0,-6.468) T3(0.904,-6.468) T43(17.721,-6.468) T45(18.625,-6.468) U2(0.452,-6.852) U4(1.336,-6.874) U6(1.934,-7.052) U7(2.531,-7.052) U8(3.128,-7.052) U10(3.724,-7.052) U11(4.321,-7.052) U12(4.918,-7.052) U14(5.515,-6.846) U16(6.328,-6.846) U18(7.141,-6.846) U20(7.954,-6.846) U22(8.766,-6.846) U24(9.579,-6.846) U26(10.392,-6.846) U28(11.205,-6.846) U30(12.018,-6.846) U32(12.83,-6.846) U34(13.707,-7.052) U35(14.304,-7.052) U36(14.9,-7.052) U38(15.497,-7.052) U39(16.094,-7.052) U40(16.691,-7.052) U42(17.289,-6.874) U44(18.173,-6.896) V1(0,-7.28) V3(0.904,-7.28) V14(5.515,-7.506) V16(6.328,-7.506) V18(7.141,-7.506) V20(7.954,-7.506) V22(8.766,-7.506) V24(9.579,-7.506) V26(10.392,-7.506) V28(11.205,-7.506) V30(12.018,-7.506) V32(12.83,-7.506) V43(17.721,-7.28) V45(18.625,-7.28) W2(0.472,-7.687) W44(18.152,-7.687) Y1(0,-8.093) Y3(0.904,-8.093) Y6(1.934,-8.03) Y7(2.531,-8.03) Y8(3.128,-8.03) Y10(3.724,-8.03) Y11(4.321,-8.03) Y12(4.918,-8.03) Y14(5.515,-8.167) Y16(6.328,-8.167) Y18(7.141,-8.167) Y20(7.954,-8.167) Y22(8.766,-8.167) Y24(9.579,-8.167) Y26(10.392,-8.167) Y28(11.205,-8.167) Y30(12.018,-8.167) Y32(12.83,-8.167) Y34(13.707,-8.03) Y35(14.304,-8.03) Y36(14.9,-8.03) Y38(15.497,-8.03) Y39(16.094,-8.03) Y40(16.691,-8.03) Y43(17.721,-8.093) Y45(18.625,-8.093)
