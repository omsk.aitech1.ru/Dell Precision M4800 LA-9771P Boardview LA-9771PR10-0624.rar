# Allegro board LA-9771PR10-0624.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DOCKED#: length 4.9
  TOP w0.102: v1(27.75,154.72) 27.77,154.75 R518.2 27.75,155.33 U9.45
  BOTTOM w0.102: Q326.1 26.73,153.96 27.12,154.35 v2(27.12,154.72) v1(27.75,154.72)
DP_A_MXM_AUX_Q: length 52.7
  IN2 w0.127: v1(244.38,67.37) 242.22,69.53 239.3,69.53 235.31,65.54 227.06,65.54 223.02,61.5 217.15,61.5 215.96,62.7 212.84,62.7 v1(211.31,61.17)
  BOTTOM w0.102: v1(211.31,61.17) 211.32,61.19 R2193.2 ; Q340.2 243.35,76.5 243.35,76.31 243.75,75.92 243.75,75.14 243.45,74.85 243.05,74.85 242.71,75.19 242.71,75.25 Q340.5 v2(242.5,72.83) 242.5,70.19 243.67,69.02 243.67,68.59 244.32,67.94 Q339.3 244.63,67.62 v1(244.38,67.37)
DP_CFG0: length 4.6
  TOP w0.102: U9.44 26.92,154.93 R64.2 R61.2 27.29,153.07 v2(26.79,152.58)
DP_CFG1: length 4.6
  TOP w0.102: v2(20.35,150.4) R73.2 R72.2 19.2,151.38 19.2,152.86 19.66,153.32 U9.29
DP_MB_P14: length 25.9
  TOP w0.102: JDP1.14 268.69,154.68 268.69,147.98 267.75,147.04 266.73,147.04 v2(266.15,146.45) 264.02,144.32 264.02,141.36 v1(263.28,140.63)
  BOTTOM w0.102: v1(263.28,140.63) 263.27,140.64 261.31,140.64 260.79,141.16 R801.2
DP_RP_CEXT: length 5.3
  BOTTOM w0.102: U22.2 238.58,90.5 238.16,90.92 236.42,90.92 C87.1 235.01,91.4 v2(234.88,91.53)
DP_RP_CFG0: length 3.1
  BOTTOM w0.102: U22.5 240.08,89.89 239.82,90.14 239.82,91.25 R77.1 239.67,91.4 R76.2
DP_RP_CFG1: length 6.6
  BOTTOM w0.102: U22.40 236.86,84.64 236.85,84.66 235.4,84.66 234.98,84.24 v2(234.98,82.6) 234.98,81.79 235.05,81.73 R79.1 R78.2
DP_RP_PEQ: length 4.2
  BOTTOM w0.102: R81.1 R80.2 238,91.4 238.48,90.92 239.36,90.92 239.53,90.76 239.53,89.93 239.58,89.88 U22.4
DP_RP_REXT: length 2.4
  BOTTOM w0.102: R75.2 241.99,91.02 v2(241.49,90.52) 241.08,90.11 U22.7
DPC_CA_DET: length 45.7
  TOP w0.102: Q110.2 83.11,131.21 82.83,131.49 81.68,131.49 C1174.1 80.06,131.86 79.74,132.18 D88.2 79.26,133.44 v2(76,130.18) 74.1,128.28 74.1,125.41 74.53,124.98 v1(74.46,124.98) ; v1(75.8,113.75) 77.36,112.2 U20.1 81.24,112.2 R492.2 82.43,113.24 82.43,114.31 82.13,114.62 80.96,114.62 80.49,114.15 U20.4
  IN2 w0.127: v1(74.46,124.98) 75.07,124.98 77.53,122.51 77.53,120.74 74.1,117.31 74.1,114.95 74.79,114.26 75.29,114.26 v1(75.8,113.75)
  BOTTOM w0.102: v1(74.46,124.98) 74.53,124.98 74.2,125.31 JDOCK1.6
DPC_CA_DET#: length 33.7
  TOP w0.102: Q110.6 Q110.5 83.11,132.6 83.32,132.38 83.97,132.38 84.77,133.18 R1532.2 84.31,133.77 84.31,133.96 83.94,134.33 83.7,134.33 v2(83.57,134.2) 83.05,133.68 81.83,133.68 81.15,132.99 v1(81.15,132.97) ; v1(75.17,113.7) 74.31,112.85 U20.13 ; U20.10 74.2,114.8 v1(74.53,115.12)
  IN1 w0.109: v1(74.53,115.12) 74.53,114.34 v1(75.17,113.7)
  IN2 w0.127: v1(74.53,115.12) 74.96,115.12 78.65,118.81 78.65,126.25 80.04,127.65 80.04,131.86 v1(81.15,132.97)
DPC_DOCK_AUX: length 2.2
  TOP w0.102: C387.1 81.04,112.85 U20.2
DPC_DOCK_AUX#: length 2.2
  TOP w0.102: U20.5 80.43,114.8 80.78,115.15 C388.1
DPC_DOCK_LANE_C_N0: length 1.2
  BOTTOM w0.102: R2173.2 74.59,135.36 74.59,135.48 C438.1
DPC_DOCK_LANE_C_N1: length 1.2
  BOTTOM w0.102: C440.1 76.62,135.48 76.62,135.36 R2175.2
DPC_DOCK_LANE_C_N2: length 1.2
  BOTTOM w0.102: C442.1 78.65,135.48 78.65,135.36 R2177.2
DPC_DOCK_LANE_C_N3: length 1.2
  BOTTOM w0.102: C444.1 80.69,135.48 80.69,135.36 R2179.2
DPC_DOCK_LANE_C_P0: length 1.2
  BOTTOM w0.102: R2172.2 74.32,135.36 74.32,135.48 C431.1
DPC_DOCK_LANE_C_P1: length 1.2
  BOTTOM w0.102: C439.1 76.35,135.48 76.35,135.36 R2174.2
DPC_DOCK_LANE_C_P2: length 1.2
  BOTTOM w0.102: C441.1 78.39,135.48 78.39,135.36 R2176.2
DPC_DOCK_LANE_C_P3: length 1.2
  BOTTOM w0.102: R2178.2 80.42,135.36 80.42,135.48 C443.1
DPC_DOCK_LANE_N0_R: length 8.4
  BOTTOM w0.102: JDOCK1.12 75.7,127.2 75.58,127.32 75.58,130.23 74.58,131.23 v3(74.58,131.56) 74.58,133.69 R2173.1
DPC_DOCK_LANE_N1_R: length 8.2
  BOTTOM w0.102: JDOCK1.18 77.2,127.21 77.08,127.33 77.08,132.23 76.62,132.7 v3(76.62,133.02) 76.62,133.69 R2175.1
DPC_DOCK_LANE_N2_R: length 8
  BOTTOM w0.102: R2177.1 78.65,133.69 78.65,132.28 78.58,132.22 v3(78.58,131.46) 78.58,127.35 78.7,127.24 JDOCK1.24
DPC_DOCK_LANE_N3_R: length 8.2
  BOTTOM w0.102: R2179.1 80.68,133.69 80.68,131.75 v3(80.34,131.41) 80.08,131.15 80.08,127.33 80.2,127.21 JDOCK1.30
DPC_DOCK_LANE_P0_R: length 8.4
  BOTTOM w0.102: R2172.1 74.32,133.7 v3(74.32,133.03) 74.32,131.12 75.32,130.12 75.32,127.29 75.2,127.17 JDOCK1.10
DPC_DOCK_LANE_P1_R: length 8.2
  BOTTOM w0.102: JDOCK1.16 76.7,127.2 76.82,127.32 v3(76.82,131.39) 76.82,132.12 76.35,132.59 76.35,133.7 R2174.1
DPC_DOCK_LANE_P2_R: length 8
  BOTTOM w0.102: R2176.1 78.38,133.7 v3(78.38,132.98) 78.38,132.39 78.32,132.33 78.32,127.34 78.2,127.22 JDOCK1.22
DPC_DOCK_LANE_P3_R: length 8.2
  BOTTOM w0.102: R2178.1 80.41,133.7 v3(80.41,133.06) 80.41,131.86 79.82,131.26 79.82,127.32 79.7,127.2 JDOCK1.28
DPC_DOCK_SW_AUX: length 42.1
  TOP w0.102: v1(79.89,123.76) 80.05,123.6 80.09,123.56 80.09,123.45 79.92,123.28 78.7,123.28 74.8,119.38 73.74,119.38 70.95,116.59 70.95,115.35 71.23,115.07 71.79,115.07 72.72,114.15 U20.11 74.28,114.15 75.14,115.01 75.67,115.01 76.35,114.32 77.66,114.32 78.48,113.5 U20.3 ; Q113.1 v1(85.89,130.19)
  BOTTOM w0.102: v1(79.89,123.76) 80.11,123.98 80.11,124.28 80.68,124.85 81.03,124.85 81.31,125.13 81.31,125.28 81.2,125.4 JDOCK1.34 81.2,127.2 81.33,127.33 81.33,130.51 81.74,130.92 83.8,130.92 85.02,129.7 86.27,129.7 87.03,130.46 87.03,131.53 86.75,131.81 86.6,131.81 v2(85.89,131.09) v1(85.89,130.19)
DPC_DOCK_SW_AUX#: length 41.9
  TOP w0.102: v1(87.16,133.54) 87.19,133.52 Q113.4 ; v1(80.53,123.76) 80.32,123.56 80.32,123.35 80.02,123.05 78.79,123.05 74.89,119.15 73.83,119.15 71.18,116.5 71.18,115.45 71.32,115.3 71.71,115.3 71.81,115.4 71.81,116.01 71.97,116.16 72.53,116.16 72.59,116.1 U20.8 74.27,116.1 75.13,115.24 75.76,115.24 76.45,114.55 77.62,114.55 78.51,115.45 U20.6
  BOTTOM w0.102: v1(80.53,123.76) 80.34,123.95 80.34,124.18 80.78,124.62 81.13,124.62 81.54,125.04 81.54,125.19 81.54,125.26 81.7,125.42 JDOCK1.36 81.7,127.21 81.56,127.35 81.56,130.41 81.84,130.69 83.7,130.69 84.92,129.47 86.37,129.47 87.26,130.36 87.26,131.63 86.84,132.05 86.83,132.06 86.83,133.21 v1(87.16,133.54)
DPC_GPU_HPD: length 45.5
  TOP w0.102: C696.1 R2160.1 82.63,128 v1(82.53,128.1)
  IN2 w0.127: v1(61.17,108.27) 64.07,111.16 68.13,111.16 70.24,113.27 75.95,113.27 78.14,115.45 78.14,117.94 78.9,118.7 78.9,124.88 82.13,128.1 v1(82.53,128.1)
  BOTTOM w0.102: v1(82.53,128.1) 82.7,127.94 JDOCK1.40 ; U14.2 61.63,103.76 D18.2 61.17,104.79 v2(61.17,107.54) v1(61.17,108.27)
DPC_GPU_HPD_GATE: length 13.5
  TOP w0.102: v1(63.41,99.6) 59.65,99.6 59.39,99.35 57.18,99.35 56.96,99.58 55.88,99.58 55.6,99.3 55.6,97.94 56,97.55 JMXM1.302
  BOTTOM w0.102: v4(64,100.18) 63.43,99.6 v1(63.41,99.6) 63.41,100.29 63.31,100.39 U14.4
DPD_CA_DET: length 81.5
  TOP w0.102: U9.42 24.86,153.14 25,152.99 25,152.08 24.24,151.32 24.05,151.32 R491.2 C1332.1 24.43,150.02 25.74,150.02 25.94,150.23 25.94,151.14 26.42,151.62 27.63,151.62 v2(28.23,151.02) 28.71,150.54 v1(28.71,150.51)
  IN3 w0.127: v1(28.71,150.51) 28.71,150.07 29.68,149.11 30.18,149.11 31.3,147.99 31.3,147.73 34.71,144.33 34.71,142.66 37.37,139.99 38.71,139.99 41.67,137.03 44.27,137.03 44.46,137.22 49.4,137.22 51.74,134.88 58.94,134.88 61.43,132.4 61.43,126.93 62.89,125.47 v1(62.89,118.43)
  BOTTOM w0.102: v1(62.89,118.43) 64.79,116.52 73.47,116.52 74.2,117.26 JDOCK1.5
DPD_CPU_LANE_N0: length 144.5
  TOP w0.102: v1(45.25,156.5) 45.45,156.3 45.45,156.04 45.3,155.89 45.3,155.15 45.16,155.02 44.96,155.02 C516.1 ; JCPU1.P29 v1(78.12,53.75)
  IN1 w0.089: v1(78.12,53.75) 78.12,54.02 77.99,54.15 77.73,54.15 77.52,54.36 77.52,55.69 75.5,57.7 75.5,57.92 75.28,58.14 74.9,58.14 74.51,58.52 74.51,58.89 74.26,59.15 73.89,59.15 73.54,59.5 73.54,59.87 73.26,60.14 72.04,60.14 72.03,60.13 72.02,60.13
  IN1 w0.117: 72.02,60.13 71.5,60.13 70.58,61.05 70.58,77.89 70.95,78.26 70.95,88.38 64.98,94.35 64.98,99.31 64.16,100.14 63.49,100.14 59.62,104.01 59.62,107.7 57.14,110.19 56.5,110.19 56.01,110.68 56.01,114.23 57.53,115.76 57.53,129.9 54.01,133.43 39.72,133.43 37.68,135.47 37.68,135.75 37.45,135.98 36.07,135.98 35.13,136.92 35.13,139.3 37.91,142.08 37.91,145.64 40.74,148.47 40.74,155.2 42.53,156.99 43.77,156.99 44.21,156.54 44.21,156.09 44.35,155.95 45.33,155.95 45.45,156.07 45.45,156.3 v1(45.25,156.5)
DPD_CPU_LANE_N0_C: length 5.7
  TOP w0.102: C516.2 43.37,155.02 42.75,155.02 42.39,154.66 40.64,154.66 39.68,153.71 39.3,153.71 39.21,153.8 U629.12
DPD_CPU_LANE_N1: length 138.1
  TOP w0.102: v1(79.12,52.75) JCPU1.N28 ; C518.1 42.15,155.79 42.2,155.73 42.88,155.73 43.06,155.92 43.06,156.17 42.99,156.25 v1(42.83,156.25)
  IN1 w0.089: 71.99,61.14 72.01,61.14 72.01,61.15 73.26,61.15 73.52,60.89 73.52,60.52 73.88,60.16 74.25,60.16 74.53,59.88 74.53,59.51 74.9,59.14 75.35,59.14 75.53,58.96 75.53,58.49 76.87,57.16 77.27,57.16 78.53,55.89 78.53,53.46 78.77,53.23 78.91,53.23 79,53.14 79,52.96 79.12,52.84 v1(79.12,52.75)
  IN1 w0.117: 71.99,61.14 71.74,61.14 71.32,61.57 71.32,77.4 71.71,77.8 71.71,88.65 65.72,94.65 65.72,99.62 63.15,102.18 62.49,102.18 60.89,103.79 60.89,107.38 60.5,107.77 60.5,109.44 58.63,111.31 58.63,111.94 58.27,112.31 58.27,130.21 54.31,134.17 40.03,134.17 38.59,135.62 38.59,135.88 36.9,137.57 36.31,137.57 35.87,138.01 35.87,138.97 38.82,141.92 38.82,143.14 41.48,145.8 41.48,154.26 43.04,155.82 43.04,156.04 v1(42.83,156.25)
DPD_CPU_LANE_N1_C: length 3.2
  TOP w0.102: U629.15 39.2,155 39.31,154.89 39.86,154.89 40.2,155.23 40.22,155.23 40.78,155.79 41.18,155.79 41.23,155.84 C518.2
DPD_CPU_LANE_N2: length 147
  TOP w0.102: JCPU1.P31 v1(76.12,53.75) ; v1(45.37,158.15) 45.58,157.95 45.58,157.8 45.47,157.69 44.96,157.69 C520.1
  IN1 w0.089: 71.94,58.16 71.96,58.16 71.97,58.16 72.84,58.16 73.82,57.18 74.22,57.18 75.51,55.89 75.51,54.35 75.72,54.13 75.98,54.13 76.12,54 v1(76.12,53.75)
  IN1 w0.117: 71.94,58.16 71.68,58.16 71.68,58.15 71.39,58.15 69.11,60.43 69.11,78.83 69.43,79.15 69.43,85.45 63.22,91.66 63.22,96 60.15,99.07 60.15,99.73 57.89,102 57.89,106.3 55.47,108.72 55.19,108.72 54.36,109.55 54.36,115.67 56.06,117.38 56.06,129.3 53.98,131.37 47.61,131.37 47.05,131.93 37.68,131.93 33.64,135.97 33.64,140.35 35.48,142.2 35.48,147.5 38.91,150.93 38.91,157.03 41.54,159.66 43.69,159.66 44.49,158.85 44.49,158.17 44.97,157.69 45.39,157.69 45.57,157.87 45.57,157.96 v1(45.37,158.15)
DPD_CPU_LANE_N2_C: length 6
  TOP w0.102: C520.2 43.39,157.71 43.18,157.71 42.6,157.14 41.08,157.14 v3(40.17,156.23) 39.66,155.72 39.3,155.72 39.22,155.8 U629.17
DPD_CPU_LANE_N3: length 142.5
  TOP w0.102: JCPU1.N30 v1(77.12,52.75) ; v1(42.83,158.91) 43.04,158.71 43.04,158.56 42.8,158.32 42.48,158.32 C522.1
  IN1 w0.089: 72.02,59.13 72.03,59.13 72.04,59.15 72.11,59.15 72.12,59.16 73.27,59.16 73.5,58.93 73.5,58.52 73.86,58.16 74.25,58.16 74.51,57.89 74.51,57.53 74.88,57.16 75.24,57.16 76.5,55.9 76.5,53.38 76.75,53.13 77.03,53.13 77.12,53.05 v1(77.12,52.75)
  IN1 w0.117: 72.02,59.13 71.45,59.13 69.84,60.74 69.84,78.31 70.21,78.67 70.21,85.71 63.96,91.96 63.96,98.11 59.39,102.68 59.39,102.91 58.78,103.51 58.78,107.02 56.98,108.82 56.73,108.82 55.18,110.36 55.18,114.9 56.8,116.52 56.8,129.6 53.73,132.67 37.99,132.67 34.39,136.26 34.39,140.06 36.88,142.55 36.88,145.9 40.01,149.03 40.01,155.58 43.02,158.6 43.02,158.73 v1(42.83,158.91)
DPD_CPU_LANE_N3_C: length 3.6
  TOP w0.102: C522.2 40.9,158.33 40.44,158.33 40.25,158.14 40.24,158.14 39.86,157.76 39.86,157.75 39.62,157.5 39.62,157 39.52,156.89 39.33,156.89 39.23,157 U629.20
DPD_CPU_LANE_P0: length 144.5
  TOP w0.102: v1(45.88,156.5) 45.67,156.28 45.67,155.95 45.51,155.8 45.51,155.06 45.25,154.8 44.96,154.8 C515.1 ; JCPU1.R29 78.12,54.75 v1(78.12,54.75)
  IN1 w0.089: 72.02,60.37 72.04,60.35 73.35,60.35 73.74,59.95 73.74,59.59 73.98,59.36 74.34,59.36 74.72,58.98 74.72,58.61 74.99,58.35 75.37,58.35 75.71,58 75.71,57.79 77.73,55.77 77.73,55.77 77.71,55.75 77.71,54.44 77.81,54.34 77.99,54.34 78.12,54.48 78.12,54.75 v1(78.12,54.75)
  IN1 w0.117: v1(45.88,156.5) 45.69,156.3 45.69,155.97 45.42,155.71 44.25,155.71 43.98,155.99 43.98,156.45 43.67,156.75 42.63,156.75 40.98,155.1 40.98,148.38 38.14,145.54 38.14,141.98 35.37,139.2 35.37,137.02 36.17,136.21 37.55,136.21 37.91,135.85 37.91,135.57 39.81,133.67 54.11,133.67 57.77,130 57.77,115.66 56.24,114.13 56.24,110.78 56.6,110.42 57.23,110.42 59.86,107.8 59.86,104.1 63.59,100.37 64.25,100.37 65.22,99.41 65.22,94.44 71.19,88.48 71.19,78.16 70.82,77.79 70.82,61.15 71.6,60.37 72.02,60.37
DPD_CPU_LANE_P0_C: length 5.7
  TOP w0.102: C515.2 43.37,154.8 42.84,154.8 42.48,154.44 40.72,154.44 39.77,153.49 39.34,153.49 39.25,153.4 U629.11
DPD_CPU_LANE_P1: length 137.6
  TOP w0.102: v1(43.47,156.25) 43.28,156.06 43.28,155.83 42.97,155.52 42.43,155.52 C517.1 ; v1(79.12,53.75) JCPU1.P28
  IN1 w0.089: 71.99,61.38 72,61.38 72.02,61.36 72.08,61.36 72.09,61.35 73.35,61.35 73.73,60.97 73.73,60.6 73.97,60.37 74.33,60.37 74.73,59.97 74.73,59.6 74.99,59.35 75.44,59.35 75.74,59.04 75.74,58.58 76.95,57.36 77.35,57.36 78.74,55.98 78.74,53.55 78.85,53.44 79.01,53.44 79.12,53.55 v1(79.12,53.75)
  IN1 w0.117: 71.99,61.38 71.84,61.38 71.55,61.66 71.55,77.3 71.95,77.7 71.95,88.75 65.95,94.75 65.95,99.72 63.25,102.42 62.59,102.42 61.13,103.88 61.13,107.47 60.74,107.86 60.74,109.54 58.87,111.41 58.87,112.04 58.5,112.41 58.5,130.31 54.41,134.41 40.13,134.41 38.83,135.72 38.83,135.97 37,137.81 36.41,137.81 36.1,138.11 36.1,138.87 39.06,141.83 39.06,143.04 41.72,145.7 41.72,154.16 43.27,155.72 43.27,156.05 v1(43.47,156.25)
DPD_CPU_LANE_P1_C: length 3.2
  TOP w0.102: C517.2 41.23,155.51 41.17,155.57 40.87,155.57 v3(40.16,154.87) 39.97,154.67 39.3,154.67 39.23,154.6 U629.14
DPD_CPU_LANE_P2: length 147
  TOP w0.102: C519.1 44.96,157.47 45.56,157.47 45.79,157.71 45.79,157.94 v1(46.01,158.15) ; JCPU1.R31 v1(76.12,54.75)
  IN1 w0.089: 71.94,58.39 71.97,58.39 71.99,58.37 72.93,58.37 73.9,57.39 74.3,57.39 74.53,57.16 74.53,57.16 75.71,55.98 75.71,54.43 75.8,54.34 75.96,54.34 76.12,54.51 v1(76.12,54.75)
  IN1 w0.117: v1(46.01,158.15) 45.8,157.95 45.8,157.77 45.49,157.46 44.87,157.46 44.26,158.07 44.26,158.76 43.59,159.42 41.64,159.42 39.15,156.93 39.15,150.84 35.72,147.41 35.72,142.1 33.87,140.25 33.87,136.07 37.78,132.17 47.15,132.17 47.71,131.61 54.08,131.61 56.3,129.39 56.3,117.28 54.59,115.58 54.59,109.65 55.29,108.95 55.57,108.95 58.12,106.4 58.12,102.09 60.38,99.83 60.38,99.17 63.46,96.1 63.46,91.76 69.67,85.54 69.67,79.06 69.35,78.73 69.35,60.53 71.49,58.39 71.59,58.39 71.59,58.39 71.94,58.39
DPD_CPU_LANE_P2_C: length 6
  TOP w0.102: U629.16 39.25,155.4 39.35,155.5 39.75,155.5 40.1,155.85 40.12,155.85 40.55,156.28 40.55,156.3 41.17,156.92 42.69,156.92 43.26,157.49 43.35,157.49 C519.2
DPD_CPU_LANE_P3: length 142.4
  TOP w0.102: C521.1 42.48,158.11 42.89,158.11 43.25,158.47 43.25,158.7 v1(43.47,158.91) ; JCPU1.P30 v1(77.12,53.75)
  IN1 w0.089: v1(77.12,53.75) 77.12,53.45 77.01,53.34 76.84,53.34 76.71,53.47 76.71,55.99 75.32,57.37 74.97,57.37 74.72,57.61 74.72,57.98 74.33,58.37 73.95,58.37 73.71,58.61 73.71,59.01 73.35,59.37 72.02,59.37
  IN1 w0.117: 72.02,59.37 71.55,59.37 70.08,60.84 70.08,78.21 70.44,78.57 70.44,85.81 64.19,92.06 64.19,98.21 59.62,102.78 59.62,103.01 59.02,103.61 59.02,107.11 57.08,109.05 56.83,109.05 55.42,110.46 55.42,114.8 57.03,116.42 57.03,129.7 53.83,132.9 38.08,132.9 34.63,136.36 34.63,139.96 37.12,142.45 37.12,145.81 40.24,148.93 40.24,155.48 43.26,158.5 43.26,158.7 v1(43.47,158.91)
DPD_CPU_LANE_P3_C: length 3.6
  TOP w0.102: U629.19 39.25,156.6 39.33,156.68 39.61,156.68 39.84,156.91 39.84,157.41 v3(40.21,157.79) 40.53,158.11 40.89,158.11 C521.2
DPD_DOCK_AUX: length 98
  TOP w0.102: v1(30.16,162.09) 29.97,162.28 Q337.1 29.51,162.23 28.58,161.3 27.54,161.3 27.16,160.92 27.16,159.9 27.06,159.81 26.67,159.41 26.38,159.41 26.31,159.33 U9.55
  IN3 w0.127: v1(30.16,162.09) 30.16,161.25 29.78,160.87 29.35,160.87 29.22,161 29.22,162.36 29.83,162.98 30.76,162.98 31.71,162.03 31.71,157.34 31.66,157.29 31.66,156.48 30.46,155.29 30.46,150.98 32.83,148.62 32.83,147.48 35.21,145.1 35.21,143.04 37.12,141.13 38.52,141.13 39.33,140.32 39.33,140.09 41.88,137.54 44.06,137.54 44.25,137.73 49.65,137.73 51.99,135.39 53.74,135.39 54.2,135.85 56.63,135.85 57.08,135.39 59.15,135.39 61.93,132.61 61.93,127.92 62.39,127.47 62.71,127.47 v1(62.89,127.29)
  BOTTOM w0.102: v1(30.16,162.09) v2(30.74,162.09) ; JDOCK1.33 81.2,119.23 81.29,119.31 81.39,119.31 81.47,119.4 81.47,119.61 81.26,119.82 80.86,119.82 80.55,119.52 79.41,119.52 77.43,121.5 77.43,122.8 76.83,123.4 73.85,123.4 72.3,124.96 72.3,126.51 71.27,127.53 62.99,127.53 62.89,127.43 v1(62.89,127.29)
DPD_DOCK_AUX#: length 97.4
  TOP w0.102: U9.54 26.35,158.94 26.42,159.01 26.42,159.1 26.5,159.18 26.76,159.18 26.93,159.35 27.07,159.35 27.13,159.29 27.26,159.29 27.35,159.39 27.35,159.52 27.29,159.58 27.29,159.71 27.39,159.81 27.39,160.02 27.49,160.12 27.49,160.43 27.39,160.53 27.39,160.82 27.64,161.07 28.48,161.07 28.56,161 28.56,160.87 28.21,160.52 Q337.4 28.21,160.08 28.28,160.02 28.28,159.77 v1(28.21,159.7)
  IN3 w0.127: v1(62.89,127.93) 62.68,127.72 62.49,127.72 62.19,128.03 62.19,132.71 59.25,135.65 57.19,135.65 56.73,136.1 54.09,136.1 53.64,135.65 52.09,135.65 49.75,137.98 44.14,137.98 43.95,137.79 41.99,137.79 39.58,140.2 39.58,140.43 38.62,141.39 37.22,141.39 35.47,143.14 35.47,145.2 33.08,147.59 33.08,148.73 30.72,151.09 30.72,155.18 31.91,156.37 31.91,157.19 31.96,157.24 31.96,162.14 30.87,163.23 29.73,163.23 28.96,162.47 28.96,160.71 v1(28.21,159.7)
  BOTTOM w0.102: v1(62.89,127.93) 63.05,127.76 71.37,127.76 72.53,126.6 72.53,125.05 73.95,123.63 76.92,123.63 77.66,122.9 77.66,121.59 79.5,119.75 80.46,119.75 80.76,120.05 81.36,120.05 81.7,119.71 JDOCK1.35
DPD_DOCK_AUX_Q: length 26.3
  TOP w0.102: v1(28.89,159.7) 28.86,159.73 Q337.5 29.43,160.95 30.97,160.95 31.4,160.51 31.4,160.49 ; v1(28.13,150.51) 28.13,150.53 27.57,151.09 27.09,151.09 26.83,150.84 26.83,149.95 26.26,149.37 Q336.3 25.7,149.11 R2153.2 ; v1(26.63,161.63) 26.78,161.78 28.38,161.78 28.86,162.27 Q337.2 ; Q335.5 31.4,160.49 ; 31.4,160.49 31.58,160.67 31.58,161.91 31.4,162.09 Q335.2
  BOTTOM w0.102: v1(26.63,161.63) 26.96,161.63 v2(27.67,160.92) v1(28.89,159.7) 28.28,159.09 28.28,152.21 28.13,152.06 v1(28.13,150.51)
DPD_DOCK_LANE_N0: length 1.3
  BOTTOM w0.102: C367.1 75.04,111.3 74.75,111.59 74.75,111.76 R2165.1
DPD_DOCK_LANE_N0_R: length 5.8
  BOTTOM w0.102: JDOCK1.11 75.7,117.38 75.56,117.24 75.56,116.64 75.15,116.24 75.15,114.37 74.76,113.98 74.76,113.47 R2165.2
DPD_DOCK_LANE_N1: length 1.3
  BOTTOM w0.102: R2167.1 76.79,111.76 76.79,111.59 77.07,111.3 C369.1
DPD_DOCK_LANE_N1_R: length 5.6
  BOTTOM w0.102: JDOCK1.17 77.2,117.41 77.06,117.27 77.06,116.44 76.79,116.18 76.79,113.47 R2167.2
DPD_DOCK_LANE_N2: length 1.2
  BOTTOM w0.102: R2169.1 78.82,111.76 78.82,111.64 79.16,111.3 C425.1
DPD_DOCK_LANE_N2_R: length 5.6
  BOTTOM w0.102: R2169.2 78.82,113.47 78.82,113.79 78.55,114.07 78.55,117.23 78.7,117.39 JDOCK1.23
DPD_DOCK_LANE_N3: length 1.2
  BOTTOM w0.102: C427.1 81.16,111.3 80.85,111.61 80.85,111.76 R2171.1
DPD_DOCK_LANE_N3_R: length 5.8
  BOTTOM w0.102: R2171.2 80.86,113.47 80.86,115.29 80.06,116.09 80.06,117.25 80.2,117.39 JDOCK1.29
DPD_DOCK_LANE_P0: length 1.2
  BOTTOM w0.102: R2164.1 74.54,111.76 74.54,111.61 74.23,111.3 C366.1
DPD_DOCK_LANE_P0_R: length 5.8
  BOTTOM w0.102: R2164.2 74.54,113.49 74.54,114.07 74.94,114.46 74.94,116.33 75.34,116.73 75.34,117.23 75.2,117.38 JDOCK1.9
DPD_DOCK_LANE_P1: length 1.3
  BOTTOM w0.102: C368.1 76.28,111.3 76.57,111.59 76.57,111.76 R2166.1
DPD_DOCK_LANE_P1_R: length 5.6
  BOTTOM w0.102: R2166.2 76.58,113.49 76.58,116.27 76.84,116.53 76.84,117.26 76.7,117.4 JDOCK1.15
DPD_DOCK_LANE_P2: length 1.2
  BOTTOM w0.102: C424.1 78.29,111.3 78.6,111.61 78.6,111.76 R2168.1
DPD_DOCK_LANE_P2_R: length 5.6
  BOTTOM w0.102: R2168.2 78.61,113.49 78.61,113.7 78.33,113.98 78.33,117.27 78.2,117.4 JDOCK1.21
DPD_DOCK_LANE_P3: length 1.3
  BOTTOM w0.102: R2170.1 80.63,111.76 80.63,111.6 80.34,111.3 C426.1
DPD_DOCK_LANE_P3_R: length 5.8
  BOTTOM w0.102: R2170.2 80.64,113.49 80.64,115.2 79.84,116 79.84,117.26 79.7,117.4 JDOCK1.27
DPD_GPU_HPD: length 112.8
  TOP w0.102: v1(74.18,154.09) 71.13,157.14 57.83,157.14 57.22,156.53 49.93,156.53 49.42,156.02 48.73,156.02 48.27,155.56 48.27,154.39 45.39,151.51 45.39,149.8 46.01,149.18 46.01,148.06 45.68,147.74 45.39,147.74 44.58,146.92 42.36,146.92 38.73,143.29 37.68,143.29 37.16,142.77 35.63,142.77 33.73,144.68 v2(30.09,144.68) 29,145.77 27.29,145.77 25.83,147.23 24.36,147.23 20.74,150.85 20.74,151.88 21.01,152.16 21.01,152.66 20.86,152.82 U9.32 ; C695.1 R1000.1 82.83,119.01 v1(82.2,119.63)
  IN1 w0.109: v1(82.2,119.63) 82.2,121.85 82.27,121.92 82.27,124.65 80.2,126.72 80.2,129.98 77.76,132.42 77.76,140.96 78.67,141.87 78.67,143.55 77.55,144.66 77.55,150.18 76.7,151.03 76.7,151.59 74.2,154.09 v1(74.18,154.09)
  BOTTOM w0.102: v1(82.2,119.63) 82.7,119.14 JDOCK1.39
DPD_GPU_LANE_N0: length 84.4
  TOP w0.102: U9.39 23.66,153.15 23.75,153.06 23.75,152.45 v1(23.55,152.26)
  IN3 w0.127: v1(64.3,109.87) 64.15,110.01 63.63,110.01 62.16,111.48 62.16,111.98 60.41,113.72 60.41,132.34 58.62,134.13 50.86,134.13 48.63,136.36 44.76,136.36 44.4,135.99 40.17,135.99 37.35,138.82 36.74,138.82 33.33,142.23 33.33,142.89 31.78,144.44 31.78,145.48 30.18,147.08 29.53,147.08 28.74,147.86 28.74,148.32 26.53,150.53 25.99,150.53 25.45,151.07 24.29,151.07 23.66,151.7 23.66,152.15 v1(23.55,152.26)
  BOTTOM w0.102: v1(64.3,109.87) 64.49,110.06 65.12,110.06 65.62,109.56 74.48,109.56 74.9,109.98 74.9,110.13 C367.2
DPD_GPU_LANE_N1: length 87.7
  TOP w0.102: v1(22.36,152.26) 22.52,152.42 22.52,153.06 22.46,153.13 U9.36
  IN3 w0.127: v1(64.3,108.62) 64.14,108.77 63.12,108.77 60.4,111.49 60.4,112 59.06,113.35 59.06,130.52 56.2,133.37 50.46,133.37 48.46,135.37 45.04,135.37 44.8,135.14 39.73,135.14 39.73,135.13 38.46,135.13 32.53,141.06 32.53,142.55 30.87,144.21 30.87,145.12 29.67,146.32 28.96,146.32 25.28,150 24.11,150 22.46,151.65 22.46,152.16 v1(22.36,152.26)
  BOTTOM w0.102: v1(64.3,108.62) 64.49,108.81 72.16,108.81 72.21,108.86 76.25,108.86 76.94,109.55 76.94,110.14 C369.2
DPD_GPU_LANE_N2: length 93.1
  TOP w0.102: U9.33 21.26,153.14 21.35,153.05 21.35,151.91 v1(21.17,151.72)
  IN3 w0.127: v1(21.17,151.72) 21.26,151.63 21.26,151 23.02,149.24 24.9,149.24 29.73,144.4 29.73,143.39 31.76,141.36 31.76,140.16 35.38,136.54 35.38,135.25 36.44,134.2 40.09,134.2 40.27,134.38 44.66,134.38 44.84,134.19 48.57,134.19 50.15,132.61 55.89,132.61 58.3,130.2 58.3,112.28 58.61,111.98 58.61,111.48 61.58,108.51 62.06,108.51 62.57,108.01 62.76,107.82 62.87,107.7 63.67,107.7 v1(63.81,107.55)
  BOTTOM w0.102: v1(63.81,107.55) 64.03,107.77 76.43,107.77 78.27,109.61 78.7,109.61 78.95,109.86 78.95,110.11 C425.2
DPD_GPU_LANE_N3: length 99.4
  TOP w0.102: v1(19.97,152.26) 20.15,152.43 20.15,153.05 20.06,153.14 U9.30
  IN3 w0.127: v1(19.97,152.26) 20.12,152.11 20.12,150.71 22.91,147.92 23.63,147.92 29.38,142.17 29.38,140.64 30.36,139.66 30.73,139.66 34.63,135.75 34.63,134.92 36.27,133.28 41.3,133.28 41.31,133.28 48.4,133.28 49.83,131.86 55.58,131.86 57.54,129.89 57.54,115.01 56.02,113.49 56.02,110.65 56.45,110.23 58.24,110.23 61.14,107.32 61.76,107.32 62.73,106.36 63.64,106.36 v1(63.79,106.21)
  BOTTOM w0.102: v1(63.79,106.21) 63.97,106.39 65.3,106.39 65.97,107.06 76.75,107.06 78.46,108.76 78.96,108.76 79.65,109.45 80.54,109.45 81,109.91 81,110.14 C427.2
DPD_GPU_LANE_P0: length 84.4
  TOP w0.102: U9.40 24.06,153.16 23.97,153.07 23.97,152.33 24.04,152.26 v1(24.19,152.26)
  IN3 w0.127: v1(24.19,152.26) 24.14,152.26 23.91,152.03 23.91,151.8 24.4,151.32 25.56,151.32 26.1,150.78 26.63,150.78 28.99,148.42 28.99,147.97 29.63,147.33 30.29,147.33 32.03,145.58 32.03,144.54 33.58,142.99 33.58,142.33 36.84,139.07 37.45,139.07 40.28,136.24 44.29,136.24 44.66,136.61 48.73,136.61 50.96,134.38 58.73,134.38 60.66,132.44 60.66,113.83 62.41,112.08 62.41,111.59 63.74,110.26 64.16,110.26 64.3,110.4 v1(64.3,110.5)
  BOTTOM w0.102: C366.2 74.6,110.39 74.68,110.3 74.68,110.07 74.39,109.78 65.71,109.78 65.21,110.27 64.37,110.27 64.3,110.35 v1(64.3,110.5)
DPD_GPU_LANE_P1: length 87.7
  TOP w0.102: v1(22.94,152.26) 22.89,152.26 22.74,152.41 22.74,153.02 22.86,153.14 U9.37
  IN3 w0.127: v1(22.94,152.26) 22.71,152.02 22.71,151.75 24.21,150.25 25.38,150.25 29.07,146.57 29.77,146.57 31.12,145.22 31.12,144.31 32.77,142.65 32.77,141.16 38.56,135.38 39.62,135.38 39.63,135.39 44.7,135.39 44.93,135.62 48.56,135.62 50.56,133.62 56.31,133.62 59.3,130.62 59.3,113.45 60.65,112.1 60.65,111.59 63.22,109.02 64.16,109.02 64.3,109.15 v1(64.3,109.28)
  BOTTOM w0.102: C368.2 76.63,110.39 76.72,110.29 76.72,109.64 76.16,109.08 72.12,109.08 72.07,109.03 64.4,109.03 64.3,109.13 v1(64.3,109.28)
DPD_GPU_LANE_P2: length 93.1
  TOP w0.102: v1(21.75,151.72) 21.65,151.72 21.57,151.81 21.57,153.04 21.66,153.13 U9.34
  IN3 w0.127: v1(21.75,151.72) 21.51,151.49 21.51,151.1 23.13,149.48 25,149.48 29.98,144.51 29.98,143.5 32.01,141.46 32.01,140.26 35.63,136.64 35.63,135.35 36.54,134.45 39.99,134.45 40.16,134.63 44.76,134.63 44.95,134.44 48.67,134.44 50.25,132.86 55.99,132.86 58.55,130.31 58.55,112.39 58.86,112.08 58.86,111.59 61.68,108.76 62.16,108.76 62.81,108.11 62.93,107.99 62.98,107.95 63.65,107.95 63.81,108.11 v1(63.81,108.27)
  BOTTOM w0.102: v1(63.81,108.27) 63.81,108.06 63.89,107.99 76.34,107.99 78.18,109.83 78.61,109.83 78.73,109.95 78.73,110.27 78.61,110.39 C424.2
DPD_GPU_LANE_P3: length 99.4
  TOP w0.102: U9.31 20.46,153.13 20.37,153.03 20.37,152.45 v1(20.56,152.26)
  IN3 w0.127: v1(63.79,106.92) 63.79,106.74 63.65,106.6 62.83,106.6 61.87,107.57 61.25,107.57 58.34,110.48 56.55,110.48 56.27,110.75 56.27,113.39 57.79,114.91 57.79,129.99 55.68,132.11 49.93,132.11 48.51,133.53 41.21,133.53 41.2,133.53 36.37,133.53 34.88,135.02 34.88,135.86 30.83,139.9 30.47,139.9 29.63,140.75 29.63,142.28 23.73,148.17 23.02,148.17 20.37,150.82 20.37,152.07 v1(20.56,152.26)
  BOTTOM w0.102: v1(63.79,106.92) 63.79,106.72 63.9,106.6 65.21,106.6 65.89,107.27 76.67,107.27 78.37,108.98 78.87,108.98 79.56,109.66 80.45,109.66 80.79,110 80.79,110.3 80.7,110.39 C426.2
DPD_PCH_HPD: length 114.7
  TOP w0.102: v1(27.77,140.75) v2(28.25,141.23) ; v1(27.15,105.76) 27.27,105.88 UH1.H39 ; U629.13 v1(39.58,154.2)
  IN3 w0.127: v1(27.15,105.76) 27.15,105.87 28.86,107.58 35.77,107.58 36.15,107.2 36.15,103.64 36.51,103.29 37.83,103.29 38.16,103.62 39.26,103.62 40.38,104.73 45.97,104.73 49,107.76 52.54,107.76 53.4,108.61 53.4,114.95 56.49,118.03 56.49,129.51 55.15,130.84 48.34,130.84 47.29,131.89 42.81,131.89 42.53,131.61 33.85,131.61 32.42,133.04 32.42,135.58 30.82,137.18 30.02,137.18 27.77,139.43 v1(27.77,140.75)
  IN4 w0.109: v1(39.58,154.2) 39.17,153.79 39.17,148.22 38.29,147.33 33.32,147.33 29.88,143.89 29.88,142.83 28.29,141.23 v2(28.25,141.23) v1(27.77,140.75)
DSCHRG_MOSFET_GC: length 4.5
  BOTTOM w0.102: v2(158.66,121.83) 158.4,122.08 157.31,122.08 PR1004.2
  BOTTOM w0.254: PU1001.29 155.54,121.78 155.75,121.58 PR1004.2
DSWODVREN: length 7.4
  TOP w0.102: UH1.C8 25.53,92.97 25.39,92.83 25.05,92.83 24.91,92.69 24.3,92.69 23.82,92.21 22.85,92.21 21.94,91.3 v2(21.18,91.3) 20.8,91.3 20.37,91.73 RH67.1 RH81.2
DYN_TUR_CURRNT_SET#: length 206.5
  IN3 w0.127: v1(225.31,60.82) 224.57,60.08 219.05,60.08 216.87,57.91 216.87,54.44 216.28,53.85 v1(215.41,53.85) ; v1(200.26,90.99) 200.24,90.99 194.47,96.76 192.61,96.76 191.97,97.39 184.95,97.39 184.21,96.66 181.03,96.66 175.42,102.27 172.42,102.27 159.58,115.11 159.58,116.93 157.81,118.71 157.81,121.38 152.72,126.47 151.68,126.47 151.33,126.82 151.33,134.88 149.55,136.66 149.18,136.66 149.05,136.79 144.79,136.79 136.06,145.51 133.46,145.51 131.97,144.03 121.7,144.03 120.53,145.2 113.85,145.2 113.58,144.93 108.98,144.93 108.21,145.69 106.99,145.69 106.71,145.97 100.96,145.97 97.61,149.32 97.37,149.32 95.77,150.93 95.77,151.15 94.91,152 v1(94.67,152)
  BOTTOM w0.102: v1(200.26,90.99) 200.87,90.99 201.15,90.71 201.15,75.16 201.66,74.65 201.66,73.09 204.1,70.65 204.1,63.94 214.19,53.85 v1(215.41,53.85) ; U51.A35 96.42,153.77 R1980.2 95.84,153.66 v2(95.16,152.97) 95.16,152.49 v1(94.67,152)
  BOTTOM w0.254: PQ707.5 226.81,60.98 226.58,60.75 225.37,60.75 v1(225.31,60.82)
DYN_TURB_SYS_PWR_ALRT#: length 2.4
  BOTTOM w0.102: U46.A46 220.67,88.1 221.23,88.66 T139.1
EC5048_TX: length 167.3
  TOP w0.102: JDEG2.2 169.61,114.24 170.8,113.04 170.8,113.03 R849.2 171.19,112.22 171.19,111.52 v2(172.18,110.53) 172.18,109.47 v1(174.95,106.7)
  IN1 w0.109: v1(221.42,77.35) 220.98,76.91 213.14,76.91 212.4,77.64 210.71,77.64 209.8,78.56 203.02,78.56 198.03,83.55 185.66,83.55 181.16,88.05 181.16,92.05 174.15,99.06 v1(172.36,99.06)
  IN3 w0.127: v1(172.36,99.06) 170.01,99.06 159.85,109.22 150.49,109.22 144.81,114.89 130.94,114.89 129.73,116.1 123.53,116.1 119.45,120.18 119.45,124.65 114.12,129.98 112.3,129.98 109.68,132.6 v1(106.55,132.6)
  BOTTOM w0.102: v1(174.95,106.7) 174.95,99.78 174.23,99.06 v1(172.36,99.06) ; v1(221.42,77.35) 221.42,77.35 U46.B2 ; JMINI3.17 108.15,133.36 107.39,132.6 v1(106.55,132.6)
EC_32KHZ_ECE5048: length 154.7
  IN3 w0.127: v1(208.03,89.06) 205.9,91.2 201.71,91.2 194.73,98.18 180.64,98.18 169.59,109.23 169.59,117.07 167.4,119.26 163.4,119.26 158.51,124.15 158.51,125.18 155.67,128.02 155.67,137.18 154.49,138.36 154.49,139.63 150.26,143.85 150.26,145.3 138.24,157.33 131.87,157.33 129.96,159.24 127.03,159.24 126.7,159.57 125.18,159.57 123.68,161.07 118.94,161.07 117.83,159.97 111.9,159.97 110.77,161.1 105.42,161.1 v1(104.73,160.41)
  BOTTOM w0.102: v1(104.73,160.41) 104.75,160.43 U51.B62 ; U46.B35 213.92,86.3 212.49,87.73 v2(211.7,87.73) 209.37,87.73 v1(208.03,89.06)
EC_WAKE#: length 165.5
  TOP w0.089: UH1.R11 30.5,94.1 v1(30.24,93.85)
  TOP w0.102: v1(97.82,144.54) 98.15,144.21 102.12,144.21 103.14,145.22 105.29,145.22 106.72,143.8 110.73,143.8 113.14,146.21 113.14,150.72 v1(115.07,152.65) ; v1(104.83,153.27) v2(104.83,153.88)
  IN2 w0.127: v1(30.24,93.85) 30.67,94.27 30.67,94.57 31.38,95.29 32.7,95.29 33.23,95.81 33.23,97.36 34.37,98.51 36.58,98.51 37.4,99.32 43.06,99.32 43.89,100.15 48.15,100.15 50.66,102.66 53.09,102.66 54.45,104.02 60.64,104.02 62.31,102.35 63.94,102.35 66.74,105.15 66.74,106.89 67.88,108.02 67.88,110.55 70.19,112.86 81.31,112.86 82.5,114.06 89.36,114.06 90.53,115.23 90.53,117.83 91.68,118.97 91.68,125.46 93.07,126.86 93.07,132.08 93.66,132.66 93.66,136.09 98.21,140.64 98.21,144.16 v1(97.82,144.54)
  IN4 w0.109: v1(104.83,153.27) 104.83,153.93 105.98,155.08 107.82,155.08 109.34,156.6 110.16,156.6 v1(110.5,156.26)
  BOTTOM w0.102: v1(110.5,156.26) 110.5,156.83 111.19,157.53 112.09,157.53 112.56,157.06 113.15,157.06 114.12,158.02 R563.1 115.21,157.58 115.21,156.67 115.53,156.35 115.53,154.16 115.07,153.71 v1(115.07,152.65) ; U51.B23 105.25,152.26 105.37,152.39 105.37,152.87 104.96,153.27 v1(104.83,153.27) ; RH216.1 26.25,85.41 26.25,86.19 26.48,86.43 27.25,86.43 28.99,88.17 28.99,89.37 29.88,90.26 29.88,91.63 29.74,91.77 29.74,93.27 30.24,93.77 v1(30.24,93.85)
EDID_SELECT#: length 197.3
  TOP w0.102: v1(86.17,160.79) v2(86.86,160.79)
  IN3 w0.127: v1(86.17,160.79) 86.17,160.89 86.62,161.35 110.88,161.35 112.01,160.22 117.73,160.22 118.83,161.33 123.86,161.33 125.31,159.88 126.76,159.88 127.14,159.5 130.08,159.5 132,157.58 138.34,157.58 147.51,148.41 148.55,148.41 152.7,144.27 152.7,141.91 154.75,139.87 154.75,138.46 155.93,137.28 155.93,128.12 158.77,125.28 158.77,124.25 162.37,120.65 168.44,120.65 172.47,116.62 172.47,107.06 180.85,98.69 195.94,98.69 202.7,91.93 206.33,91.93 209.13,89.14 215.71,89.14 216.07,88.78 221.27,88.78 221.7,88.35 221.7,86.7 223.6,84.8 224.65,84.8 225,85.15 226.11,85.15 226.42,84.84 226.42,83.78 225.38,82.74 224.57,82.74 222.61,80.77 v1(221.83,80.77)
  BOTTOM w0.102: U46.B61 v1(221.83,80.77) ; U19.1 86.08,160.7 v1(86.17,160.79)
EDP_COMP: length 3.3
  TOP w0.457: JCPU1.E24 83.56,44.28 v1(83.07,44.77)
  BOTTOM w0.508: v1(83.07,44.77) v2(83.07,45.93) 83.07,46.67 82.71,47.03 RC1.2
EDP_CPU_AUX: length 111.1
  TOP w0.102: v1(80.12,52.75) JCPU1.N27
  IN1 w0.089: 83.75,53.71 83.75,53.69 83.74,53.68 83.74,53.41 83.49,53.16 79.89,53.16 79.72,52.99 79.72,52.44 80.03,52.13 80.19,52.13 80.27,52.22 80.27,52.6 v1(80.12,52.75)
  IN1 w0.117: 83.75,53.71 83.75,76.09 82.59,77.24 82.59,98.11 82.91,98.44 82.91,107.48 82.62,107.77 82.62,111.15 82.13,111.64 82.13,113.1 83.91,114.87 83.91,126.57 83.22,127.26 83.22,127.74 84.82,129.34 84.82,139.05 81.36,142.52 81.36,145.21 83.04,146.9 83.04,148.7 84.18,149.85 84.41,149.85 v1(84.62,149.64)
  BOTTOM w0.102: v1(84.62,149.64) 84.4,149.86 84.16,149.86 83.98,149.68 R1995.1 83.59,149.85 83.38,149.85 R2195.1
EDP_CPU_AUX#: length 111.2
  TOP w0.102: JCPU1.M27 v1(80.12,51.75)
  IN1 w0.089: 83.51,53.71 83.51,53.68 83.53,53.66 83.53,53.5 83.4,53.36 79.8,53.36 79.51,53.08 79.51,52.35 v1(80.12,51.75)
  IN1 w0.117: v1(84.62,150.28) 84.42,150.08 84.09,150.08 82.81,148.8 82.81,147 81.12,145.31 81.12,142.42 84.58,138.96 84.58,129.44 82.98,127.84 82.98,127.17 83.67,126.48 83.67,114.97 81.9,113.2 81.9,111.54 82.39,111.05 82.39,107.67 82.68,107.38 82.68,98.53 82.36,98.21 82.36,77.15 83.51,75.99 83.51,53.71
  BOTTOM w0.102: R2196.1 83.38,150.07 83.59,150.07 R1994.2 83.98,150.25 84.16,150.07 84.41,150.07 v1(84.62,150.28)
EDP_CPU_AUX#_C: length 3.4
  BOTTOM w0.102: C105.1 80.02,150.07 79.74,150.07 79.46,149.79 79.46,148.92 79.03,148.5 78.88,148.5 78.79,148.59 U23.3
EDP_CPU_AUX#_R: length 1.1
  BOTTOM w0.102: C105.2 81.61,150.06 81.78,150.06 R2196.2
EDP_CPU_AUX_C: length 3.4
  BOTTOM w0.102: C104.1 80.01,149.86 79.83,149.86 79.68,149.7 79.68,148.82 v3(79.45,148.59) 79.14,148.28 78.86,148.28 78.77,148.19 U23.4
EDP_CPU_AUX_R: length 1.1
  BOTTOM w0.102: C104.2 81.59,149.85 81.8,149.85 R2195.2
EDP_CPU_LANE_N0: length 118.6
  TOP w0.102: v1(72.12,53.75) JCPU1.P35
  IN1 w0.089: 81.21,50.13 81.2,50.13 81.18,50.14 81.12,50.14 81.1,50.16 78.87,50.16 78.53,50.5 78.53,50.88 78.17,51.24 73.79,51.24 72.51,52.52 72.51,54.08 72.45,54.13 72.24,54.13 72.12,54.01 v1(72.12,53.75)
  IN1 w0.117: 81.21,50.13 81.84,50.13 81.87,50.1 83.39,50.1 85.28,52 85.28,69.23 85.79,69.74 85.79,93.94 84.42,95.31 84.42,108.08 84.11,108.39 84.11,111.64 85.68,113.22 85.68,116.29 88.3,118.91 88.3,120.74 87.56,121.48 87.56,127.37 88.45,128.26 88.45,130.49 87.82,131.13 87.82,136.39 86.34,137.87 86.34,139.74 84.18,141.9 84.18,143.86 82.79,145.25 82.79,145.53 82.91,145.65 83.15,145.65 v1(83.35,145.45)
  BOTTOM w0.102: C101.2 82.93,145.66 83.14,145.66 v1(83.35,145.45)
EDP_CPU_LANE_N0_C: length 4.1
  BOTTOM w0.102: U23.8 78.77,146.59 78.86,146.68 79.14,146.68 79.16,146.67 79.65,146.67 80.04,146.28 80.04,146.09 80.49,145.64 v3(80.72,145.64) 81.36,145.64 C101.1
EDP_CPU_LANE_N1: length 118.7
  TOP w0.102: JCPU1.N34 v1(73.12,52.75)
  IN1 w0.089: 83.27,51.14 83.25,51.14 83.25,51.15 79.44,51.15 78.65,51.94 74.1,51.94 73.53,52.5 73.53,53.05 73.45,53.13 73.24,53.13 73.12,53.02 v1(73.12,52.75)
  IN1 w0.117: v1(82.71,143.65) 82.52,143.85 82.28,143.85 82.11,143.68 82.11,142.91 85.59,139.43 85.59,137.29 86.58,136.3 86.58,129.61 84.67,127.7 84.67,121.21 84.87,121.02 84.87,118.96 84.67,118.76 84.67,114.45 82.97,112.74 82.97,111.94 83.37,111.54 83.37,108.09 83.68,107.78 83.68,94.69 83.9,94.47 83.9,92.33 83.68,92.11 83.68,83.48 83.8,83.37 84.57,83.37 84.84,83.1 84.84,82.46 84.57,82.19 83.8,82.19 83.68,82.08 83.68,81.61 83.8,81.49 84.79,81.49 85.05,81.24 85.05,80.57 84.79,80.32 83.8,80.32 83.68,80.2 83.68,79.73 83.8,79.62 84.79,79.62 85.05,79.36 85.05,78.7 84.79,78.44 83.8,78.44 83.68,78.33 83.68,77.57 84.77,76.49 84.77,70.41 84.52,70.17 84.52,52.12 83.54,51.14 83.27,51.14
  BOTTOM w0.102: v1(82.71,143.65) 82.51,143.86 81.76,143.86 C118.2
EDP_CPU_LANE_N1_C: length 4
  BOTTOM w0.102: U23.10 78.77,145.79 78.88,145.9 79.24,145.9 79.57,145.56 v3(79.57,144.74) 79.57,144.29 79.98,143.89 80.2,143.89 C118.1
EDP_CPU_LANE_P0: length 118.6
  TOP w0.102: v1(72.12,54.75) JCPU1.R35
  IN1 w0.089: v1(72.12,54.75) 72.12,54.49 72.27,54.34 72.54,54.34 72.72,54.17 72.72,52.6 73.87,51.45 78.25,51.45 78.74,50.96 78.74,50.58 78.96,50.36 81.21,50.36
  IN1 w0.117: v1(83.35,146.09) 83.14,145.88 82.81,145.88 82.55,145.63 82.55,145.15 83.94,143.76 83.94,141.8 86.1,139.64 86.1,137.77 87.58,136.29 87.58,131.03 88.22,130.4 88.22,128.35 87.33,127.46 87.33,121.38 88.06,120.64 88.06,119.01 85.45,116.39 85.45,113.32 83.87,111.74 83.87,108.29 84.18,107.98 84.18,95.21 85.56,93.84 85.56,69.84 85.05,69.33 85.05,52.09 83.29,50.34 81.97,50.34 81.94,50.36 81.21,50.36
  BOTTOM w0.102: C100.2 82.93,145.88 83.14,145.88 v1(83.35,146.09)
EDP_CPU_LANE_P0_C: length 4.1
  BOTTOM w0.102: C100.1 81.33,145.86 81.05,145.86 81.03,145.87 80.56,145.87 80.26,146.17 80.26,146.37 79.73,146.9 v3(79.49,146.9) 78.88,146.9 78.79,146.99 U23.7
EDP_CPU_LANE_P1: length 118.7
  TOP w0.102: v1(73.12,53.75) JCPU1.P34
  IN1 w0.089: 83.27,51.38 83.25,51.38 83.22,51.36 79.52,51.36 78.74,52.14 74.18,52.14 73.74,52.58 73.74,53.13 73.53,53.34 73.25,53.34 73.12,53.47 v1(73.12,53.75)
  IN1 w0.117: 83.27,51.38 83.45,51.38 84.29,52.22 84.29,70.27 84.53,70.51 84.53,76.39 83.45,77.48 83.45,78.43 83.7,78.68 84.69,78.68 84.81,78.8 84.81,79.26 84.69,79.38 83.7,79.38 83.45,79.64 83.45,80.3 83.7,80.55 84.69,80.55 84.81,80.67 84.81,81.14 84.69,81.26 83.7,81.26 83.45,81.51 83.45,82.17 83.7,82.43 84.48,82.43 84.6,82.56 84.6,83 84.48,83.13 83.7,83.13 83.45,83.39 83.45,92.21 83.67,92.43 83.67,94.38 83.45,94.6 83.45,107.68 83.14,107.99 83.14,111.44 82.74,111.84 82.74,112.84 84.44,114.54 84.44,118.86 84.63,119.06 84.63,120.92 84.44,121.11 84.44,127.8 86.34,129.71 86.34,136.21 85.36,137.19 85.36,139.33 81.87,142.81 81.87,143.77 82.18,144.08 82.52,144.08 v1(82.71,144.28)
  BOTTOM w0.102: v1(82.71,144.28) 82.51,144.07 81.82,144.07 C103.2
EDP_CPU_LANE_P1_C: length 4
  BOTTOM w0.102: C103.1 80.21,144.1 80.07,144.1 79.79,144.38 79.79,144.46 79.8,144.47 79.8,145.01 79.79,145.02 79.79,145.65 79.33,146.11 78.85,146.11 78.77,146.19 U23.9
EDP_DET#: length 4.8
  BOTTOM w0.102: U46.A44 219.67,88.7 R19.2 220.15,89.99 220.65,90.49 R29.1
EDP_HPD#: length 24.3
  TOP w0.102: JCPU1.P27 v1(80.12,53.75)
  BOTTOM w0.102: v1(80.12,53.75) 79.61,53.24 79.61,52.49 78.62,51.5 78.62,47.56 78.51,47.45 78.51,46.59 78.19,46.26 71.92,46.26 v2(70.32,44.66) 69.35,43.7 QC6.1 66.2,42.71 RC65.1
EN_1.5VSP: length 6.2
  BOTTOM w0.102: v2(263.28,37.96) 262.47,37.15 PR404.1
  BOTTOM w0.254: PR404.1 262.39,36.66 PR403.2 PR406.2 260.56,36.61 PC406.1 260.56,35.57 259.67,34.68 PU400.5
EN_+1.05VSP: length 5.1
  TOP w0.254: v1(21.48,147.98) 21.48,148.06 21.04,148.5 v2(20.61,148.5) 20.35,148.25 20.35,147.74 20.48,147.61 PC307.1 PR315.1 PR303.2
  BOTTOM w0.254: PU300.3 v1(21.48,147.98)
EN_DK_PWRBAR: length 3.4
  BOTTOM w0.254: PR1028.1 146.42,122.97 PR1027.1 v2(147.43,122.05) 147.81,122.05 148.08,121.78 PU1001.17
EN_DOCK_PWR_BAR: length 89.8
  IN3 w0.127: v1(215.5,84.62) 215.34,84.78 212.8,84.78 210.9,86.68 199.45,86.68 192.49,93.64 180.02,93.64 174.18,99.48 169.95,99.48 159.62,109.8 158.39,109.8 156.76,111.43 155.91,111.43 152.75,114.59 151.05,114.59 146.55,119.08 146.55,120.27 v1(144.76,122.06)
  BOTTOM w0.102: U46.B37 214.92,85.63 215.05,85.51 215.05,84.97 215.4,84.62 v1(215.5,84.62) ; PR1027.2 144.77,122.05 v1(144.76,122.06) 144.76,121.85 v2(144.48,121.58)
EN_I2S_NB_CODEC#: length 227.7
  TOP w0.102: v1(14.28,93.38) 14.06,93.6 JIO1.60 ; v1(200.82,92.72) 200.94,92.61 210.46,92.61 213.5,89.57 213.5,87.03 214.64,85.89 v1(214.64,85.23)
  IN2 w0.127: v1(200.82,92.72) 200.82,93.57 199.02,95.36 189.31,95.36 182.72,101.95 179.22,101.95 178.96,101.7 141.12,101.7 138.69,104.13 132.77,104.13 128.65,100 122.16,100 121.16,98.99 120.24,98.99 119.57,99.67 115.24,99.67 115.01,99.9 86.85,99.9 86.38,99.43 83.49,99.43 82.01,97.95 82.01,97.59 81.15,96.72 80.24,96.72 79.28,95.77 75.83,95.77 71.33,91.27 69.87,91.27 65.45,86.85 61.98,86.85 60.96,87.87 57.93,87.87 57.04,86.98 47.36,86.98 45.64,85.27 40.52,85.27 40.41,85.15 36.07,85.15 34.79,86.43 31.44,86.43 30.77,85.76 28.72,85.76 28.05,86.43 25.53,86.43 25.09,85.99 21.09,85.99 18.21,88.87 18.21,89.7 16.51,91.4 15.63,91.4 14.36,92.67 14.36,93.3 v1(14.28,93.38)
  BOTTOM w0.102: v1(214.64,85.23) 214.42,85.45 U46.B36
EN_INVPWR: length 90.9
  TOP w0.102: v1(70.65,155.38) v2(69.88,156.14) 69.12,156.91 57.93,156.91 57.32,156.3 50.07,156.3 49.06,155.28 48.7,155.28 v1(48.68,155.31)
  IN2 w0.127: v1(103.23,150.33) 104.38,151.47 107.07,151.47 108.14,152.54 108.14,153.96 107.22,154.87 107.02,154.87 106.46,155.43 106.46,156.58 102.88,160.17 102.88,160.51 102.42,160.97 99.09,160.97 97.37,159.24 96.42,159.24 90.25,153.07 72.96,153.07 v1(70.65,155.38)
  IN3 w0.127: v1(103.23,150.33) 103.23,149.64 104.62,148.26 107.83,148.26 108.13,147.97 108.87,147.97 109.41,148.5 v1(109.41,149.26)
  BOTTOM w0.102: v1(109.41,149.26) 110.66,149.26 111.68,148.25 RP7.6 ; U51.A25 103.5,150.59 v1(103.23,150.33) ; Q22.2 49.94,155.15 48.83,155.15 v1(48.68,155.31)
EN_LCDPWR: length 10.2
  BOTTOM w0.102: D53.1 42.23,144.72 43.5,146 D6.1 45.79,146 R431.1 46.52,146.04 v2(46.52,147.05) 46.71,147.24 46.71,150.24 46.94,150.47 U62.3
ENVDD_PCH: length 225.9
  TOP w0.102: UH1.G36 27.16,104.54 27.42,104.8 v1(27.45,104.8)
  IN2 w0.127: v1(51.8,112.82) 51.7,112.82 51.66,112.79 48.88,112.79 46.87,114.79 42.86,114.79 41.21,113.14 38.13,113.14 37.88,113.4 37.88,114.86 37.92,114.9 37.92,115.69 v1(37.65,115.96) ; v1(215.48,85.2) 215.02,85.66 212.7,85.66 206.48,91.88 204.82,91.88 199.71,96.99 197.89,96.99 195.27,99.6 188.33,99.6 181.94,105.99 177.55,105.99 175.48,108.06 158.33,108.06 156.71,106.44 130.65,106.44 129.7,105.48 116.89,105.48 115.27,107.1 85.05,107.1 83.89,105.94 80.94,105.94 80.24,105.24 76.04,105.24 v1(75.17,106.11)
  IN4 w0.109: v1(27.45,104.8) 27.41,104.84 27.41,105.47 27.54,105.6 27.54,106.31 27.29,106.56 27.29,107.2 28.18,108.09 28.18,109.33 29.77,110.92 34.49,110.92 35.18,111.61 36.59,111.61 37.88,112.9 37.88,114.87 37.91,114.9 37.91,115.24 37.65,115.5 v1(37.65,115.96)
  BOTTOM w0.102: v1(27.45,104.8) 27,104.35 26.48,104.35 RH118.2 ; v1(215.48,85.2) 215.48,85.23 215.42,85.29 U46.B38 ; v1(51.8,112.82) 51.82,112.85 52.09,112.85 53.12,113.88 62.59,113.88 64.52,111.95 64.52,111.49 63.31,110.27 63.31,105.97 63.63,105.65 v2(65.59,105.65) 74.71,105.65 v1(75.17,106.11)
EQ_A: length 1.7
  BOTTOM w0.102: R551.1 216.87,61.43 U637.19
EQ_B: length 1.8
  BOTTOM w0.102: U637.18 217.37,62.18 217.79,61.76 R564.1
ERC1: length 2.7
  BOTTOM w0.254: PC1007.1 153.18,115.63 152.7,116.11 PU1001.3
ERC2: length 4.7
  BOTTOM w0.102: v2(144.51,119.78) 145.92,119.78 PC1009.1
  BOTTOM w0.254: PC1009.1 146.92,119.29 147.38,119.75 148.2,119.75 148.23,119.78 PU1001.13
ERC3: length 5.4
  BOTTOM w0.102: PC1008.1 146.06,117.49 v2(144.22,117.49)
  BOTTOM w0.254: 147.6,119.17 147.71,119.28 PU1001.12
  BOTTOM w0.508: 147.6,119.17 146.72,118.29 PC1008.1
ESATA_PRX_DTX_N3_C: length 128.5
  TOP w0.102: C673.1 43.36,165.63 43.36,164.6 40.52,161.75 40.22,161.75 v1(40.01,161.96) ; v1(46.62,93.35) 46.8,93.53 46.8,93.84 46.54,94.09 45.83,94.09 45.59,94.33 43.58,94.33 43.57,94.32 43.13,94.32 42.92,94.52 42.45,94.52 UH1.BC12
  IN4 w0.117: v1(40.01,161.96) 40.21,161.77 40.52,161.77 40.88,161.41 40.88,158.99 40.21,158.32 40.21,155.47 40.31,155.37 40.31,148.31 38.52,146.52 34.74,146.52 26.98,138.76 26.98,135.16 26.58,134.77 26.58,133.83 26.15,133.4 26.15,130.39 22.13,126.37 22.13,123.28 20.63,121.78 20.63,120.53 19.11,119.01 19.11,118.37 18.36,117.62 18.36,116.83 16.14,114.61 16.14,107.17 15.07,106.1 15.07,105.04 15.41,104.71 15.41,102.19 16.75,100.85 16.75,99.88 18.03,98.61 18.51,98.61 19.74,97.37 19.74,97.37 20.82,96.29 21.23,96.29 21.33,96.39 23.14,96.39 24.39,95.14 24.39,90.41 25.36,89.44 25.36,89.32 26.4,88.28 29.17,88.28 29.73,87.71 33.76,87.71 35.62,89.57 39.35,89.57 39.86,90.08 42.12,90.08 44.53,92.49 44.53,92.55 44.87,92.88 46.67,92.88 46.81,93.02 46.81,93.16 v1(46.62,93.35)
ESATA_PRX_DTX_P3_C: length 128.6
  TOP w0.102: C674.1 43.58,165.63 43.58,164.51 40.61,161.54 40.23,161.54 v1(40.01,161.33) ; UH1.BE12 43.35,94.53 43.48,94.53 43.49,94.55 45.68,94.55 45.92,94.31 46.63,94.31 47.01,93.93 47.01,93.55 v1(47.2,93.35)
  IN4 w0.117: v1(40.01,161.33) 40.22,161.53 40.42,161.53 40.64,161.31 40.64,159.09 39.97,158.42 39.97,155.37 40.08,155.27 40.08,148.41 38.42,146.75 34.64,146.75 26.74,138.86 26.74,135.26 26.35,134.86 26.35,133.93 25.92,133.49 25.92,130.48 21.9,126.46 21.9,123.37 20.4,121.88 20.4,120.63 18.87,119.11 18.87,118.47 18.12,117.72 18.12,116.93 15.9,114.71 15.9,107.27 14.83,106.2 14.83,104.95 15.17,104.61 15.17,102.09 16.52,100.75 16.52,99.78 17.93,98.37 18.41,98.37 19.51,97.28 19.51,97.27 20.72,96.06 21.33,96.06 21.43,96.16 23.04,96.16 24.16,95.04 24.16,90.31 25.12,89.35 25.12,89.22 26.3,88.04 29.07,88.04 29.64,87.47 33.86,87.47 35.72,89.33 39.45,89.33 39.96,89.84 42.22,89.84 44.77,92.39 44.77,92.45 44.97,92.64 46.77,92.64 47.05,92.92 47.05,93.2 v1(47.2,93.35)
ESATA_PTX_DRX_N3_C: length 115.7
  TOP w0.102: C672.1 40.68,166.03 40.45,165.79 40.45,163.33 40.55,163.23 v1(40.8,163.23) ; v1(39.21,94.37) 39.21,94.6 UH1.AR13
  IN4 w0.089: 38.99,91.53 38.99,91.55 39.02,91.58 39.02,93.53 39.53,94.04 39.53,94.22 39.38,94.37 v1(39.21,94.37)
  IN4 w0.117: v1(40.8,163.23) 40.55,163.23 40.45,163.13 40.45,162.88 41.06,162.27 41.72,162.27 42.54,161.45 42.54,159.96 41.66,159.09 41.66,148.63 38.81,145.77 35.03,145.77 27.71,138.45 27.71,134.86 27.32,134.46 27.32,133.52 26.89,133.09 26.89,130.08 22.87,126.06 22.87,122.95 21.37,121.45 21.37,120.23 19.87,118.73 19.87,118.1 19.09,117.32 19.09,116.43 18.47,115.81 18.47,115.38 16.87,113.78 16.87,106.25 16.15,105.53 16.15,102.59 17.69,101.05 17.69,99.99 18.19,99.48 20.42,99.48 22.39,97.52 24.01,97.52 24.37,97.16 24.37,96.22 25.21,95.39 25.21,90.66 25.93,89.93 33.52,89.93 34.2,90.61 38.64,90.61 38.99,90.96 38.99,91.53
ESATA_PTX_DRX_P3_C: length 115.7
  TOP w0.102: v1(39.89,94.37) 39.53,94.72 39.53,94.88 ; v1(40.04,163.23) 40.23,163.42 40.23,165.71 C671.1
  IN4 w0.089: v1(39.89,94.37) 39.71,94.19 39.71,93.97 39.2,93.46 39.2,91.57 39.23,91.54 39.23,91.53
  IN4 w0.117: 39.23,91.53 39.23,90.87 38.74,90.38 34.3,90.38 33.62,89.7 25.84,89.7 24.97,90.57 24.97,95.29 24.14,96.12 24.14,97.06 23.91,97.29 22.29,97.29 20.32,99.25 18.09,99.25 17.45,99.89 17.45,100.95 15.91,102.49 15.91,105.62 16.64,106.35 16.64,113.88 18.24,115.48 18.24,115.91 18.86,116.52 18.86,117.41 19.64,118.19 19.64,118.83 21.13,120.33 21.13,121.55 22.63,123.04 22.63,126.16 26.65,130.18 26.65,133.19 27.08,133.62 27.08,134.56 27.48,134.95 27.48,138.55 34.93,146.01 38.71,146.01 41.43,148.72 41.43,159.19 42.3,160.06 42.3,161.35 41.62,162.03 40.96,162.03 40.21,162.78 40.21,163.06 v1(40.04,163.23)
ESATA_USB_PWR_EN#: length 219.9
  TOP w0.102: U48.4 U48.5 70.54,163.03 v2(70.73,163.22) 70.76,163.24 v1(70.76,165.06)
  IN1 w0.109: v1(70.76,165.06) 71.97,166.27 88.23,166.27 89.44,165.06 93.38,165.06 101.58,173.27 111.36,173.27 114.2,170.42 116.92,170.42 117.84,169.5 120.64,169.5 123.1,167.04 123.1,165.96 126.31,162.75 128.04,162.75 128.82,161.97 134.47,161.97 137.45,158.99 141.03,158.99 146.81,153.21 147.53,153.21 151.23,149.51 151.23,143.29 155.03,139.49 155.03,137.62 159.26,133.39 160.78,133.39 161.08,133.69 165.34,133.69 167.53,131.49 167.53,129.96 170.18,127.31 170.18,122.13 172.37,119.95 172.37,112.07 175.81,108.62 176.66,108.62 186.14,99.14 192.88,99.14 197.77,94.24 197.77,91.43 202.25,86.95 210.96,86.95 212.03,85.88 217.64,85.88 218.14,85.38 218.14,85.05 v1(217.71,84.62)
  IN3 w0.127: v1(217.71,84.62) 217.71,84.59 219.19,83.12 220.73,83.12 220.84,83.22 222,83.22 223.25,84.47 224.93,84.47 v1(225.18,84.72)
  BOTTOM w0.102: v1(225.18,84.72) 225.14,84.68 RP1.8 ; v1(217.71,84.62) 217.84,84.62 218.37,85.15 218.37,85.54 218.42,85.58 U46.B44
EXPCLK_REQ#: length 51.6
  TOP w0.102: UH1.V3 32.01,90.59 32.01,90.12 32.22,89.91 32.22,89.57 32.19,89.54 32.19,88.24 30.25,86.31 29.92,86.31 v2(29.58,85.97) 29.04,85.43 29.04,82.46 RH125.1 29.5,81.54 v1(29.7,81.34) ; JIO1.41 v1(6.23,99)
  IN3 w0.127: v1(29.7,81.34) 28.96,82.08 13.39,82.08 7.39,88.07 5.93,88.07 4.56,89.44 4.56,90.43 4.68,90.56 4.68,96.55 6.23,98.09 v1(6.23,99)
FAN1_PWM: length 153
  IN2 w0.127: v1(104.48,149.72) 104.07,150.12 104.07,150.58 104.68,151.19 109.48,151.19 111.25,152.96 111.25,156.39 109.48,158.15 109.48,159.74 108.14,161.08 104.84,161.08 104.44,161.48 98.43,161.48 97.82,160.87 95.54,160.87 93.2,158.53 93.2,156.74 91.69,155.23 88.66,155.23 88.03,155.87 81.95,155.87 80.96,154.88 80.17,154.88 79.29,155.76 77.83,155.76 77.53,156.07 68.94,156.07 68.31,155.44 68.31,152.89 68.72,152.48 68.72,149.09 65.76,146.14 61.15,146.14 57.78,142.77 57.78,142.52 55.08,139.81 55.08,137.08 52.99,134.99 49.55,134.99 48.71,135.82 44.76,135.82 39.45,130.52 v1(39.45,128.27)
  IN3 w0.127: v1(39.45,128.27) 37.25,130.47 27.29,130.47 20.91,124.09 18.45,124.09 15.5,127.04 15.5,128.99 14.72,129.77 v1(14.72,129.77)
  IN4 w0.109: v1(104.48,149.72) 105.57,148.63 106.74,148.63 108.29,147.08 v1(108.29,146.77)
  BOTTOM w0.102: v1(108.29,146.77) 108.34,146.72 R407.2 ; v1(104.48,149.72) 104,150.2 U51.A24 ; JFAN1.2 v1(14.72,129.77) 15.09,130.15 15.09,130.17 v2(15.22,130.3)
FAN1_TACH_FB: length 130.3
  IN2 w0.127: v1(46.22,130.67) 46.22,131.56 47.42,132.75 65.78,132.75 73.69,140.66 73.69,141 74.54,141.84 74.62,141.84 76.67,143.89 78.6,143.89 78.76,143.74 79.3,143.74 80.24,142.8 85.66,142.8 86.37,143.51 86.92,143.51 90.33,146.92 90.33,147.4 90.84,147.91 90.84,153.23 93.65,156.04 94.53,156.04 94.81,156.33 94.81,156.92 96.27,158.37 97.99,158.37 99.39,159.76 100.75,159.76 101.45,159.07 101.96,159.07 104.66,156.37 104.66,154.92 105.27,154.31 105.27,153.12 v1(105.77,152.61)
  IN3 w0.127: v1(14.66,129.17) 14.21,129.63 14.21,130.74 14.46,131 14.97,131 19.19,126.78 22.84,126.78 27.16,131.1 42.74,131.1 43.02,131.38 45.51,131.38 v1(46.22,130.67)
  IN4 w0.109: v1(108.4,148.42) 107.9,148.93 105.77,148.93 105.52,149.18 105.52,152.36 v1(105.77,152.61)
  BOTTOM w0.102: v2(15.38,128.53) 14.74,129.17 v1(14.66,129.17) 14.02,128.52 JFAN1.3 ; v1(105.77,152.61) 105.77,152.52 105.75,152.49 U51.B22 ; v1(108.4,148.42) 108.4,147.9 108.63,147.67 R408.2
FAN2_PWM: length 15.9
  TOP w0.102: v2(170.4,139.71) 170.85,139.27 v1(170.85,139.1)
  TOP w0.254: v1(165.25,131.24) 166.02,132.01 U29.15 ; v1(170.85,139.1) 171.48,139.73 D90.1
  BOTTOM w0.254: v1(165.25,131.24) 165.44,131.43 165.44,132.4 167.17,134.12 167.17,138.75 168.03,139.61 170.34,139.61 v1(170.85,139.1)
